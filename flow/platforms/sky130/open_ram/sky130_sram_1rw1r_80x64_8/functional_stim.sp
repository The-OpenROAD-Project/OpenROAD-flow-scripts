* Functional test stimulus file for 10ns period

* TT process corner
.lib "/afs/eecs.umich.edu/vlsida/projects/restricted/google/sky130_fd_bd_sram/third_party/sky130_fd_pr/models/sky130.lib.spice" tt
.include "sky130_sram_1rw1r_80x64_8.sp"

* Global Power Supplies
Vvdd vdd 0 1.8

*Nodes gnd and 0 are the same global ground node in ngspice/hspice/xa. Otherwise, this source may be needed.
*Vgnd gnd 0 0.0

* Instantiation of the SRAM
Xsky130_sram_1rw1r_80x64_8 din0_0 din0_1 din0_2 din0_3 din0_4 din0_5 din0_6 din0_7 din0_8 din0_9 din0_10 din0_11 din0_12 din0_13 din0_14 din0_15 din0_16 din0_17 din0_18 din0_19 din0_20 din0_21 din0_22 din0_23 din0_24 din0_25 din0_26 din0_27 din0_28 din0_29 din0_30 din0_31 din0_32 din0_33 din0_34 din0_35 din0_36 din0_37 din0_38 din0_39 din0_40 din0_41 din0_42 din0_43 din0_44 din0_45 din0_46 din0_47 din0_48 din0_49 din0_50 din0_51 din0_52 din0_53 din0_54 din0_55 din0_56 din0_57 din0_58 din0_59 din0_60 din0_61 din0_62 din0_63 din0_64 din0_65 din0_66 din0_67 din0_68 din0_69 din0_70 din0_71 din0_72 din0_73 din0_74 din0_75 din0_76 din0_77 din0_78 din0_79 a0_0 a0_1 a0_2 a0_3 a0_4 a0_5 a1_0 a1_1 a1_2 a1_3 a1_4 a1_5 CSB0 CSB1 WEB0 clk0 clk1 WMASK0_0 WMASK0_1 WMASK0_2 WMASK0_3 WMASK0_4 WMASK0_5 WMASK0_6 WMASK0_7 WMASK0_8 WMASK0_9 dout0_0 dout0_1 dout0_2 dout0_3 dout0_4 dout0_5 dout0_6 dout0_7 dout0_8 dout0_9 dout0_10 dout0_11 dout0_12 dout0_13 dout0_14 dout0_15 dout0_16 dout0_17 dout0_18 dout0_19 dout0_20 dout0_21 dout0_22 dout0_23 dout0_24 dout0_25 dout0_26 dout0_27 dout0_28 dout0_29 dout0_30 dout0_31 dout0_32 dout0_33 dout0_34 dout0_35 dout0_36 dout0_37 dout0_38 dout0_39 dout0_40 dout0_41 dout0_42 dout0_43 dout0_44 dout0_45 dout0_46 dout0_47 dout0_48 dout0_49 dout0_50 dout0_51 dout0_52 dout0_53 dout0_54 dout0_55 dout0_56 dout0_57 dout0_58 dout0_59 dout0_60 dout0_61 dout0_62 dout0_63 dout0_64 dout0_65 dout0_66 dout0_67 dout0_68 dout0_69 dout0_70 dout0_71 dout0_72 dout0_73 dout0_74 dout0_75 dout0_76 dout0_77 dout0_78 dout0_79 dout1_0 dout1_1 dout1_2 dout1_3 dout1_4 dout1_5 dout1_6 dout1_7 dout1_8 dout1_9 dout1_10 dout1_11 dout1_12 dout1_13 dout1_14 dout1_15 dout1_16 dout1_17 dout1_18 dout1_19 dout1_20 dout1_21 dout1_22 dout1_23 dout1_24 dout1_25 dout1_26 dout1_27 dout1_28 dout1_29 dout1_30 dout1_31 dout1_32 dout1_33 dout1_34 dout1_35 dout1_36 dout1_37 dout1_38 dout1_39 dout1_40 dout1_41 dout1_42 dout1_43 dout1_44 dout1_45 dout1_46 dout1_47 dout1_48 dout1_49 dout1_50 dout1_51 dout1_52 dout1_53 dout1_54 dout1_55 dout1_56 dout1_57 dout1_58 dout1_59 dout1_60 dout1_61 dout1_62 dout1_63 dout1_64 dout1_65 dout1_66 dout1_67 dout1_68 dout1_69 dout1_70 dout1_71 dout1_72 dout1_73 dout1_74 dout1_75 dout1_76 dout1_77 dout1_78 dout1_79 vdd gnd sky130_sram_1rw1r_80x64_8

* SRAM output loads
CD00 dout0_0  0 27.56f
CD01 dout0_1  0 27.56f
CD02 dout0_2  0 27.56f
CD03 dout0_3  0 27.56f
CD04 dout0_4  0 27.56f
CD05 dout0_5  0 27.56f
CD06 dout0_6  0 27.56f
CD07 dout0_7  0 27.56f
CD08 dout0_8  0 27.56f
CD09 dout0_9  0 27.56f
CD010 dout0_10  0 27.56f
CD011 dout0_11  0 27.56f
CD012 dout0_12  0 27.56f
CD013 dout0_13  0 27.56f
CD014 dout0_14  0 27.56f
CD015 dout0_15  0 27.56f
CD016 dout0_16  0 27.56f
CD017 dout0_17  0 27.56f
CD018 dout0_18  0 27.56f
CD019 dout0_19  0 27.56f
CD020 dout0_20  0 27.56f
CD021 dout0_21  0 27.56f
CD022 dout0_22  0 27.56f
CD023 dout0_23  0 27.56f
CD024 dout0_24  0 27.56f
CD025 dout0_25  0 27.56f
CD026 dout0_26  0 27.56f
CD027 dout0_27  0 27.56f
CD028 dout0_28  0 27.56f
CD029 dout0_29  0 27.56f
CD030 dout0_30  0 27.56f
CD031 dout0_31  0 27.56f
CD032 dout0_32  0 27.56f
CD033 dout0_33  0 27.56f
CD034 dout0_34  0 27.56f
CD035 dout0_35  0 27.56f
CD036 dout0_36  0 27.56f
CD037 dout0_37  0 27.56f
CD038 dout0_38  0 27.56f
CD039 dout0_39  0 27.56f
CD040 dout0_40  0 27.56f
CD041 dout0_41  0 27.56f
CD042 dout0_42  0 27.56f
CD043 dout0_43  0 27.56f
CD044 dout0_44  0 27.56f
CD045 dout0_45  0 27.56f
CD046 dout0_46  0 27.56f
CD047 dout0_47  0 27.56f
CD048 dout0_48  0 27.56f
CD049 dout0_49  0 27.56f
CD050 dout0_50  0 27.56f
CD051 dout0_51  0 27.56f
CD052 dout0_52  0 27.56f
CD053 dout0_53  0 27.56f
CD054 dout0_54  0 27.56f
CD055 dout0_55  0 27.56f
CD056 dout0_56  0 27.56f
CD057 dout0_57  0 27.56f
CD058 dout0_58  0 27.56f
CD059 dout0_59  0 27.56f
CD060 dout0_60  0 27.56f
CD061 dout0_61  0 27.56f
CD062 dout0_62  0 27.56f
CD063 dout0_63  0 27.56f
CD064 dout0_64  0 27.56f
CD065 dout0_65  0 27.56f
CD066 dout0_66  0 27.56f
CD067 dout0_67  0 27.56f
CD068 dout0_68  0 27.56f
CD069 dout0_69  0 27.56f
CD070 dout0_70  0 27.56f
CD071 dout0_71  0 27.56f
CD072 dout0_72  0 27.56f
CD073 dout0_73  0 27.56f
CD074 dout0_74  0 27.56f
CD075 dout0_75  0 27.56f
CD076 dout0_76  0 27.56f
CD077 dout0_77  0 27.56f
CD078 dout0_78  0 27.56f
CD079 dout0_79  0 27.56f
CD10 dout1_0  0 27.56f
CD11 dout1_1  0 27.56f
CD12 dout1_2  0 27.56f
CD13 dout1_3  0 27.56f
CD14 dout1_4  0 27.56f
CD15 dout1_5  0 27.56f
CD16 dout1_6  0 27.56f
CD17 dout1_7  0 27.56f
CD18 dout1_8  0 27.56f
CD19 dout1_9  0 27.56f
CD110 dout1_10  0 27.56f
CD111 dout1_11  0 27.56f
CD112 dout1_12  0 27.56f
CD113 dout1_13  0 27.56f
CD114 dout1_14  0 27.56f
CD115 dout1_15  0 27.56f
CD116 dout1_16  0 27.56f
CD117 dout1_17  0 27.56f
CD118 dout1_18  0 27.56f
CD119 dout1_19  0 27.56f
CD120 dout1_20  0 27.56f
CD121 dout1_21  0 27.56f
CD122 dout1_22  0 27.56f
CD123 dout1_23  0 27.56f
CD124 dout1_24  0 27.56f
CD125 dout1_25  0 27.56f
CD126 dout1_26  0 27.56f
CD127 dout1_27  0 27.56f
CD128 dout1_28  0 27.56f
CD129 dout1_29  0 27.56f
CD130 dout1_30  0 27.56f
CD131 dout1_31  0 27.56f
CD132 dout1_32  0 27.56f
CD133 dout1_33  0 27.56f
CD134 dout1_34  0 27.56f
CD135 dout1_35  0 27.56f
CD136 dout1_36  0 27.56f
CD137 dout1_37  0 27.56f
CD138 dout1_38  0 27.56f
CD139 dout1_39  0 27.56f
CD140 dout1_40  0 27.56f
CD141 dout1_41  0 27.56f
CD142 dout1_42  0 27.56f
CD143 dout1_43  0 27.56f
CD144 dout1_44  0 27.56f
CD145 dout1_45  0 27.56f
CD146 dout1_46  0 27.56f
CD147 dout1_47  0 27.56f
CD148 dout1_48  0 27.56f
CD149 dout1_49  0 27.56f
CD150 dout1_50  0 27.56f
CD151 dout1_51  0 27.56f
CD152 dout1_52  0 27.56f
CD153 dout1_53  0 27.56f
CD154 dout1_54  0 27.56f
CD155 dout1_55  0 27.56f
CD156 dout1_56  0 27.56f
CD157 dout1_57  0 27.56f
CD158 dout1_58  0 27.56f
CD159 dout1_59  0 27.56f
CD160 dout1_60  0 27.56f
CD161 dout1_61  0 27.56f
CD162 dout1_62  0 27.56f
CD163 dout1_63  0 27.56f
CD164 dout1_64  0 27.56f
CD165 dout1_65  0 27.56f
CD166 dout1_66  0 27.56f
CD167 dout1_67  0 27.56f
CD168 dout1_68  0 27.56f
CD169 dout1_69  0 27.56f
CD170 dout1_70  0 27.56f
CD171 dout1_71  0 27.56f
CD172 dout1_72  0 27.56f
CD173 dout1_73  0 27.56f
CD174 dout1_74  0 27.56f
CD175 dout1_75  0 27.56f
CD176 dout1_76  0 27.56f
CD177 dout1_77  0 27.56f
CD178 dout1_78  0 27.56f
CD179 dout1_79  0 27.56f

* Important signals for debug
* bl: xsky130_sram_1rw1r_80x64_8.xbank0.bl_0_0
* br: xsky130_sram_1rw1r_80x64_8.xbank0.br_0_0
* s_en: xsky130_sram_1rw1r_80x64_8.s_en
* q: xsky130_sram_1rw1r_80x64_8.xbank0.xbitcell_array.xla_0.xarray.xbitcell_array.xbit_r0_c0.Q
* qbar: xsky130_sram_1rw1r_80x64_8.xbank0.xbitcell_array.xla_0.xarray.xbitcell_array.xbit_r0_c0.Q_bar

* Sequence of operations
*	Idle during cycle 0 (0ns - 10ns)
*	Writing 00000101011001000000010110101110111000101111101001011100110000011001011011101100  to  address 110110 (from port 0) during cycle 1 (10ns - 20ns)
*	Reading 00000101011001000000010110101110111000101111101001011100110000011001011011101100 from address 110110 (from port 1) during cycle 2 (20ns - 30ns)
*	Reading 00000101011001000000010110101110111000101111101001011100110000011001011011101100 from address 110110 (from port 0) during cycle 3 (30ns - 40ns)
*	Reading 00000101011001000000010110101110111000101111101001011100110000011001011011101100 from address 110110 (from port 1) during cycle 3 (30ns - 40ns)
*	Writing 11010101001111110001100110110111001101010110000001101111001110001010010010011001  to  address 111110 (from port 0) during cycle 4 (40ns - 50ns)
*	Writing (partial) 10000001001010110010110011000000110111111000110101011001100000100100110111001101  to  address 111110 with mask bit 1001000100 (from port 0) during cycle 5 (50ns - 60ns)
*	Writing (partial) 00011110001111100110111100101111100010011011000111011011001111101101000000001011  to  address 111110 with mask bit 0001000001 (from port 0) during cycle 6 (60ns - 70ns)
*	Reading 10000001001111110001100100101111001101010110000001101111100000101010010000001011 from address 111110 (from port 1) during cycle 7 (70ns - 80ns)
*	Writing (partial) 00011100011111100101010111001111100011000101001101111010010010001101011011110000  to  address 110110 with mask bit 0010111111 (from port 0) during cycle 9 (90ns - 100ns)
*	Reading 00000101011001000101010110101110100011000101001101111010010010001101011011110000 from address 110110 (from port 1) during cycle 10 (100ns - 110ns)
*	Writing (partial) 01011010101111001000001100011000110111011010000110100110110011100011110101101110  to  address 111110 with mask bit 1111101100 (from port 0) during cycle 11 (110ns - 120ns)
*	Reading 00000101011001000101010110101110100011000101001101111010010010001101011011110000 from address 110110 (from port 1) during cycle 11 (110ns - 120ns)
*	Reading 00000101011001000101010110101110100011000101001101111010010010001101011011110000 from address 110110 (from port 0) during cycle 13 (130ns - 140ns)
*	Reading 01011010101111001000001100011000110111010110000010100110110011101010010000001011 from address 111110 (from port 1) during cycle 13 (130ns - 140ns)
*	Writing 10101000111001000011100110100111011010011010111101100001110110011000001111011001  to  address 101110 (from port 0) during cycle 14 (140ns - 150ns)
*	Reading 00000101011001000101010110101110100011000101001101111010010010001101011011110000 from address 110110 (from port 1) during cycle 14 (140ns - 150ns)
*	Reading 10101000111001000011100110100111011010011010111101100001110110011000001111011001 from address 101110 (from port 0) during cycle 15 (150ns - 160ns)
*	Reading 00000101011001000101010110101110100011000101001101111010010010001101011011110000 from address 110110 (from port 1) during cycle 15 (150ns - 160ns)
*	Reading 01011010101111001000001100011000110111010110000010100110110011101010010000001011 from address 111110 (from port 1) during cycle 17 (170ns - 180ns)
*	Reading 10101000111001000011100110100111011010011010111101100001110110011000001111011001 from address 101110 (from port 0) during cycle 18 (180ns - 190ns)
*	Reading 10101000111001000011100110100111011010011010111101100001110110011000001111011001 from address 101110 (from port 1) during cycle 18 (180ns - 190ns)
*	Reading 00000101011001000101010110101110100011000101001101111010010010001101011011110000 from address 110110 (from port 0) during cycle 19 (190ns - 200ns)
*	Writing (partial) 10100110010000001000011100100110101110101100001011100110101011111001010110001001  to  address 111110 with mask bit 1001110010 (from port 0) during cycle 20 (200ns - 210ns)
*	Reading 10100110101111001000001100100110101110101100001010100110110011101001010100001011 from address 111110 (from port 0) during cycle 22 (220ns - 230ns)
*	Reading 00000101011001000101010110101110100011000101001101111010010010001101011011110000 from address 110110 (from port 1) during cycle 22 (220ns - 230ns)
*	Reading 10100110101111001000001100100110101110101100001010100110110011101001010100001011 from address 111110 (from port 0) during cycle 23 (230ns - 240ns)
*	Writing (partial) 10111010010111010111100111010011101000110100001111001000110011111011010011010101  to  address 110110 with mask bit 1010111010 (from port 0) during cycle 24 (240ns - 250ns)
*	Writing (partial) 10000010100000110000101001010000100100010000110001100001100010010110100001100100  to  address 101110 with mask bit 0011111110 (from port 0) during cycle 25 (250ns - 260ns)
*	Writing 11000100101011111010011100101110000100001101101010110101100000001111110100110010  to  address 001101 (from port 0) during cycle 26 (260ns - 270ns)
*	Writing 11110100000101110110010000101011001101101000000001111010111010010110011101000111  to  address 000100 (from port 0) during cycle 27 (270ns - 280ns)
*	Writing (partial) 10001011100100001011111000011010111011010111011111001001011101101110010000001111  to  address 111110 with mask bit 0010011011 (from port 0) during cycle 28 (280ns - 290ns)
*	Reading 10100110101111001011111000100110101110100111011111001001110011101110010000001111 from address 111110 (from port 0) during cycle 29 (290ns - 300ns)
*	Reading 11000100101011111010011100101110000100001101101010110101100000001111110100110010 from address 001101 (from port 1) during cycle 29 (290ns - 300ns)
*	Reading 11110100000101110110010000101011001101101000000001111010111010010110011101000111 from address 000100 (from port 0) during cycle 30 (300ns - 310ns)
*	Writing (partial) 00011110011000011100010111010110010101010100101100000110101000000100111011000000  to  address 101110 with mask bit 0010111110 (from port 0) during cycle 32 (320ns - 330ns)
*	Reading 11110100000101110110010000101011001101101000000001111010111010010110011101000111 from address 000100 (from port 1) during cycle 32 (320ns - 330ns)
*	Reading 10101000111001001100010101010000010101010100101100000110101000000100111011011001 from address 101110 (from port 0) during cycle 33 (330ns - 340ns)
*	Reading 11110100000101110110010000101011001101101000000001111010111010010110011101000111 from address 000100 (from port 1) during cycle 33 (330ns - 340ns)
*	Reading 10100110101111001011111000100110101110100111011111001001110011101110010000001111 from address 111110 (from port 0) during cycle 34 (340ns - 350ns)
*	Reading 11000100101011111010011100101110000100001101101010110101100000001111110100110010 from address 001101 (from port 1) during cycle 34 (340ns - 350ns)
*	Writing 11010000110101011111110011101011110101111001100101110110000100000011100000101110  to  address 101011 (from port 0) during cycle 35 (350ns - 360ns)
*	Reading 10101000111001001100010101010000010101010100101100000110101000000100111011011001 from address 101110 (from port 0) during cycle 36 (360ns - 370ns)
*	Reading 11010000110101011111110011101011110101111001100101110110000100000011100000101110 from address 101011 (from port 1) during cycle 37 (370ns - 380ns)
*	Reading 11010000110101011111110011101011110101111001100101110110000100000011100000101110 from address 101011 (from port 1) during cycle 38 (380ns - 390ns)
*	Writing 01100011101010100001100000010101100110000110011111001111000010100011011011001101  to  address 010001 (from port 0) during cycle 39 (390ns - 400ns)
*	Reading 11000100101011111010011100101110000100001101101010110101100000001111110100110010 from address 001101 (from port 1) during cycle 39 (390ns - 400ns)
*	Reading 01100011101010100001100000010101100110000110011111001111000010100011011011001101 from address 010001 (from port 0) during cycle 40 (400ns - 410ns)
*	Reading 10111010011001000111100110101110101000110100001111001000010010001011010011110000 from address 110110 (from port 1) during cycle 40 (400ns - 410ns)
*	Reading 10100110101111001011111000100110101110100111011111001001110011101110010000001111 from address 111110 (from port 1) during cycle 41 (410ns - 420ns)
*	Reading 11110100000101110110010000101011001101101000000001111010111010010110011101000111 from address 000100 (from port 0) during cycle 42 (420ns - 430ns)
*	Reading 11010000110101011111110011101011110101111001100101110110000100000011100000101110 from address 101011 (from port 1) during cycle 42 (420ns - 430ns)
*	Writing (partial) 10111001000010010000000011111001101000111100011110011110110011010110100010011011  to  address 000100 with mask bit 1101111101 (from port 0) during cycle 43 (430ns - 440ns)
*	Reading 10100110101111001011111000100110101110100111011111001001110011101110010000001111 from address 111110 (from port 0) during cycle 45 (450ns - 460ns)
*	Writing 01001110101000111111011010001011100010111000001111100011010001101001110110111010  to  address 100100 (from port 0) during cycle 47 (470ns - 480ns)
*	Writing 00001100101000110000111100100100100110001100001100111011101110110101111111101100  to  address 010010 (from port 0) during cycle 48 (480ns - 490ns)
*	Reading 11010000110101011111110011101011110101111001100101110110000100000011100000101110 from address 101011 (from port 1) during cycle 48 (480ns - 490ns)
*	Writing 01001111000100111000001000010100100101010110100101110101101110110111011010100001  to  address 100010 (from port 0) during cycle 49 (490ns - 500ns)
*	Writing (partial) 10001110111110010001000111110101100101100101010100111000111100111010101011100100  to  address 110110 with mask bit 1111100111 (from port 0) during cycle 50 (500ns - 510ns)
*	Reading 01001111000100111000001000010100100101010110100101110101101110110111011010100001 from address 100010 (from port 1) during cycle 50 (500ns - 510ns)
*	Writing (partial) 10111110011011000110011000100010011100111010111011101101010101100101110111011010  to  address 100010 with mask bit 1010100111 (from port 0) during cycle 52 (520ns - 530ns)
*	Writing 11110111010001101101010101000001001111111101100010001100111110001100100011111110  to  address 100011 (from port 0) during cycle 53 (530ns - 540ns)
*	Reading 11000100101011111010011100101110000100001101101010110101100000001111110100110010 from address 001101 (from port 0) during cycle 55 (550ns - 560ns)
*	Reading 11010000110101011111110011101011110101111001100101110110000100000011100000101110 from address 101011 (from port 1) during cycle 55 (550ns - 560ns)
*	Writing (partial) 00000010011001011100100001111110001100001100111011000100000100001011100000100000  to  address 001101 with mask bit 0111010001 (from port 0) during cycle 57 (570ns - 580ns)
*	Writing (partial) 00100111111001110001001001010101110101100110010001111010010111001101000111000101  to  address 010010 with mask bit 0111000111 (from port 0) during cycle 58 (580ns - 590ns)
*	Reading 10100110101111001011111000100110101110100111011111001001110011101110010000001111 from address 111110 (from port 1) during cycle 58 (580ns - 590ns)
*	Writing (partial) 01100010010010011011001000100100000110111001000111011100101100001011011111010001  to  address 010010 with mask bit 1110110100 (from port 0) during cycle 59 (590ns - 600ns)
*	Writing (partial) 00000110000001100011111011101010001000110111011000010010100010010011010100010111  to  address 111110 with mask bit 0010111110 (from port 0) during cycle 60 (600ns - 610ns)
*	Writing (partial) 01000010101010011001111000010001011101011000100001110001101110110001111111000100  to  address 101011 with mask bit 0001110010 (from port 0) during cycle 61 (610ns - 620ns)
*	Reading 01100010010010011011001001010101000110111001000100111011101100001101000111000101 from address 010010 (from port 1) during cycle 61 (610ns - 620ns)
*	Reading 11010000110101011111110000010001011101011000100001110110000100000001111100101110 from address 101011 (from port 0) during cycle 62 (620ns - 630ns)
*	Reading 11010000110101011111110000010001011101011000100001110110000100000001111100101110 from address 101011 (from port 1) during cycle 62 (620ns - 630ns)
*	Writing (partial) 10100101101010000100101010011101011000111011000000010010001001110000011110001001  to  address 100100 with mask bit 1111100000 (from port 0) during cycle 63 (630ns - 640ns)
*	Reading 10101000111001001100010101010000010101010100101100000110101000000100111011011001 from address 101110 (from port 0) during cycle 64 (640ns - 650ns)
*	Writing 11000100001000101010100100000110011010101001010101101001110110000101000010101000  to  address 010100 (from port 0) during cycle 66 (660ns - 670ns)
*	Reading 01100010010010011011001001010101000110111001000100111011101100001101000111000101 from address 010010 (from port 1) during cycle 66 (660ns - 670ns)
*	Writing (partial) 01001010001000010011101101100100111111010101011101110000100001001101101001011101  to  address 100010 with mask bit 0001000010 (from port 0) during cycle 67 (670ns - 680ns)
*	Reading 11000100011001011100100001111110000100001100111010110101100000001111110100100000 from address 001101 (from port 1) during cycle 68 (680ns - 690ns)
*	Reading 11010000110101011111110000010001011101011000100001110110000100000001111100101110 from address 101011 (from port 0) during cycle 69 (690ns - 700ns)
*	Reading 10111110000100110110011001100100011100110110100101110101010101101101101011011010 from address 100010 (from port 1) during cycle 69 (690ns - 700ns)
*	Reading 10100101101010000100101010011101011000111000001111100011010001101001110110111010 from address 100100 (from port 0) during cycle 70 (700ns - 710ns)
*	Reading 10111001000010010110010011111001101000111100011110011110110011010110011110011011 from address 000100 (from port 1) during cycle 70 (700ns - 710ns)
*	Writing 00111110110001101100010001001011100111101100111001010001110000011111101110011001  to  address 011100 (from port 0) during cycle 71 (710ns - 720ns)
*	Writing 10001100010100010101011100101011010001011000010011001001010101110111100011001101  to  address 110000 (from port 0) during cycle 72 (720ns - 730ns)
*	Reading 11110111010001101101010101000001001111111101100010001100111110001100100011111110 from address 100011 (from port 1) during cycle 72 (720ns - 730ns)
*	Reading 10111110000100110110011001100100011100110110100101110101010101101101101011011010 from address 100010 (from port 0) during cycle 74 (740ns - 750ns)
*	Reading 11000100011001011100100001111110000100001100111010110101100000001111110100100000 from address 001101 (from port 1) during cycle 74 (740ns - 750ns)
*	Reading 01100010010010011011001001010101000110111001000100111011101100001101000111000101 from address 010010 (from port 1) during cycle 75 (750ns - 760ns)
*	Reading 10111001000010010110010011111001101000111100011110011110110011010110011110011011 from address 000100 (from port 0) during cycle 76 (760ns - 770ns)
*	Writing 11110111000101000011110100111011110010111000000010010110100011100000001011101101  to  address 111011 (from port 0) during cycle 77 (770ns - 780ns)
*	Reading 10001110111110010001000111110101100101100100001111001000111100111010101011100100 from address 110110 (from port 1) during cycle 77 (770ns - 780ns)
*	Writing (partial) 11010101010100100101011110011000001111010100010001111001001111011000000010101110  to  address 100010 with mask bit 1100011011 (from port 0) during cycle 78 (780ns - 790ns)
*	Reading 00111110110001101100010001001011100111101100111001010001110000011111101110011001 from address 011100 (from port 1) during cycle 78 (780ns - 790ns)
*	Writing (partial) 00100111011000100111111110010011010000000101110101101101000110101001001111110000  to  address 011100 with mask bit 0111111101 (from port 0) during cycle 79 (790ns - 800ns)
*	Reading 10001100010100010101011100101011010001011000010011001001010101110111100011001101 from address 110000 (from port 0) during cycle 80 (800ns - 810ns)
*	Reading 10111001000010010110010011111001101000111100011110011110110011010110011110011011 from address 000100 (from port 1) during cycle 80 (800ns - 810ns)
*	Reading 10100101101010000100101010011101011000111000001111100011010001101001110110111010 from address 100100 (from port 1) during cycle 81 (810ns - 820ns)
*	Reading 10101000111001001100010101010000010101010100101100000110101000000100111011011001 from address 101110 (from port 0) during cycle 82 (820ns - 830ns)
*	Reading 10100101101010000100101010011101011000111000001111100011010001101001110110111010 from address 100100 (from port 1) during cycle 82 (820ns - 830ns)
*	Reading 01100011101010100001100000010101100110000110011111001111000010100011011011001101 from address 010001 (from port 1) during cycle 83 (830ns - 840ns)
*	Writing (partial) 11000100111101110000110011100010001100011111101000001101111010101011000100110100  to  address 101110 with mask bit 1100101111 (from port 0) during cycle 84 (840ns - 850ns)
*	Reading 00111110011000100111111110010011010000000101110101101101000110101111101111110000 from address 011100 (from port 1) during cycle 84 (840ns - 850ns)
*	Writing (partial) 00100110011011010101010110101000010110110100011011110000000100010101011011111111  to  address 001101 with mask bit 1001100100 (from port 0) during cycle 85 (850ns - 860ns)
*	Reading 10001100010100010101011100101011010001011000010011001001010101110111100011001101 from address 110000 (from port 1) during cycle 85 (850ns - 860ns)
*	Writing 00110110101010011010011001011111101011010111010110110100000111110101011001010110  to  address 001101 (from port 0) during cycle 86 (860ns - 870ns)
*	Reading 00110110101010011010011001011111101011010111010110110100000111110101011001010110 from address 001101 (from port 0) during cycle 87 (870ns - 880ns)
*	Reading 10001100010100010101011100101011010001011000010011001001010101110111100011001101 from address 110000 (from port 1) during cycle 87 (870ns - 880ns)
*	Reading 01100011101010100001100000010101100110000110011111001111000010100011011011001101 from address 010001 (from port 0) during cycle 88 (880ns - 890ns)
*	Reading 11000100111101111100010101010000001100010100101100001101111010101011000100110100 from address 101110 (from port 0) during cycle 90 (900ns - 910ns)
*	Writing (partial) 10101100101110010011101100101110110101101110000001111110110011011001111001010110  to  address 100011 with mask bit 1011101101 (from port 0) during cycle 91 (910ns - 920ns)
*	Reading 10001100010100010101011100101011010001011000010011001001010101110111100011001101 from address 110000 (from port 1) during cycle 91 (910ns - 920ns)
*	Reading 10111001000010010110010011111001101000111100011110011110110011010110011110011011 from address 000100 (from port 0) during cycle 92 (920ns - 930ns)
*	Reading 10111001000010010110010011111001101000111100011110011110110011010110011110011011 from address 000100 (from port 1) during cycle 92 (920ns - 930ns)
*	Writing (partial) 01101110110011110111110100100101000011100001101011000100011110001100101010111110  to  address 100010 with mask bit 0111110101 (from port 0) during cycle 93 (930ns - 940ns)
*	Reading 00110110101010011010011001011111101011010111010110110100000111110101011001010110 from address 001101 (from port 1) during cycle 93 (930ns - 940ns)
*	Writing 11011110101011010010110010111101000110100110001000111110011011111101001010100000  to  address 010010 (from port 0) during cycle 94 (940ns - 950ns)
*	Writing 00001101000101100100101100001001101101111110110111101010111001100010110010111110  to  address 011101 (from port 0) during cycle 95 (950ns - 960ns)
*	Writing 10011110000001101110111111001110110101111010110011110000011001000000011110101000  to  address 110010 (from port 0) during cycle 96 (960ns - 970ns)
*	Reading 10001110111110010001000111110101100101100100001111001000111100111010101011100100 from address 110110 (from port 0) during cycle 97 (970ns - 980ns)
*	Reading 11011110101011010010110010111101000110100110001000111110011011111101001010100000 from address 010010 (from port 1) during cycle 97 (970ns - 980ns)
*	Writing 01110111100101000111111100001010100111010111100010110011010010110110110110010001  to  address 011001 (from port 0) during cycle 98 (980ns - 990ns)
*	Reading 00110110101010011010011001011111101011010111010110110100000111110101011001010110 from address 001101 (from port 1) during cycle 98 (980ns - 990ns)
*	Writing 11100111110011100000100111010100100110101011111010001010101010000100101000111111  to  address 111011 (from port 0) during cycle 99 (990ns - 1000ns)
*	Reading 10001100010100010101011100101011010001011000010011001001010101110111100011001101 from address 110000 (from port 1) during cycle 99 (990ns - 1000ns)
*	Writing (partial) 11110110111000111101011110010011000111111000001001011011111001101110010001011010  to  address 010001 with mask bit 1010010110 (from port 0) during cycle 100 (1000ns - 1010ns)
*	Writing (partial) 00000000011011000100100111010111110001000000000000011101111001010011110111011100  to  address 110000 with mask bit 1000010101 (from port 0) during cycle 101 (1010ns - 1020ns)
*	Reading 11100111110011100000100111010100100110101011111010001010101010000100101000111111 from address 111011 (from port 1) during cycle 101 (1010ns - 1020ns)
*	Writing 00011101100000011110101010010110010001001011001101000101001011101011010101010100  to  address 101101 (from port 0) during cycle 102 (1020ns - 1030ns)
*	Reading 10100110101111000011111000100110001000110111011000010010100010010011010100001111 from address 111110 (from port 1) during cycle 102 (1020ns - 1030ns)
*	Writing (partial) 11001111001100001110011000010010000011100011000011111100110111110001000110011111  to  address 101011 with mask bit 0001010000 (from port 0) during cycle 103 (1030ns - 1040ns)
*	Reading 00000000010100010101011100101011010001010000000011001001111001010111100011011100 from address 110000 (from port 1) during cycle 103 (1030ns - 1040ns)
*	Reading 10100101101010000100101010011101011000111000001111100011010001101001110110111010 from address 100100 (from port 0) during cycle 104 (1040ns - 1050ns)
*	Reading 11000100001000101010100100000110011010101001010101101001110110000101000010101000 from address 010100 (from port 1) during cycle 104 (1040ns - 1050ns)
*	Writing (partial) 01101000010011111111011110110110110100100010011000101101010111001001101100111100  to  address 001101 with mask bit 1111000110 (from port 0) during cycle 105 (1050ns - 1060ns)
*	Reading 01110111100101000111111100001010100111010111100010110011010010110110110110010001 from address 011001 (from port 1) during cycle 105 (1050ns - 1060ns)
*	Reading 11000100111101111100010101010000001100010100101100001101111010101011000100110100 from address 101110 (from port 1) during cycle 106 (1060ns - 1070ns)
*	Reading 01101000010011111111011110110110101011010111010110110100010111001001101101010110 from address 001101 (from port 0) during cycle 107 (1070ns - 1080ns)
*	Reading 01101000010011111111011110110110101011010111010110110100010111001001101101010110 from address 001101 (from port 1) during cycle 108 (1080ns - 1090ns)
*	Writing (partial) 00111110110000001101111100101111101111100110011110100110000111001000101011011100  to  address 011001 with mask bit 0101111101 (from port 0) during cycle 109 (1090ns - 1100ns)
*	Reading 11010101110011110111110100100101000011100001101001111001011110001000000010111110 from address 100010 (from port 0) during cycle 111 (1110ns - 1120ns)
*	Reading 11100111110011100000100111010100100110101011111010001010101010000100101000111111 from address 111011 (from port 1) during cycle 111 (1110ns - 1120ns)
*	Reading 11000100001000101010100100000110011010101001010101101001110110000101000010101000 from address 010100 (from port 0) during cycle 112 (1120ns - 1130ns)
*	Reading 00001101000101100100101100001001101101111110110111101010111001100010110010111110 from address 011101 (from port 0) during cycle 113 (1130ns - 1140ns)
*	Reading 00111110011000100111111110010011010000000101110101101101000110101111101111110000 from address 011100 (from port 1) during cycle 113 (1130ns - 1140ns)
*	Reading 11000100001000101010100100000110011010101001010101101001110110000101000010101000 from address 010100 (from port 0) during cycle 114 (1140ns - 1150ns)
*	Reading 11010000110101011111110000010010011101010011000001110110000100000001111100101110 from address 101011 (from port 1) during cycle 114 (1140ns - 1150ns)
*	Writing (partial) 10000000100010100010010010001011000001001111111011001000110000001101000010100110  to  address 011001 with mask bit 1101111111 (from port 0) during cycle 115 (1150ns - 1160ns)
*	Reading 00000000010100010101011100101011010001010000000011001001111001010111100011011100 from address 110000 (from port 1) during cycle 115 (1150ns - 1160ns)
*	Writing 11000100101101110011011111100001110101000001001001100010001000111000110001101111  to  address 111011 (from port 0) during cycle 116 (1160ns - 1170ns)
*	Writing 11100111110011111000011100101110001100111010111101101001010000000011010111101101  to  address 100000 (from port 0) during cycle 117 (1170ns - 1180ns)
*	Reading 10111001000010010110010011111001101000111100011110011110110011010110011110011011 from address 000100 (from port 1) during cycle 117 (1170ns - 1180ns)
*	Writing (partial) 10010000000101011110111010111011010100100100001001000101100000000110001110101111  to  address 111110 with mask bit 0111001000 (from port 0) during cycle 118 (1180ns - 1190ns)
*	Reading 11000100111101111100010101010000001100010100101100001101111010101011000100110100 from address 101110 (from port 1) during cycle 119 (1190ns - 1200ns)
*	Writing (partial) 00100100010100111000000011010111000111101110011111000111010100000110101010011101  to  address 110000 with mask bit 0101111011 (from port 0) during cycle 120 (1200ns - 1210ns)
*	Reading 11011110101011010010110010111101000110100110001000111110011011111101001010100000 from address 010010 (from port 1) during cycle 120 (1200ns - 1210ns)
*	Writing 01001100100000100000011101000101100001001110110100011110100111001001001111100001  to  address 111101 (from port 0) during cycle 121 (1210ns - 1220ns)
*	Reading 11100111110011111000011100101110001100111010111101101001010000000011010111101101 from address 100000 (from port 1) during cycle 121 (1210ns - 1220ns)
*	Reading 10011110000001101110111111001110110101111010110011110000011001000000011110101000 from address 110010 (from port 1) during cycle 122 (1220ns - 1230ns)
*	Reading 10101100010001100011101100101110110101101101100001111110110011011100100001010110 from address 100011 (from port 1) during cycle 123 (1230ns - 1240ns)
*	Reading 10100110000101011110111010111011001000110111011001000101100010010011010100001111 from address 111110 (from port 0) during cycle 125 (1250ns - 1260ns)
*	Reading 10101100010001100011101100101110110101101101100001111110110011011100100001010110 from address 100011 (from port 0) during cycle 126 (1260ns - 1270ns)
*	Reading 11000100101101110011011111100001110101000001001001100010001000111000110001101111 from address 111011 (from port 1) during cycle 127 (1270ns - 1280ns)
*	Writing 11001000010010110000110001000011101111110000100001001000001001011100101001110111  to  address 010001 (from port 0) during cycle 128 (1280ns - 1290ns)
*	Reading 00000000010100110101011111010111000111101110011111000111111001010110101010011101 from address 110000 (from port 0) during cycle 129 (1290ns - 1300ns)
*	Writing (partial) 00101110010011110101100111000110000011010010010001111011000010000111000110011110  to  address 100011 with mask bit 1101110001 (from port 0) during cycle 130 (1300ns - 1310ns)
*	Reading 10000000100010100111111110001011000001001111111011001000110000001101000010100110 from address 011001 (from port 0) during cycle 131 (1310ns - 1320ns)
*	Reading 01001100100000100000011101000101100001001110110100011110100111001001001111100001 from address 111101 (from port 0) during cycle 132 (1320ns - 1330ns)
*	Reading 11000100111101111100010101010000001100010100101100001101111010101011000100110100 from address 101110 (from port 1) during cycle 132 (1320ns - 1330ns)
*	Reading 10011110000001101110111111001110110101111010110011110000011001000000011110101000 from address 110010 (from port 0) during cycle 133 (1330ns - 1340ns)
*	Reading 11001000010010110000110001000011101111110000100001001000001001011100101001110111 from address 010001 (from port 1) during cycle 133 (1330ns - 1340ns)
*	Writing 11110111111000001101110001011011110011010000111111111101000110000101110010111000  to  address 000000 (from port 0) during cycle 135 (1350ns - 1360ns)
*	Reading 10001110111110010001000111110101100101100100001111001000111100111010101011100100 from address 110110 (from port 1) during cycle 135 (1350ns - 1360ns)
*	Writing (partial) 10110101010010001110011110100111111111001001011101111100001101000110110011101101  to  address 000000 with mask bit 1010000010 (from port 0) during cycle 136 (1360ns - 1370ns)
*	Reading 00111110011000100111111110010011010000000101110101101101000110101111101111110000 from address 011100 (from port 1) during cycle 136 (1360ns - 1370ns)
*	Reading 01001100100000100000011101000101100001001110110100011110100111001001001111100001 from address 111101 (from port 0) during cycle 137 (1370ns - 1380ns)
*	Reading 11000100111101111100010101010000001100010100101100001101111010101011000100110100 from address 101110 (from port 1) during cycle 137 (1370ns - 1380ns)
*	Writing (partial) 10100010010010100110100110010010000110001110101111100101110100001011001101011100  to  address 110010 with mask bit 1000011100 (from port 0) during cycle 138 (1380ns - 1390ns)
*	Writing (partial) 00110111011000001001101100101001011110011110110111011001110100111111010011111011  to  address 010010 with mask bit 0011011010 (from port 0) during cycle 139 (1390ns - 1400ns)
*	Writing (partial) 10110011011010001101000110011100100101101101001100100101100111100000001101101101  to  address 101110 with mask bit 0110101011 (from port 0) during cycle 140 (1400ns - 1410ns)
*	Reading 10001110111110010001000111110101100101100100001111001000111100111010101011100100 from address 110110 (from port 1) during cycle 140 (1400ns - 1410ns)
*	Writing (partial) 01100110010111100011001110001000010001101100100001000010011010101010100001000111  to  address 100010 with mask bit 1000110101 (from port 0) during cycle 141 (1410ns - 1420ns)
*	Reading 11001000010010110000110001000011101111110000100001001000001001011100101001110111 from address 010001 (from port 1) during cycle 141 (1410ns - 1420ns)
*	Reading 01101000010011111111011110110110101011010111010110110100010111001001101101010110 from address 001101 (from port 1) during cycle 142 (1420ns - 1430ns)
*	Reading 00011101100000011110101010010110010001001011001101000101001011101011010101010100 from address 101101 (from port 0) during cycle 143 (1430ns - 1440ns)
*	Reading 00001101000101100100101100001001101101111110110111101010111001100010110010111110 from address 011101 (from port 1) during cycle 144 (1440ns - 1450ns)
*	Writing 00101010001000001010111101011100000010100001000001011010010000010110100101110100  to  address 010011 (from port 0) during cycle 145 (1450ns - 1460ns)
*	Writing 10011011111001001001100101011101000011010010101010100010100000100010110011000110  to  address 000011 (from port 0) during cycle 146 (1460ns - 1470ns)
*	Reading 11001000010010110000110001000011101111110000100001001000001001011100101001110111 from address 010001 (from port 1) during cycle 146 (1460ns - 1470ns)
*	Writing (partial) 11001000010000111100000001011011100001011111001011111110111110000011001101110001  to  address 110010 with mask bit 0010000001 (from port 0) during cycle 147 (1470ns - 1480ns)
*	Reading 00000000010100110101011111010111000111101110011111000111111001010110101010011101 from address 110000 (from port 0) during cycle 148 (1480ns - 1490ns)
*	Reading 00101110010011110011101111000110000011010010010001111110110011011100100010011110 from address 100011 (from port 1) during cycle 148 (1480ns - 1490ns)
*	Reading 01001100100000100000011101000101100001001110110100011110100111001001001111100001 from address 111101 (from port 1) during cycle 150 (1500ns - 1510ns)
*	Writing (partial) 10111100100110101101000011100101010001001111001111000001000101010001010101101010  to  address 000100 with mask bit 1110001000 (from port 0) during cycle 151 (1510ns - 1520ns)
*	Reading 11000100101101110011011111100001110101000001001001100010001000111000110001101111 from address 111011 (from port 1) during cycle 151 (1510ns - 1520ns)
*	Reading 10001110111110010001000111110101100101100100001111001000111100111010101011100100 from address 110110 (from port 1) during cycle 152 (1520ns - 1530ns)
*	Reading 11000100011010001101000101010000100101100100101100100101111010100000001101101101 from address 101110 (from port 0) during cycle 153 (1530ns - 1540ns)
*	Writing (partial) 01111000011011010000101100010110111000100111001000010000101001000100011010011101  to  address 010011 with mask bit 0101111010 (from port 0) during cycle 154 (1540ns - 1550ns)
*	Reading 00111110011000100111111110010011010000000101110101101101000110101111101111110000 from address 011100 (from port 1) during cycle 155 (1550ns - 1560ns)
*	Writing (partial) 10110101011000000010101000001001001111001011001110110010011101010110110010001111  to  address 011100 with mask bit 1111001101 (from port 0) during cycle 156 (1560ns - 1570ns)
*	Reading 11010000110101011111110000010010011101010011000001110110000100000001111100101110 from address 101011 (from port 1) during cycle 156 (1560ns - 1570ns)
*	Reading 11010000110101011111110000010010011101010011000001110110000100000001111100101110 from address 101011 (from port 0) during cycle 157 (1570ns - 1580ns)
*	Reading 11000100101101110011011111100001110101000001001001100010001000111000110001101111 from address 111011 (from port 1) during cycle 157 (1570ns - 1580ns)
*	Writing (partial) 01001110000010000100110111100010101100001000100111110010001100111001010101101011  to  address 000100 with mask bit 0101010011 (from port 0) during cycle 158 (1580ns - 1590ns)
*	Reading 00101010011011011010111100010110111000100111001000010000010000010100011001110100 from address 010011 (from port 1) during cycle 158 (1580ns - 1590ns)
*	Writing (partial) 11111111011001001011110101011000001100101101001010101111101001000001011111000011  to  address 010010 with mask bit 0010101101 (from port 0) during cycle 159 (1590ns - 1600ns)
*	Reading 01001100100000100000011101000101100001001110110100011110100111001001001111100001 from address 111101 (from port 1) during cycle 159 (1590ns - 1600ns)
*	Writing 01110010011101001100010110000111000101001001110010111111000110011101111111111011  to  address 100001 (from port 0) during cycle 160 (1600ns - 1610ns)
*	Reading 00001101000101100100101100001001101101111110110111101010111001100010110010111110 from address 011101 (from port 1) during cycle 160 (1600ns - 1610ns)
*	Reading 01101000010011111111011110110110101011010111010110110100010111001001101101010110 from address 001101 (from port 1) during cycle 161 (1610ns - 1620ns)
*	Writing 00010010010100011101000101010101111011101101001101101011111001111000001111100101  to  address 101100 (from port 0) during cycle 162 (1620ns - 1630ns)
*	Reading 10001110111110010001000111110101100101100100001111001000111100111010101011100100 from address 110110 (from port 1) during cycle 162 (1620ns - 1630ns)
*	Writing (partial) 00101100010111100111001111000001100011001011010101100101111100011000100011011011  to  address 110110 with mask bit 0010000101 (from port 0) during cycle 163 (1630ns - 1640ns)
*	Reading 00000000010100110101011111010111000111101110011111000111111001010110101010011101 from address 110000 (from port 1) during cycle 163 (1630ns - 1640ns)
*	Writing (partial) 10001100110101011000111101001101101010101000001110100100011000110011001001101110  to  address 110000 with mask bit 1110011101 (from port 0) during cycle 164 (1640ns - 1650ns)
*	Reading 00001101000101100100101100001001101101111110110111101010111001100010110010111110 from address 011101 (from port 1) during cycle 164 (1640ns - 1650ns)
*	Writing (partial) 10101010011101000011110100101000000010100010111100000000111001011011110010110011  to  address 110010 with mask bit 0010101100 (from port 0) during cycle 166 (1660ns - 1670ns)
*	Reading 00101110010011110011101111000110000011010010010001111110110011011100100010011110 from address 100011 (from port 1) during cycle 166 (1660ns - 1670ns)
*	Reading 11001000010010110000110001000011101111110000100001001000001001011100101001110111 from address 010001 (from port 0) during cycle 167 (1670ns - 1680ns)
*	Reading 10100010000001100011110111001110000010101110101100000000111001010000011101110001 from address 110010 (from port 1) during cycle 167 (1670ns - 1680ns)
*	Writing (partial) 00111001000111111101010001110000100011011111110111100010011111011010000001101111  to  address 010011 with mask bit 0111010001 (from port 0) during cycle 168 (1680ns - 1690ns)
*	Reading 01001100100000100000011101000101100001001110110100011110100111001001001111100001 from address 111101 (from port 1) during cycle 168 (1680ns - 1690ns)
*	Writing (partial) 01100111010111111011011011111111000000000011000000000100110110111100011111100001  to  address 011100 with mask bit 1001001111 (from port 0) during cycle 170 (1700ns - 1710ns)
*	Reading 10100101101010000100101010011101011000111000001111100011010001101001110110111010 from address 100100 (from port 1) during cycle 171 (1710ns - 1720ns)
*	Reading 01110010011101001100010110000111000101001001110010111111000110011101111111111011 from address 100001 (from port 1) during cycle 173 (1730ns - 1740ns)
*	Writing 00000000011010001000101000100110110100011100011010011000000011110011101101110010  to  address 110101 (from port 0) during cycle 174 (1740ns - 1750ns)
*	Writing 10110110100101110011111011000011101010000100011011001111001111101111010011110001  to  address 100100 (from port 0) during cycle 176 (1760ns - 1770ns)
*	Reading 10001100110101011000111111010111000111101000001110100100011000110110101001101110 from address 110000 (from port 1) during cycle 176 (1760ns - 1770ns)
*	Reading 00101110010011110011101111000110000011010010010001111110110011011100100010011110 from address 100011 (from port 1) during cycle 178 (1780ns - 1790ns)
*	Writing 11111100011110100000011000010001011110011000011110101011010111001010011101011110  to  address 111100 (from port 0) during cycle 179 (1790ns - 1800ns)
*	Writing (partial) 11000110011001101100000110100100010100111011110101001100010010011110100011110111  to  address 110110 with mask bit 1111110000 (from port 0) during cycle 180 (1800ns - 1810ns)
*	Writing (partial) 10110110000101100111101010000101000000011100011111110111110111110010001000101011  to  address 110101 with mask bit 0001110000 (from port 0) during cycle 181 (1810ns - 1820ns)
*	Reading 11010000110101011111110000010010011101010011000001110110000100000001111100101110 from address 101011 (from port 0) during cycle 182 (1820ns - 1830ns)
*	Writing (partial) 00111101011110100011001101111110000111001000110001001101100011001001100110100010  to  address 000011 with mask bit 1000011111 (from port 0) during cycle 184 (1840ns - 1850ns)
*	Reading 00101110010011110011101111000110000011010010010001111110110011011100100010011110 from address 100011 (from port 0) during cycle 185 (1850ns - 1860ns)
*	Reading 10000000100010100111111110001011000001001111111011001000110000001101000010100110 from address 011001 (from port 1) during cycle 185 (1850ns - 1860ns)
*	Writing (partial) 01111001101110001011001111000101001011100100110000101111000001001001110110010000  to  address 101011 with mask bit 1110010011 (from port 0) during cycle 186 (1860ns - 1870ns)
*	Reading 00011101100000011110101010010110010001001011001101000101001011101011010101010100 from address 101101 (from port 1) during cycle 186 (1860ns - 1870ns)
*	Writing (partial) 01001111010000110100010100001110110000100100010100000101001110101010111111010101  to  address 011001 with mask bit 0100000010 (from port 0) during cycle 187 (1870ns - 1880ns)
*	Reading 11011110101011011011110100101001001100101110110110101111101001001111010011000011 from address 010010 (from port 1) during cycle 187 (1870ns - 1880ns)
*	Writing 10100100110011110000011010011000001010111011111011101110000111100001011010110000  to  address 100010 (from port 0) during cycle 189 (1890ns - 1900ns)
*	Writing (partial) 00011111010010011111101000111100001001101001100100111111011101001011100001001000  to  address 111110 with mask bit 0001011101 (from port 0) during cycle 190 (1900ns - 1910ns)
*	Reading 10110110100101110011111011000011101010000100011011001111001111101111010011110001 from address 100100 (from port 0) during cycle 191 (1910ns - 1920ns)
*	Writing (partial) 00100011100010110011101111001100110011100000110010101100110101011110010100011001  to  address 011001 with mask bit 0111101011 (from port 0) during cycle 192 (1920ns - 1930ns)
*	Reading 10100100110011110000011010011000001010111011111011101110000111100001011010110000 from address 100010 (from port 1) during cycle 192 (1920ns - 1930ns)
*	Reading 10111100000010001101000011100010101000111000100111000001110011011001010101101011 from address 000100 (from port 1) during cycle 193 (1930ns - 1940ns)
*	Reading 11000100011010001101000101010000100101100100101100100101111010100000001101101101 from address 101110 (from port 0) during cycle 194 (1940ns - 1950ns)
*	Reading 11000100001000101010100100000110011010101001010101101001110110000101000010101000 from address 010100 (from port 1) during cycle 195 (1950ns - 1960ns)
*	Reading 11000100001000101010100100000110011010101001010101101001110110000101000010101000 from address 010100 (from port 1) during cycle 196 (1960ns - 1970ns)
*	Writing 00101100011000010101001101111110111100101111100000110110100011101101010001100011  to  address 000110 (from port 0) during cycle 197 (1970ns - 1980ns)
*	Writing (partial) 10110100101011111100001011100010000111100100011011001001010001000110111110000000  to  address 101100 with mask bit 0001100011 (from port 0) during cycle 199 (1990ns - 2000ns)
*	Reading 11000110011001101100000110100100010100111011110111001000111100011010101011011011 from address 110110 (from port 1) during cycle 199 (1990ns - 2000ns)
*	Reading 10100110000101011110111000111100001000111001100100111111011101000011010101001000 from address 111110 (from port 0) during cycle 200 (2000ns - 2010ns)
*	Reading 01111001101110001011001100010010011101010100110001110110000100001001110110010000 from address 101011 (from port 1) during cycle 200 (2000ns - 2010ns)
*	Writing (partial) 10010011001110111111001000001010010110000000010101001010011010110100000111000010  to  address 011001 with mask bit 1100101110 (from port 0) during cycle 201 (2010ns - 2020ns)
*	Writing (partial) 11000000011000000010000101111101010000010010100101001010110001001010010000100011  to  address 101100 with mask bit 0101000000 (from port 0) during cycle 202 (2020ns - 2030ns)
*	Idle during cycle 203 (2030ns - 2040ns)

* Generation of data and address signals
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 1), (50, 1), (60, 1), (70, 1), (80, 1), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 0), (260, 0), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 1), (400, 1), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 0), (480, 0), (490, 1), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 1), (590, 1), (600, 1), (610, 0), (620, 0), (630, 1), (640, 1), (650, 1), (660, 0), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 1), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 1), (990, 1), (1000, 0), (1010, 0), (1020, 0), (1030, 1), (1040, 1), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 1), (1370, 1), (1380, 0), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 0), (1460, 0), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 0), (1520, 0), (1530, 0), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 0), (1650, 0), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 0), (1750, 0), (1760, 1), (1770, 1), (1780, 1), (1790, 0), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 0), (1850, 0), (1860, 0), (1870, 1), (1880, 1), (1890, 0), (1900, 0), (1910, 0), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 0), (2000, 0), (2010, 0), (2020, 1), (2030, 1)]
Vdin0_0  din0_0  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 1.8v 499.495n 1.8v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 0.0v 669.495n 0.0v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 1.8v 859.495n 1.8v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 1), (70, 1), (80, 1), (90, 0), (100, 0), (110, 1), (120, 1), (130, 1), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 0), (330, 0), (340, 0), (350, 1), (360, 1), (370, 1), (380, 1), (390, 0), (400, 0), (410, 0), (420, 0), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 0), (490, 0), (500, 0), (510, 0), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 0), (580, 0), (590, 0), (600, 1), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 1), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 0), (950, 1), (960, 0), (970, 0), (980, 0), (990, 1), (1000, 1), (1010, 0), (1020, 0), (1030, 1), (1040, 1), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 1), (1160, 1), (1170, 0), (1180, 1), (1190, 1), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 1), (1400, 0), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 0), (1460, 1), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 1), (1520, 1), (1530, 1), (1540, 0), (1550, 0), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 0), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 1), (1750, 1), (1760, 0), (1770, 0), (1780, 0), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 1), (1980, 1), (1990, 0), (2000, 0), (2010, 1), (2020, 1), (2030, 1)]
Vdin0_1  din0_1  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 1.8v 609.495n 1.8v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 1.8v 789.495n 1.8v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 0.0v 949.495n 0.0v 949.505n 1.8v 959.495n 1.8v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 0), (50, 1), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 1), (120, 1), (130, 1), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 1), (250, 1), (260, 0), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 0), (330, 0), (340, 0), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 1), (410, 1), (420, 1), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 1), (490, 0), (500, 1), (510, 1), (520, 0), (530, 1), (540, 1), (550, 1), (560, 1), (570, 0), (580, 1), (590, 0), (600, 1), (610, 1), (620, 1), (630, 0), (640, 0), (650, 0), (660, 0), (670, 1), (680, 1), (690, 1), (700, 1), (710, 0), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 1), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 0), (950, 1), (960, 0), (970, 0), (980, 0), (990, 1), (1000, 0), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 0), (1360, 1), (1370, 1), (1380, 1), (1390, 0), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 1), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 1), (1630, 0), (1640, 1), (1650, 1), (1660, 0), (1670, 0), (1680, 1), (1690, 1), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 1), (1800, 1), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 1), (1880, 1), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0)]
Vdin0_2  din0_2  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 0.0v 49.495n 0.0v 49.505n 1.8v 59.495n 1.8v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 0.0v 269.495n 0.0v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 1.8v 489.495n 1.8v 489.505n 0.0v 499.495n 0.0v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 0.0v 529.495n 0.0v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 0.0v 579.495n 0.0v 579.505n 1.8v 589.495n 1.8v 589.505n 0.0v 599.495n 0.0v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 0.0v 719.495n 0.0v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 0.0v 949.495n 0.0v 949.505n 1.8v 959.495n 1.8v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 1.8v 999.495n 1.8v 999.505n 0.0v 1009.495n 0.0v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 1), (60, 1), (70, 1), (80, 1), (90, 0), (100, 0), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 0), (250, 0), (260, 0), (270, 0), (280, 1), (290, 1), (300, 1), (310, 1), (320, 0), (330, 0), (340, 0), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 1), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 0), (500, 0), (510, 0), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 1), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 1), (940, 0), (950, 1), (960, 1), (970, 1), (980, 0), (990, 1), (1000, 1), (1010, 1), (1020, 0), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 0), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 0), (1600, 1), (1610, 1), (1620, 0), (1630, 1), (1640, 1), (1650, 1), (1660, 0), (1670, 0), (1680, 1), (1690, 1), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 1), (1800, 0), (1810, 1), (1820, 1), (1830, 1), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0)]
Vdin0_3  din0_3  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 1.8v 859.495n 1.8v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 1.8v 939.495n 1.8v 939.505n 0.0v 949.495n 0.0v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 0.0v 989.495n 0.0v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 1), (50, 0), (60, 0), (70, 0), (80, 0), (90, 1), (100, 1), (110, 0), (120, 0), (130, 0), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 0), (210, 0), (220, 0), (230, 0), (240, 1), (250, 0), (260, 1), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 0), (490, 0), (500, 0), (510, 0), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 0), (580, 0), (590, 1), (600, 1), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 0), (950, 1), (960, 0), (970, 0), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 1), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 0), (1370, 0), (1380, 1), (1390, 1), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 1), (1460, 0), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 0), (1520, 0), (1530, 0), (1540, 1), (1550, 1), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 1), (1610, 1), (1620, 0), (1630, 1), (1640, 0), (1650, 0), (1660, 1), (1670, 1), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 0), (1910, 0), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0)]
Vdin0_4  din0_4  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 1.8v 49.495n 1.8v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 1.8v 249.495n 1.8v 249.505n 0.0v 259.495n 0.0v 259.505n 1.8v 269.495n 1.8v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 0.0v 949.495n 0.0v 949.505n 1.8v 959.495n 1.8v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 1), (260, 1), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 1), (360, 1), (370, 1), (380, 1), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 0), (530, 1), (540, 1), (550, 1), (560, 1), (570, 1), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 1), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 0), (990, 1), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 0), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 1), (1360, 1), (1370, 1), (1380, 0), (1390, 1), (1400, 1), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 1), (1460, 0), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 1), (1590, 0), (1600, 1), (1610, 1), (1620, 1), (1630, 0), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 0), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 0), (1870, 0), (1880, 0), (1890, 1), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 1), (1980, 1), (1990, 0), (2000, 0), (2010, 0), (2020, 1), (2030, 1)]
Vdin0_5  din0_5  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 0.0v 529.495n 0.0v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 1.8v 669.495n 1.8v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 0.0v 989.495n 0.0v 989.505n 1.8v 999.495n 1.8v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 0), (50, 1), (60, 0), (70, 0), (80, 0), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 0), (210, 0), (220, 0), (230, 0), (240, 1), (250, 1), (260, 0), (270, 1), (280, 0), (290, 0), (300, 0), (310, 0), (320, 1), (330, 1), (340, 1), (350, 0), (360, 0), (370, 0), (380, 0), (390, 1), (400, 1), (410, 1), (420, 1), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 1), (490, 0), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 0), (580, 1), (590, 1), (600, 0), (610, 1), (620, 1), (630, 0), (640, 0), (650, 0), (660, 0), (670, 1), (680, 1), (690, 1), (700, 1), (710, 0), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 0), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 0), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 1), (1010, 1), (1020, 1), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 0), (1160, 1), (1170, 1), (1180, 0), (1190, 0), (1200, 0), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 0), (1670, 0), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 1), (1880, 1), (1890, 0), (1900, 1), (1910, 1), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 1), (1980, 1), (1990, 0), (2000, 0), (2010, 1), (2020, 0), (2030, 0)]
Vdin0_6  din0_6  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 0.0v 49.495n 0.0v 49.505n 1.8v 59.495n 1.8v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 0.0v 269.495n 0.0v 269.505n 1.8v 279.495n 1.8v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 1.8v 489.495n 1.8v 489.505n 0.0v 499.495n 0.0v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 0.0v 579.495n 0.0v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 0.0v 609.495n 0.0v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 0.0v 719.495n 0.0v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 0.0v 789.495n 0.0v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 0.0v 849.495n 0.0v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 1), (60, 0), (70, 0), (80, 0), (90, 1), (100, 1), (110, 0), (120, 0), (130, 0), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 1), (330, 1), (340, 1), (350, 0), (360, 0), (370, 0), (380, 0), (390, 1), (400, 1), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 0), (580, 1), (590, 1), (600, 0), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 0), (680, 0), (690, 0), (700, 0), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 0), (850, 1), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 0), (1000, 0), (1010, 1), (1020, 0), (1030, 1), (1040, 1), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 0), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 0), (1290, 0), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 0), (1390, 1), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 1), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 0), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 0), (1650, 0), (1660, 1), (1670, 1), (1680, 0), (1690, 0), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 0), (1750, 0), (1760, 1), (1770, 1), (1780, 1), (1790, 0), (1800, 1), (1810, 0), (1820, 0), (1830, 0), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 1), (2000, 1), (2010, 1), (2020, 0), (2030, 0)]
Vdin0_7  din0_7  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 0.0v 579.495n 0.0v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 0.0v 609.495n 0.0v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 0.0v 849.495n 0.0v 849.505n 1.8v 859.495n 1.8v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 1), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 0), (250, 0), (260, 1), (270, 1), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 1), (480, 1), (490, 0), (500, 0), (510, 0), (520, 1), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 1), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 1), (970, 1), (980, 1), (990, 0), (1000, 0), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 1), (1180, 1), (1190, 1), (1200, 0), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 0), (1290, 0), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 0), (1360, 0), (1370, 0), (1380, 1), (1390, 0), (1400, 1), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 1), (1460, 0), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 0), (1770, 0), (1780, 0), (1790, 1), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 0), (1900, 0), (1910, 0), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 0), (1980, 0), (1990, 1), (2000, 1), (2010, 1), (2020, 0), (2030, 0)]
Vdin0_8  din0_8  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 1.8v 59.495n 1.8v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 1.8v 529.495n 1.8v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 1.8v 719.495n 1.8v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 1), (100, 1), (110, 0), (120, 0), (130, 0), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 1), (280, 0), (290, 0), (300, 0), (310, 0), (320, 1), (330, 1), (340, 1), (350, 0), (360, 0), (370, 0), (380, 0), (390, 1), (400, 1), (410, 1), (420, 1), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 1), (490, 1), (500, 1), (510, 1), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 1), (600, 0), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 0), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 1), (780, 0), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 0), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 0), (960, 1), (970, 1), (980, 0), (990, 1), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 0), (1160, 0), (1170, 0), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 1), (1390, 0), (1400, 1), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 0), (1520, 0), (1530, 0), (1540, 1), (1550, 1), (1560, 0), (1570, 0), (1580, 0), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 0), (1640, 1), (1650, 1), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 0), (1770, 0), (1780, 0), (1790, 1), (1800, 0), (1810, 1), (1820, 1), (1830, 1), (1840, 0), (1850, 0), (1860, 0), (1870, 1), (1880, 1), (1890, 1), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 1), (2000, 1), (2010, 0), (2020, 0), (2030, 0)]
Vdin0_9  din0_9  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 1.8v 279.495n 1.8v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 1.8v 599.495n 1.8v 599.505n 0.0v 609.495n 0.0v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 0.0v 669.495n 0.0v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 1.8v 779.495n 1.8v 779.505n 0.0v 789.495n 0.0v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 0.0v 849.495n 0.0v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 0.0v 959.495n 0.0v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 0.0v 989.495n 0.0v 989.505n 1.8v 999.495n 1.8v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 1), (60, 0), (70, 0), (80, 0), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 0), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 0), (360, 0), (370, 0), (380, 0), (390, 1), (400, 1), (410, 1), (420, 1), (430, 0), (440, 0), (450, 0), (460, 0), (470, 1), (480, 1), (490, 1), (500, 0), (510, 0), (520, 1), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 0), (940, 0), (950, 1), (960, 1), (970, 1), (980, 1), (990, 0), (1000, 1), (1010, 1), (1020, 1), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 1), (1170, 1), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 1), (1360, 1), (1370, 1), (1380, 0), (1390, 1), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 1), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 1), (1670, 1), (1680, 0), (1690, 0), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 0), (1750, 0), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 0), (1910, 0), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 0), (2020, 1), (2030, 1)]
Vdin0_10  din0_10  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 0.0v 259.495n 0.0v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 1.8v 529.495n 1.8v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 0.0v 999.495n 0.0v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 1), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 1), (120, 1), (130, 1), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 1), (260, 1), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 0), (400, 0), (410, 0), (420, 0), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 0), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 1), (580, 0), (590, 0), (600, 0), (610, 1), (620, 1), (630, 0), (640, 0), (650, 0), (660, 0), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 1), (920, 1), (930, 1), (940, 0), (950, 1), (960, 0), (970, 0), (980, 1), (990, 1), (1000, 0), (1010, 1), (1020, 0), (1030, 0), (1040, 0), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 0), (1160, 1), (1170, 0), (1180, 0), (1190, 0), (1200, 1), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 1), (1290, 1), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 1), (1360, 1), (1370, 1), (1380, 0), (1390, 0), (1400, 0), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 1), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 1), (1570, 1), (1580, 0), (1590, 0), (1600, 1), (1610, 1), (1620, 0), (1630, 1), (1640, 0), (1650, 0), (1660, 1), (1670, 1), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 1), (1750, 1), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 1), (1810, 0), (1820, 0), (1830, 0), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 0), (1900, 1), (1910, 1), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 1), (2000, 1), (2010, 0), (2020, 0), (2030, 0)]
Vdin0_11  din0_11  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 1.8v 59.495n 1.8v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 0.0v 499.495n 0.0v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 0.0v 949.495n 0.0v 949.505n 1.8v 959.495n 1.8v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 0.0v 1009.495n 0.0v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 0), (50, 0), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 0), (260, 1), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 1), (410, 1), (420, 1), (430, 0), (440, 0), (450, 0), (460, 0), (470, 1), (480, 1), (490, 1), (500, 0), (510, 0), (520, 1), (530, 0), (540, 0), (550, 0), (560, 0), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 0), (640, 0), (650, 0), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 0), (780, 0), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 0), (940, 1), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 1), (1160, 0), (1170, 1), (1180, 0), (1190, 0), (1200, 0), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 0), (1290, 0), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 0), (1370, 0), (1380, 1), (1390, 1), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 0), (1630, 0), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 1), (1850, 1), (1860, 1), (1870, 0), (1880, 0), (1890, 1), (1900, 1), (1910, 1), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 1), (1980, 1), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0)]
Vdin0_12  din0_12  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 0.0v 259.495n 0.0v 259.505n 1.8v 269.495n 1.8v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 1.8v 529.495n 1.8v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 0.0v 939.495n 0.0v 939.505n 1.8v 949.495n 1.8v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 1), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 1), (120, 1), (130, 1), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 0), (330, 0), (340, 0), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 1), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 0), (480, 0), (490, 1), (500, 1), (510, 1), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 1), (580, 0), (590, 1), (600, 1), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 1), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 1), (960, 0), (970, 0), (980, 1), (990, 0), (1000, 1), (1010, 1), (1020, 1), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 0), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 0), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 1), (1570, 1), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 0), (1850, 0), (1860, 0), (1870, 1), (1880, 1), (1890, 0), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 0), (1980, 0), (1990, 1), (2000, 1), (2010, 0), (2020, 1), (2030, 1)]
Vdin0_13  din0_13  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 1.8v 49.495n 1.8v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 1.8v 579.495n 1.8v 579.505n 0.0v 589.495n 0.0v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 1.8v 849.495n 1.8v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 1.8v 959.495n 1.8v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 1.8v 989.495n 1.8v 989.505n 0.0v 999.495n 0.0v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 1), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 1), (440, 1), (450, 1), (460, 1), (470, 0), (480, 1), (490, 1), (500, 0), (510, 0), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 0), (580, 1), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 0), (920, 0), (930, 1), (940, 1), (950, 0), (960, 0), (970, 0), (980, 1), (990, 1), (1000, 1), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 1), (1160, 0), (1170, 0), (1180, 1), (1190, 1), (1200, 1), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 0), (1390, 1), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 1), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 0), (1590, 0), (1600, 1), (1610, 1), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 0), (1750, 0), (1760, 1), (1770, 1), (1780, 1), (1790, 0), (1800, 1), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 1), (2020, 0), (2030, 0)]
Vdin0_14  din0_14  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 0.0v 479.495n 0.0v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 0.0v 579.495n 0.0v 579.505n 1.8v 589.495n 1.8v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 0), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 0), (120, 0), (130, 0), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 0), (260, 1), (270, 0), (280, 1), (290, 1), (300, 1), (310, 1), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 1), (480, 0), (490, 0), (500, 1), (510, 1), (520, 0), (530, 1), (540, 1), (550, 1), (560, 1), (570, 1), (580, 1), (590, 1), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 1), (920, 1), (930, 1), (940, 1), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 1), (1010, 0), (1020, 1), (1030, 0), (1040, 0), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 1), (1390, 1), (1400, 0), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 1), (1590, 0), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 0), (1650, 0), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 0), (1750, 0), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 0), (1820, 0), (1830, 0), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 0), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 0), (2000, 0), (2010, 0), (2020, 1), (2030, 1)]
Vdin0_15  din0_15  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 0.0v 59.495n 0.0v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 0.0v 259.495n 0.0v 259.505n 1.8v 269.495n 1.8v 269.505n 0.0v 279.495n 0.0v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 1.8v 479.495n 1.8v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 0.0v 529.495n 0.0v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 1.8v 1009.495n 1.8v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 0), (270, 1), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 1), (440, 1), (450, 1), (460, 1), (470, 0), (480, 1), (490, 1), (500, 1), (510, 1), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 0), (780, 1), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 0), (940, 1), (950, 0), (960, 0), (970, 0), (980, 1), (990, 0), (1000, 0), (1010, 1), (1020, 0), (1030, 1), (1040, 1), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 1), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 1), (1290, 1), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 1), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 1), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 1), (1520, 1), (1530, 1), (1540, 0), (1550, 0), (1560, 1), (1570, 1), (1580, 1), (1590, 0), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 1), (2020, 0), (2030, 0)]
Vdin0_16  din0_16  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 0.0v 269.495n 0.0v 269.505n 1.8v 279.495n 1.8v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 0.0v 479.495n 0.0v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 0.0v 779.495n 0.0v 779.505n 1.8v 789.495n 1.8v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 0.0v 939.495n 0.0v 939.505n 1.8v 949.495n 1.8v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 1.8v 989.495n 1.8v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 1), (60, 1), (70, 1), (80, 1), (90, 0), (100, 0), (110, 1), (120, 1), (130, 1), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 0), (260, 0), (270, 0), (280, 1), (290, 1), (300, 1), (310, 1), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 1), (400, 1), (410, 1), (420, 1), (430, 0), (440, 0), (450, 0), (460, 0), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 0), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 0), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 0), (920, 0), (930, 0), (940, 1), (950, 1), (960, 0), (970, 0), (980, 1), (990, 0), (1000, 1), (1010, 0), (1020, 1), (1030, 1), (1040, 1), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 1), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 0), (1460, 1), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 1), (1590, 0), (1600, 0), (1610, 0), (1620, 1), (1630, 0), (1640, 1), (1650, 1), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 0), (1800, 0), (1810, 1), (1820, 1), (1830, 1), (1840, 0), (1850, 0), (1860, 0), (1870, 1), (1880, 1), (1890, 1), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 1), (1980, 1), (1990, 0), (2000, 0), (2010, 1), (2020, 0), (2030, 0)]
Vdin0_17  din0_17  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 0.0v 789.495n 0.0v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 0.0v 859.495n 0.0v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 1.8v 989.495n 1.8v 989.505n 0.0v 999.495n 0.0v 999.505n 1.8v 1009.495n 1.8v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 1), (70, 1), (80, 1), (90, 0), (100, 0), (110, 1), (120, 1), (130, 1), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 0), (260, 0), (270, 0), (280, 1), (290, 1), (300, 1), (310, 1), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 0), (490, 0), (500, 0), (510, 0), (520, 1), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 1), (590, 0), (600, 0), (610, 0), (620, 0), (630, 1), (640, 1), (650, 1), (660, 0), (670, 1), (680, 1), (690, 1), (700, 1), (710, 0), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 0), (940, 1), (950, 1), (960, 1), (970, 1), (980, 0), (990, 0), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 1), (1370, 1), (1380, 0), (1390, 0), (1400, 1), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 0), (1590, 1), (1600, 0), (1610, 0), (1620, 1), (1630, 0), (1640, 0), (1650, 0), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 0), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 0), (1880, 0), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 0), (2020, 1), (2030, 1)]
Vdin0_18  din0_18  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 1.8v 529.495n 1.8v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 1.8v 589.495n 1.8v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 0.0v 669.495n 0.0v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 0.0v 719.495n 0.0v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 0.0v 939.495n 0.0v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 1), (50, 0), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 0), (270, 1), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 1), (400, 1), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 0), (480, 1), (490, 1), (500, 0), (510, 0), (520, 0), (530, 1), (540, 1), (550, 1), (560, 1), (570, 0), (580, 1), (590, 0), (600, 1), (610, 1), (620, 1), (630, 0), (640, 0), (650, 0), (660, 1), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 0), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 0), (960, 0), (970, 0), (980, 1), (990, 1), (1000, 0), (1010, 0), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 0), (1290, 0), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 0), (1460, 0), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 1), (1610, 1), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 0), (1870, 1), (1880, 1), (1890, 1), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 1), (1980, 1), (1990, 0), (2000, 0), (2010, 1), (2020, 0), (2030, 0)]
Vdin0_19  din0_19  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 1.8v 49.495n 1.8v 49.505n 0.0v 59.495n 0.0v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 0.0v 269.495n 0.0v 269.505n 1.8v 279.495n 1.8v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 0.0v 479.495n 0.0v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 0.0v 579.495n 0.0v 579.505n 1.8v 589.495n 1.8v 589.505n 0.0v 599.495n 0.0v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 1.8v 669.495n 1.8v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 0.0v 859.495n 0.0v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 1), (50, 0), (60, 1), (70, 1), (80, 1), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 1), (290, 1), (300, 1), (310, 1), (320, 0), (330, 0), (340, 0), (350, 1), (360, 1), (370, 1), (380, 1), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 1), (580, 1), (590, 1), (600, 0), (610, 1), (620, 1), (630, 0), (640, 0), (650, 0), (660, 1), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 0), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 0), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 0), (920, 0), (930, 1), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 0), (1550, 0), (1560, 1), (1570, 1), (1580, 1), (1590, 0), (1600, 1), (1610, 1), (1620, 0), (1630, 1), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 0), (1750, 0), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 0), (1810, 1), (1820, 1), (1830, 1), (1840, 0), (1850, 0), (1860, 0), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0)]
Vdin0_20  din0_20  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 1.8v 49.495n 1.8v 49.505n 0.0v 59.495n 0.0v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 0.0v 609.495n 0.0v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 1.8v 669.495n 1.8v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 0.0v 779.495n 0.0v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 0.0v 849.495n 0.0v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 1.8v 939.495n 1.8v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 1), (50, 0), (60, 1), (70, 1), (80, 1), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 1), (210, 1), (220, 1), (230, 1), (240, 0), (250, 0), (260, 0), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 1), (490, 1), (500, 1), (510, 1), (520, 0), (530, 1), (540, 1), (550, 1), (560, 1), (570, 0), (580, 0), (590, 1), (600, 0), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 1), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 1), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 0), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 1), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 1), (1290, 1), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 1), (1370, 1), (1380, 0), (1390, 0), (1400, 0), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 0), (1460, 0), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 0), (1520, 0), (1530, 0), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 0), (1610, 0), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 1), (1770, 1), (1780, 1), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 1), (1880, 1), (1890, 0), (1900, 1), (1910, 1), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 1), (2020, 0), (2030, 0)]
Vdin0_21  din0_21  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 1.8v 49.495n 1.8v 49.505n 0.0v 59.495n 0.0v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 0.0v 529.495n 0.0v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 1.8v 599.495n 1.8v 599.505n 0.0v 609.495n 0.0v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 1.8v 789.495n 1.8v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 1.8v 849.495n 1.8v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 0.0v 989.495n 0.0v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 0), (210, 0), (220, 0), (230, 0), (240, 1), (250, 0), (260, 0), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 0), (490, 0), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 0), (580, 1), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 1), (670, 0), (680, 0), (690, 0), (700, 0), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 1), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 0), (1000, 1), (1010, 1), (1020, 0), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 1), (1160, 0), (1170, 1), (1180, 0), (1190, 0), (1200, 1), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 1), (1390, 1), (1400, 0), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 0), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 1), (1570, 1), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 0), (1980, 0), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1)]
Vdin0_22  din0_22  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 1.8v 249.495n 1.8v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 0.0v 579.495n 0.0v 579.505n 1.8v 589.495n 1.8v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 1.8v 669.495n 1.8v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 1.8v 849.495n 1.8v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 0.0v 999.495n 0.0v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 0), (50, 1), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 0), (290, 0), (300, 0), (310, 0), (320, 1), (330, 1), (340, 1), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 1), (440, 1), (450, 1), (460, 1), (470, 0), (480, 1), (490, 1), (500, 1), (510, 1), (520, 0), (530, 1), (540, 1), (550, 1), (560, 1), (570, 0), (580, 0), (590, 1), (600, 1), (610, 1), (620, 1), (630, 0), (640, 0), (650, 0), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 1), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 1), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 1), (920, 1), (930, 0), (940, 0), (950, 1), (960, 0), (970, 0), (980, 0), (990, 1), (1000, 1), (1010, 1), (1020, 0), (1030, 1), (1040, 1), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 1), (1160, 0), (1170, 0), (1180, 1), (1190, 1), (1200, 0), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 1), (1390, 1), (1400, 1), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 0), (1520, 0), (1530, 0), (1540, 1), (1550, 1), (1560, 0), (1570, 0), (1580, 0), (1590, 1), (1600, 0), (1610, 0), (1620, 1), (1630, 1), (1640, 0), (1650, 0), (1660, 1), (1670, 1), (1680, 0), (1690, 0), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 0), (2000, 0), (2010, 0), (2020, 1), (2030, 1)]
Vdin0_23  din0_23  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 0.0v 49.495n 0.0v 49.505n 1.8v 59.495n 1.8v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 0.0v 479.495n 0.0v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 0.0v 529.495n 0.0v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 1.8v 779.495n 1.8v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 1.8v 849.495n 1.8v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 1.8v 959.495n 1.8v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 1), (50, 1), (60, 1), (70, 1), (80, 1), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 1), (260, 1), (270, 0), (280, 1), (290, 1), (300, 1), (310, 1), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 1), (400, 1), (410, 1), (420, 1), (430, 0), (440, 0), (450, 0), (460, 0), (470, 1), (480, 1), (490, 1), (500, 0), (510, 0), (520, 1), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 1), (620, 1), (630, 0), (640, 0), (650, 0), (660, 1), (670, 0), (680, 0), (690, 0), (700, 0), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 0), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 1), (990, 0), (1000, 1), (1010, 1), (1020, 1), (1030, 0), (1040, 0), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 0), (1370, 0), (1380, 1), (1390, 1), (1400, 1), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 1), (1520, 1), (1530, 1), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 0), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 0), (1900, 1), (1910, 1), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 1), (2000, 1), (2010, 0), (2020, 0), (2030, 0)]
Vdin0_24  din0_24  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 0.0v 279.495n 0.0v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 1.8v 529.495n 1.8v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 1.8v 669.495n 1.8v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 0.0v 779.495n 0.0v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 1.8v 989.495n 1.8v 989.505n 0.0v 999.495n 0.0v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 1), (50, 0), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 1), (210, 1), (220, 1), (230, 1), (240, 0), (250, 0), (260, 0), (270, 1), (280, 0), (290, 0), (300, 0), (310, 0), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 1), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 1), (590, 0), (600, 1), (610, 0), (620, 0), (630, 1), (640, 1), (650, 1), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 1), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 1), (920, 1), (930, 0), (940, 1), (950, 1), (960, 0), (970, 0), (980, 1), (990, 1), (1000, 1), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 0), (1160, 1), (1170, 0), (1180, 0), (1190, 0), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 0), (1290, 0), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 1), (1690, 1), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 0), (1810, 1), (1820, 1), (1830, 1), (1840, 0), (1850, 0), (1860, 1), (1870, 0), (1880, 0), (1890, 1), (1900, 1), (1910, 1), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 1), (1980, 1), (1990, 0), (2000, 0), (2010, 1), (2020, 1), (2030, 1)]
Vdin0_25  din0_25  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 1.8v 49.495n 1.8v 49.505n 0.0v 59.495n 0.0v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 1.8v 279.495n 1.8v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 1.8v 589.495n 1.8v 589.505n 0.0v 599.495n 0.0v 599.505n 1.8v 609.495n 1.8v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 1.8v 779.495n 1.8v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 0.0v 939.495n 0.0v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 1), (120, 1), (130, 1), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 1), (210, 1), (220, 1), (230, 1), (240, 0), (250, 0), (260, 1), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 1), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 0), (480, 0), (490, 1), (500, 0), (510, 0), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 1), (580, 0), (590, 1), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 1), (780, 0), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 0), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 0), (1160, 0), (1170, 0), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 0), (1400, 1), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 1), (1600, 1), (1610, 1), (1620, 0), (1630, 1), (1640, 1), (1650, 1), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 0), (1750, 0), (1760, 1), (1770, 1), (1780, 1), (1790, 0), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0)]
Vdin0_26  din0_26  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 1.8v 269.495n 1.8v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 1.8v 499.495n 1.8v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 0.0v 589.495n 0.0v 589.505n 1.8v 599.495n 1.8v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 1.8v 779.495n 1.8v 779.505n 0.0v 789.495n 0.0v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 0.0v 859.495n 0.0v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 1), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 1), (250, 0), (260, 0), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 1), (400, 1), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 0), (480, 1), (490, 0), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 0), (580, 1), (590, 1), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 1), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 0), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 1), (920, 1), (930, 0), (940, 1), (950, 1), (960, 0), (970, 0), (980, 0), (990, 1), (1000, 1), (1010, 1), (1020, 0), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 1), (1160, 0), (1170, 1), (1180, 0), (1190, 0), (1200, 0), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 0), (1390, 1), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 1), (1460, 0), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 0), (1820, 0), (1830, 0), (1840, 1), (1850, 1), (1860, 1), (1870, 0), (1880, 0), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 0), (1980, 0), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1)]
Vdin0_27  din0_27  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 1.8v 249.495n 1.8v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 0.0v 479.495n 0.0v 479.505n 1.8v 489.495n 1.8v 489.505n 0.0v 499.495n 0.0v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 0.0v 579.495n 0.0v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 1.8v 669.495n 1.8v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 0.0v 779.495n 0.0v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 0.0v 939.495n 0.0v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 0), (50, 1), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 1), (270, 1), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 1), (360, 1), (370, 1), (380, 1), (390, 0), (400, 0), (410, 0), (420, 0), (430, 1), (440, 1), (450, 1), (460, 1), (470, 0), (480, 1), (490, 1), (500, 1), (510, 1), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 0), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 1), (780, 1), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 0), (940, 1), (950, 0), (960, 1), (970, 1), (980, 1), (990, 0), (1000, 1), (1010, 1), (1020, 0), (1030, 1), (1040, 1), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 0), (1290, 0), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 0), (1390, 1), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 1), (1460, 0), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 0), (1520, 0), (1530, 0), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 0), (1600, 1), (1610, 1), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 1), (1750, 1), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 1), (1820, 1), (1830, 1), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 1), (1910, 1), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 1), (1980, 1), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0)]
Vdin0_28  din0_28  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 0.0v 49.495n 0.0v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 0.0v 479.495n 0.0v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 0.0v 669.495n 0.0v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 0.0v 939.495n 0.0v 939.505n 1.8v 949.495n 1.8v 949.505n 0.0v 959.495n 0.0v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 0.0v 999.495n 0.0v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 1), (50, 0), (60, 0), (70, 0), (80, 0), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 0), (250, 1), (260, 1), (270, 1), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 1), (360, 1), (370, 1), (380, 1), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 1), (590, 0), (600, 0), (610, 1), (620, 1), (630, 0), (640, 0), (650, 0), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 0), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 0), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 0), (1160, 1), (1170, 1), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 0), (1400, 1), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 0), (1670, 0), (1680, 1), (1690, 1), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 1), (1800, 0), (1810, 1), (1820, 1), (1830, 1), (1840, 0), (1850, 0), (1860, 1), (1870, 0), (1880, 0), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0)]
Vdin0_29  din0_29  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 1.8v 49.495n 1.8v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 0.0v 249.495n 0.0v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 1.8v 589.495n 1.8v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 0.0v 849.495n 0.0v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 0.0v 939.495n 0.0v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 1), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 0), (120, 0), (130, 0), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 0), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 0), (330, 0), (340, 0), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 1), (410, 1), (420, 1), (430, 0), (440, 0), (450, 0), (460, 0), (470, 1), (480, 0), (490, 1), (500, 0), (510, 0), (520, 1), (530, 0), (540, 0), (550, 0), (560, 0), (570, 1), (580, 1), (590, 1), (600, 0), (610, 1), (620, 1), (630, 0), (640, 0), (650, 0), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 0), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 0), (850, 1), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 1), (920, 1), (930, 1), (940, 0), (950, 1), (960, 1), (970, 1), (980, 0), (990, 0), (1000, 1), (1010, 0), (1020, 1), (1030, 1), (1040, 1), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 0), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 0), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 1), (1590, 0), (1600, 0), (1610, 0), (1620, 1), (1630, 1), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 1), (1690, 1), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 1), (1770, 1), (1780, 1), (1790, 0), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 0), (1870, 0), (1880, 0), (1890, 1), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1)]
Vdin0_30  din0_30  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 0.0v 269.495n 0.0v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 1.8v 479.495n 1.8v 479.505n 0.0v 489.495n 0.0v 489.505n 1.8v 499.495n 1.8v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 1.8v 529.495n 1.8v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 0.0v 609.495n 0.0v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 0.0v 779.495n 0.0v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 0.0v 849.495n 0.0v 849.505n 1.8v 859.495n 1.8v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 0.0v 949.495n 0.0v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 1.8v 1009.495n 1.8v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 1), (70, 1), (80, 1), (90, 0), (100, 0), (110, 1), (120, 1), (130, 1), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 0), (260, 1), (270, 0), (280, 1), (290, 1), (300, 1), (310, 1), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 1), (400, 1), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 0), (490, 0), (500, 0), (510, 0), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 1), (580, 0), (590, 1), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 0), (920, 0), (930, 1), (940, 0), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 0), (1010, 0), (1020, 0), (1030, 1), (1040, 1), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 1), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 1), (1360, 0), (1370, 0), (1380, 1), (1390, 1), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 0), (1550, 0), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 0), (1630, 0), (1640, 1), (1650, 1), (1660, 0), (1670, 0), (1680, 1), (1690, 1), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 0), (1810, 1), (1820, 1), (1830, 1), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 1), (1900, 0), (1910, 0), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 0), (1980, 0), (1990, 1), (2000, 1), (2010, 0), (2020, 0), (2030, 0)]
Vdin0_31  din0_31  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 0.0v 259.495n 0.0v 259.505n 1.8v 269.495n 1.8v 269.505n 0.0v 279.495n 0.0v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 0.0v 589.495n 0.0v 589.505n 1.8v 599.495n 1.8v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 1.8v 939.495n 1.8v 939.505n 0.0v 949.495n 0.0v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 1), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 0), (210, 0), (220, 0), (230, 0), (240, 1), (250, 0), (260, 0), (270, 0), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 1), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 1), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 0), (850, 0), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 0), (920, 0), (930, 0), (940, 0), (950, 1), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 1), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 0), (1160, 0), (1170, 1), (1180, 0), (1190, 0), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 1), (1520, 1), (1530, 1), (1540, 0), (1550, 0), (1560, 1), (1570, 1), (1580, 1), (1590, 0), (1600, 0), (1610, 0), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 0), (1850, 0), (1860, 0), (1870, 1), (1880, 1), (1890, 0), (1900, 1), (1910, 1), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 1), (2020, 1), (2030, 1)]
Vdin0_32  din0_32  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 1.8v 249.495n 1.8v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 1.8v 599.495n 1.8v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 1.8v 959.495n 1.8v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 1), (100, 1), (110, 0), (120, 0), (130, 0), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 0), (260, 1), (270, 0), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 0), (360, 0), (370, 0), (380, 0), (390, 1), (400, 1), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 0), (500, 0), (510, 0), (520, 1), (530, 0), (540, 0), (550, 0), (560, 0), (570, 1), (580, 0), (590, 0), (600, 1), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 1), (850, 1), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 1), (940, 1), (950, 0), (960, 0), (970, 0), (980, 0), (990, 1), (1000, 1), (1010, 0), (1020, 1), (1030, 0), (1040, 0), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 0), (1400, 1), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 0), (1590, 1), (1600, 0), (1610, 0), (1620, 1), (1630, 0), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 0), (1810, 1), (1820, 1), (1830, 1), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 1), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 1), (2000, 1), (2010, 0), (2020, 0), (2030, 0)]
Vdin0_33  din0_33  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 0.0v 259.495n 0.0v 259.505n 1.8v 269.495n 1.8v 269.505n 0.0v 279.495n 0.0v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 1.8v 529.495n 1.8v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 1.8v 579.495n 1.8v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 1.8v 609.495n 1.8v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 1), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 1), (260, 0), (270, 0), (280, 1), (290, 1), (300, 1), (310, 1), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 1), (400, 1), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 0), (480, 0), (490, 0), (500, 1), (510, 1), (520, 1), (530, 0), (540, 0), (550, 0), (560, 0), (570, 1), (580, 1), (590, 0), (600, 1), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 0), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 0), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 0), (920, 0), (930, 0), (940, 0), (950, 1), (960, 1), (970, 1), (980, 0), (990, 1), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 0), (1170, 1), (1180, 0), (1190, 0), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 0), (1290, 0), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 0), (1390, 1), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 1), (1610, 1), (1620, 0), (1630, 1), (1640, 0), (1650, 0), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 0), (1910, 0), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 0), (1980, 0), (1990, 1), (2000, 1), (2010, 1), (2020, 0), (2030, 0)]
Vdin0_34  din0_34  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 1.8v 59.495n 1.8v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 1.8v 259.495n 1.8v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 0.0v 599.495n 0.0v 599.505n 1.8v 609.495n 1.8v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 0.0v 779.495n 0.0v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 0.0v 849.495n 0.0v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 0.0v 989.495n 0.0v 989.505n 1.8v 999.495n 1.8v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 0), (50, 1), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 1), (260, 1), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 1), (500, 0), (510, 0), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 1), (580, 0), (590, 0), (600, 0), (610, 1), (620, 1), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 1), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 1), (940, 0), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 1), (1160, 0), (1170, 1), (1180, 0), (1190, 0), (1200, 0), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 1), (1360, 0), (1370, 0), (1380, 1), (1390, 1), (1400, 0), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 0), (1460, 1), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 1), (1590, 0), (1600, 1), (1610, 1), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 1), (1810, 0), (1820, 0), (1830, 0), (1840, 1), (1850, 1), (1860, 1), (1870, 0), (1880, 0), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 0), (2000, 0), (2010, 0), (2020, 1), (2030, 1)]
Vdin0_35  din0_35  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 0.0v 49.495n 0.0v 49.505n 1.8v 59.495n 1.8v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 1.8v 499.495n 1.8v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 1.8v 719.495n 1.8v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 1.8v 939.495n 1.8v 939.505n 0.0v 949.495n 0.0v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 0), (50, 0), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 1), (270, 0), (280, 1), (290, 1), (300, 1), (310, 1), (320, 0), (330, 0), (340, 0), (350, 1), (360, 1), (370, 1), (380, 1), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 1), (510, 1), (520, 0), (530, 1), (540, 1), (550, 1), (560, 1), (570, 0), (580, 0), (590, 1), (600, 1), (610, 0), (620, 0), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 0), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 0), (920, 0), (930, 1), (940, 0), (950, 0), (960, 0), (970, 0), (980, 1), (990, 1), (1000, 0), (1010, 0), (1020, 1), (1030, 1), (1040, 1), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 1), (1160, 1), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 1), (1370, 1), (1380, 0), (1390, 0), (1400, 1), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 1), (1460, 0), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 0), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 1), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 1), (1900, 1), (1910, 1), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 1), (1980, 1), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0)]
Vdin0_36  din0_36  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 1.8v 269.495n 1.8v 269.505n 0.0v 279.495n 0.0v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 0.0v 529.495n 0.0v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 0.0v 859.495n 0.0v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 1.8v 939.495n 1.8v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 0), (60, 1), (70, 1), (80, 1), (90, 0), (100, 0), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 1), (290, 1), (300, 1), (310, 1), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 1), (400, 1), (410, 1), (420, 1), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 1), (500, 0), (510, 0), (520, 1), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 1), (590, 0), (600, 1), (610, 0), (620, 0), (630, 1), (640, 1), (650, 1), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 1), (850, 0), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 0), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 0), (1010, 0), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 0), (1170, 1), (1180, 0), (1190, 0), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 0), (1290, 0), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 0), (1360, 0), (1370, 0), (1380, 1), (1390, 1), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 1), (1640, 0), (1650, 0), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 1), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 1), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 1), (1980, 1), (1990, 0), (2000, 0), (2010, 0), (2020, 1), (2030, 1)]
Vdin0_37  din0_37  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 0.0v 59.495n 0.0v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 1.8v 499.495n 1.8v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 1.8v 529.495n 1.8v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 1.8v 589.495n 1.8v 589.505n 0.0v 599.495n 0.0v 599.505n 1.8v 609.495n 1.8v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 1.8v 849.495n 1.8v 849.505n 0.0v 859.495n 0.0v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 0.0v 939.495n 0.0v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 0), (60, 0), (70, 0), (80, 0), (90, 1), (100, 1), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 0), (260, 1), (270, 0), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 0), (360, 0), (370, 0), (380, 0), (390, 1), (400, 1), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 0), (480, 1), (490, 1), (500, 1), (510, 1), (520, 0), (530, 1), (540, 1), (550, 1), (560, 1), (570, 1), (580, 1), (590, 0), (600, 1), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 0), (940, 1), (950, 1), (960, 0), (970, 0), (980, 1), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 0), (1170, 0), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 0), (1460, 0), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 0), (1570, 0), (1580, 0), (1590, 1), (1600, 0), (1610, 0), (1620, 1), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 1), (1690, 1), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 0), (1800, 0), (1810, 1), (1820, 1), (1830, 1), (1840, 0), (1850, 0), (1860, 1), (1870, 1), (1880, 1), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 0), (2020, 0), (2030, 0)]
Vdin0_38  din0_38  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 0.0v 259.495n 0.0v 259.505n 1.8v 269.495n 1.8v 269.505n 0.0v 279.495n 0.0v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 0.0v 479.495n 0.0v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 0.0v 529.495n 0.0v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 0.0v 599.495n 0.0v 599.505n 1.8v 609.495n 1.8v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 0.0v 939.495n 0.0v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 1.8v 989.495n 1.8v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 0), (50, 1), (60, 1), (70, 1), (80, 1), (90, 0), (100, 0), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 0), (250, 0), (260, 1), (270, 1), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 1), (360, 1), (370, 1), (380, 1), (390, 0), (400, 0), (410, 0), (420, 0), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 0), (500, 0), (510, 0), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 1), (580, 0), (590, 1), (600, 0), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 0), (680, 0), (690, 0), (700, 0), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 1), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 1), (920, 1), (930, 0), (940, 0), (950, 1), (960, 1), (970, 1), (980, 0), (990, 1), (1000, 1), (1010, 0), (1020, 1), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 1), (1160, 0), (1170, 1), (1180, 0), (1190, 0), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 0), (1460, 0), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 0), (1550, 0), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 0), (1670, 0), (1680, 1), (1690, 1), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 1), (1750, 1), (1760, 0), (1770, 0), (1780, 0), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 0), (1870, 0), (1880, 0), (1890, 1), (1900, 1), (1910, 1), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 1), (1980, 1), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0)]
Vdin0_39  din0_39  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 0.0v 49.495n 0.0v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 0.0v 589.495n 0.0v 589.505n 1.8v 599.495n 1.8v 599.505n 0.0v 609.495n 0.0v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 1.8v 849.495n 1.8v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 0.0v 989.495n 0.0v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 1), (50, 1), (60, 1), (70, 1), (80, 1), (90, 0), (100, 0), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 0), (210, 0), (220, 0), (230, 0), (240, 1), (250, 1), (260, 0), (270, 0), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 0), (400, 0), (410, 0), (420, 0), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 0), (490, 1), (500, 0), (510, 0), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 0), (580, 0), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 0), (670, 1), (680, 1), (690, 1), (700, 1), (710, 0), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 1), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 0), (920, 0), (930, 0), (940, 0), (950, 1), (960, 1), (970, 1), (980, 1), (990, 0), (1000, 1), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 1), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 0), (1370, 0), (1380, 0), (1390, 1), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 1), (1690, 1), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 1), (1750, 1), (1760, 0), (1770, 0), (1780, 0), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 1), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 1), (2030, 1)]
Vdin0_40  din0_40  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 0.0v 489.495n 0.0v 489.505n 1.8v 499.495n 1.8v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 0.0v 669.495n 0.0v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 0.0v 719.495n 0.0v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 0.0v 999.495n 0.0v 999.505n 1.8v 1009.495n 1.8v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 0), (50, 1), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 0), (260, 0), (270, 1), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 1), (360, 1), (370, 1), (380, 1), (390, 0), (400, 0), (410, 0), (420, 0), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 0), (490, 0), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 0), (580, 1), (590, 1), (600, 1), (610, 0), (620, 0), (630, 1), (640, 1), (650, 1), (660, 1), (670, 0), (680, 0), (690, 0), (700, 0), (710, 1), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 1), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 1), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 0), (990, 1), (1000, 1), (1010, 0), (1020, 0), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 0), (1160, 0), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 1), (1290, 1), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 1), (1550, 1), (1560, 0), (1570, 0), (1580, 0), (1590, 1), (1600, 0), (1610, 0), (1620, 1), (1630, 0), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 1), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 0), (2020, 0), (2030, 0)]
Vdin0_41  din0_41  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 0.0v 49.495n 0.0v 49.505n 1.8v 59.495n 1.8v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 1.8v 279.495n 1.8v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 0.0v 579.495n 0.0v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 1.8v 719.495n 1.8v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 1.8v 779.495n 1.8v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 1.8v 859.495n 1.8v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 0.0v 989.495n 0.0v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 1), (50, 1), (60, 0), (70, 0), (80, 0), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 1), (500, 1), (510, 1), (520, 0), (530, 1), (540, 1), (550, 1), (560, 1), (570, 0), (580, 1), (590, 0), (600, 0), (610, 1), (620, 1), (630, 0), (640, 0), (650, 0), (660, 0), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 0), (780, 1), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 0), (950, 1), (960, 1), (970, 1), (980, 1), (990, 0), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 0), (1180, 0), (1190, 0), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 0), (1390, 0), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 0), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 0), (1550, 0), (1560, 1), (1570, 1), (1580, 0), (1590, 0), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 1), (1690, 1), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 1), (1850, 1), (1860, 1), (1870, 0), (1880, 0), (1890, 0), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 0), (1980, 0), (1990, 1), (2000, 1), (2010, 0), (2020, 0), (2030, 0)]
Vdin0_42  din0_42  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 0.0v 529.495n 0.0v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 0.0v 579.495n 0.0v 579.505n 1.8v 589.495n 1.8v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 0.0v 779.495n 0.0v 779.505n 1.8v 789.495n 1.8v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 0.0v 949.495n 0.0v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 0.0v 999.495n 0.0v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 1), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 0), (250, 0), (260, 0), (270, 0), (280, 1), (290, 1), (300, 1), (310, 1), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 1), (400, 1), (410, 1), (420, 1), (430, 0), (440, 0), (450, 0), (460, 0), (470, 1), (480, 1), (490, 0), (500, 0), (510, 0), (520, 0), (530, 1), (540, 1), (550, 1), (560, 1), (570, 0), (580, 0), (590, 1), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 1), (780, 1), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 0), (920, 0), (930, 1), (940, 1), (950, 0), (960, 0), (970, 0), (980, 1), (990, 1), (1000, 1), (1010, 0), (1020, 0), (1030, 1), (1040, 1), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 1), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 1), (1460, 1), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 1), (1570, 1), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 1), (1850, 1), (1860, 1), (1870, 0), (1880, 0), (1890, 1), (1900, 0), (1910, 0), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 0), (1980, 0), (1990, 1), (2000, 1), (2010, 1), (2020, 0), (2030, 0)]
Vdin0_43  din0_43  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 1.8v 599.495n 1.8v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 1), (50, 1), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 1), (120, 1), (130, 1), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 1), (210, 1), (220, 1), (230, 1), (240, 0), (250, 1), (260, 1), (270, 1), (280, 0), (290, 0), (300, 0), (310, 0), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 1), (410, 1), (420, 1), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 1), (580, 1), (590, 1), (600, 0), (610, 1), (620, 1), (630, 0), (640, 0), (650, 0), (660, 0), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 1), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 1), (850, 1), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 1), (920, 1), (930, 0), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 0), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 1), (1290, 1), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 1), (1750, 1), (1760, 0), (1770, 0), (1780, 0), (1790, 1), (1800, 1), (1810, 0), (1820, 0), (1830, 0), (1840, 1), (1850, 1), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 1), (2020, 0), (2030, 0)]
Vdin0_44  din0_44  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 0.0v 249.495n 0.0v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 0.0v 609.495n 0.0v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 1.8v 789.495n 1.8v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 0.0v 939.495n 0.0v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 0), (260, 0), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 1), (440, 1), (450, 1), (460, 1), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 1), (580, 0), (590, 0), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 1), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 1), (850, 0), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 0), (920, 0), (930, 0), (940, 0), (950, 1), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 0), (1160, 0), (1170, 1), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 1), (1290, 1), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 1), (1370, 1), (1380, 0), (1390, 1), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 0), (1610, 0), (1620, 1), (1630, 0), (1640, 1), (1650, 1), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 1), (1870, 0), (1880, 0), (1890, 1), (1900, 1), (1910, 1), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 1), (1980, 1), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0)]
Vdin0_45  din0_45  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 1.8v 789.495n 1.8v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 1.8v 849.495n 1.8v 849.505n 0.0v 859.495n 0.0v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 1.8v 959.495n 1.8v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 0), (50, 1), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 1), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 1), (590, 0), (600, 0), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 0), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 0), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 0), (850, 1), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 1), (920, 1), (930, 0), (940, 0), (950, 0), (960, 1), (970, 1), (980, 0), (990, 0), (1000, 0), (1010, 1), (1020, 1), (1030, 0), (1040, 0), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 1), (1170, 0), (1180, 1), (1190, 1), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 1), (1360, 1), (1370, 1), (1380, 0), (1390, 1), (1400, 0), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 1), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 1), (1750, 1), (1760, 0), (1770, 0), (1780, 0), (1790, 1), (1800, 1), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 1), (1880, 1), (1890, 0), (1900, 0), (1910, 0), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 0), (2000, 0), (2010, 1), (2020, 1), (2030, 1)]
Vdin0_46  din0_46  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 0.0v 49.495n 0.0v 49.505n 1.8v 59.495n 1.8v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 1.8v 529.495n 1.8v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 1.8v 589.495n 1.8v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 0.0v 719.495n 0.0v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 0.0v 789.495n 0.0v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 0.0v 849.495n 0.0v 849.505n 1.8v 859.495n 1.8v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 0), (50, 1), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 0), (270, 0), (280, 1), (290, 1), (300, 1), (310, 1), (320, 0), (330, 0), (340, 0), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 1), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 1), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 1), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 0), (940, 0), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 0), (1010, 1), (1020, 0), (1030, 0), (1040, 0), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 0), (1160, 1), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 1), (1360, 1), (1370, 1), (1380, 0), (1390, 0), (1400, 1), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 0), (1520, 0), (1530, 0), (1540, 1), (1550, 1), (1560, 0), (1570, 0), (1580, 1), (1590, 0), (1600, 0), (1610, 0), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 0), (1670, 0), (1680, 1), (1690, 1), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 1), (1880, 1), (1890, 0), (1900, 0), (1910, 0), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0)]
Vdin0_47  din0_47  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 0.0v 49.495n 0.0v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 1.8v 589.495n 1.8v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 1.8v 779.495n 1.8v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 0.0v 1009.495n 0.0v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 1), (50, 0), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 0), (120, 0), (130, 0), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 0), (210, 0), (220, 0), (230, 0), (240, 1), (250, 0), (260, 0), (270, 1), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 1), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 0), (490, 0), (500, 1), (510, 1), (520, 0), (530, 1), (540, 1), (550, 1), (560, 1), (570, 0), (580, 1), (590, 0), (600, 0), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 0), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 0), (850, 0), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 0), (920, 0), (930, 1), (940, 1), (950, 1), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 1), (1010, 1), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 0), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 1), (1360, 1), (1370, 1), (1380, 0), (1390, 1), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 0), (1550, 0), (1560, 1), (1570, 1), (1580, 0), (1590, 0), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 0), (1750, 0), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 0), (1810, 1), (1820, 1), (1830, 1), (1840, 0), (1850, 0), (1860, 1), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 1), (2030, 1)]
Vdin0_48  din0_48  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 1.8v 49.495n 1.8v 49.505n 0.0v 59.495n 0.0v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 1.8v 249.495n 1.8v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 1.8v 279.495n 1.8v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 0.0v 529.495n 0.0v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 0.0v 579.495n 0.0v 579.505n 1.8v 589.495n 1.8v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 0.0v 789.495n 0.0v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 0), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 0), (120, 0), (130, 0), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 0), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 1), (480, 0), (490, 0), (500, 0), (510, 0), (520, 1), (530, 0), (540, 0), (550, 0), (560, 0), (570, 1), (580, 0), (590, 0), (600, 1), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 1), (670, 0), (680, 0), (690, 0), (700, 0), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 0), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 0), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 0), (940, 0), (950, 0), (960, 1), (970, 1), (980, 1), (990, 0), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 0), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 0), (1520, 0), (1530, 0), (1540, 1), (1550, 1), (1560, 0), (1570, 0), (1580, 1), (1590, 0), (1600, 1), (1610, 1), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 1), (1850, 1), (1860, 0), (1870, 1), (1880, 1), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 1), (2020, 0), (2030, 0)]
Vdin0_49  din0_49  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 0.0v 59.495n 0.0v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 0.0v 259.495n 0.0v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 1.8v 479.495n 1.8v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 1.8v 529.495n 1.8v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 1.8v 579.495n 1.8v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 1.8v 609.495n 1.8v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 1.8v 669.495n 1.8v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 0.0v 789.495n 0.0v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 0.0v 859.495n 0.0v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 0.0v 999.495n 0.0v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 0), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 0), (120, 0), (130, 0), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 0), (250, 0), (260, 1), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 1), (330, 1), (340, 1), (350, 0), (360, 0), (370, 0), (380, 0), (390, 1), (400, 1), (410, 1), (420, 1), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 1), (490, 1), (500, 1), (510, 1), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 1), (580, 1), (590, 1), (600, 0), (610, 0), (620, 0), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 0), (960, 1), (970, 1), (980, 0), (990, 1), (1000, 0), (1010, 1), (1020, 1), (1030, 0), (1040, 0), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 0), (1160, 0), (1170, 1), (1180, 0), (1190, 0), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 0), (1290, 0), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 0), (1360, 1), (1370, 1), (1380, 0), (1390, 0), (1400, 1), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 1), (1460, 1), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 1), (1610, 1), (1620, 1), (1630, 0), (1640, 1), (1650, 1), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 0), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 0), (2000, 0), (2010, 0), (2020, 1), (2030, 1)]
Vdin0_50  din0_50  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 0.0v 59.495n 0.0v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 1.8v 269.495n 1.8v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 0.0v 959.495n 0.0v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 0.0v 989.495n 0.0v 989.505n 1.8v 999.495n 1.8v 999.505n 0.0v 1009.495n 0.0v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 0), (50, 0), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 0), (330, 0), (340, 0), (350, 1), (360, 1), (370, 1), (380, 1), (390, 0), (400, 0), (410, 0), (420, 0), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 1), (580, 0), (590, 0), (600, 1), (610, 0), (620, 0), (630, 1), (640, 1), (650, 1), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 0), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 0), (1170, 1), (1180, 1), (1190, 1), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 1), (1360, 0), (1370, 0), (1380, 0), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 1), (1570, 1), (1580, 0), (1590, 1), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 0), (1690, 0), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 1), (1850, 1), (1860, 0), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 0), (2000, 0), (2010, 1), (2020, 1), (2030, 1)]
Vdin0_51  din0_51  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 1.8v 579.495n 1.8v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 1.8v 609.495n 1.8v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 0.0v 939.495n 0.0v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 1), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 1), (120, 1), (130, 1), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 1), (250, 1), (260, 0), (270, 0), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 0), (360, 0), (370, 0), (380, 0), (390, 1), (400, 1), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 0), (480, 0), (490, 1), (500, 1), (510, 1), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 1), (580, 1), (590, 0), (600, 0), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 0), (850, 0), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 0), (920, 0), (930, 0), (940, 1), (950, 0), (960, 0), (970, 0), (980, 0), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 1), (1190, 1), (1200, 1), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 1), (1360, 0), (1370, 0), (1380, 1), (1390, 0), (1400, 1), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 0), (1520, 0), (1530, 0), (1540, 1), (1550, 1), (1560, 0), (1570, 0), (1580, 0), (1590, 1), (1600, 0), (1610, 0), (1620, 1), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 1), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 1), (1850, 1), (1860, 0), (1870, 0), (1880, 0), (1890, 1), (1900, 1), (1910, 1), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 1), (1980, 1), (1990, 0), (2000, 0), (2010, 0), (2020, 1), (2030, 1)]
Vdin0_52  din0_52  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 1.8v 49.495n 1.8v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 1.8v 949.495n 1.8v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 0), (60, 1), (70, 1), (80, 1), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 0), (250, 0), (260, 1), (270, 1), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 1), (360, 1), (370, 1), (380, 1), (390, 0), (400, 0), (410, 0), (420, 0), (430, 1), (440, 1), (450, 1), (460, 1), (470, 0), (480, 1), (490, 0), (500, 1), (510, 1), (520, 1), (530, 0), (540, 0), (550, 0), (560, 0), (570, 1), (580, 0), (590, 1), (600, 1), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 1), (680, 1), (690, 1), (700, 1), (710, 0), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 1), (850, 1), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 1), (920, 1), (930, 1), (940, 1), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 0), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 1), (1370, 1), (1380, 0), (1390, 1), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 1), (1520, 1), (1530, 1), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 1), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 1), (1810, 0), (1820, 0), (1830, 0), (1840, 1), (1850, 1), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 1), (1910, 1), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 0), (2020, 1), (2030, 1)]
Vdin0_53  din0_53  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 0.0v 59.495n 0.0v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 0.0v 479.495n 0.0v 479.505n 1.8v 489.495n 1.8v 489.505n 0.0v 499.495n 0.0v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 1.8v 579.495n 1.8v 579.505n 0.0v 589.495n 0.0v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 0.0v 719.495n 0.0v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 1), (60, 0), (70, 0), (80, 0), (90, 1), (100, 1), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 1), (250, 1), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 0), (400, 0), (410, 0), (420, 0), (430, 1), (440, 1), (450, 1), (460, 1), (470, 0), (480, 0), (490, 0), (500, 1), (510, 1), (520, 0), (530, 1), (540, 1), (550, 1), (560, 1), (570, 1), (580, 1), (590, 0), (600, 1), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 1), (850, 0), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 1), (970, 1), (980, 0), (990, 1), (1000, 0), (1010, 1), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 1), (1170, 0), (1180, 0), (1190, 0), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 1), (1590, 1), (1600, 0), (1610, 0), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 0), (1670, 0), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 0), (1750, 0), (1760, 1), (1770, 1), (1780, 1), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 1), (1850, 1), (1860, 1), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 0), (2020, 1), (2030, 1)]
Vdin0_54  din0_54  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 1.8v 59.495n 1.8v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 0.0v 529.495n 0.0v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 0.0v 599.495n 0.0v 599.505n 1.8v 609.495n 1.8v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 1.8v 849.495n 1.8v 849.505n 0.0v 859.495n 0.0v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 0.0v 989.495n 0.0v 989.505n 1.8v 999.495n 1.8v 999.505n 0.0v 1009.495n 0.0v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 1), (60, 0), (70, 0), (80, 0), (90, 1), (100, 1), (110, 0), (120, 0), (130, 0), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 0), (210, 0), (220, 0), (230, 0), (240, 1), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 0), (400, 0), (410, 0), (420, 0), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 0), (490, 0), (500, 1), (510, 1), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 1), (610, 0), (620, 0), (630, 1), (640, 1), (650, 1), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 1), (950, 0), (960, 1), (970, 1), (980, 0), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 0), (1040, 0), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 1), (1160, 1), (1170, 0), (1180, 1), (1190, 1), (1200, 1), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 0), (1360, 1), (1370, 1), (1380, 1), (1390, 0), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 1), (1520, 1), (1530, 1), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 1), (1590, 0), (1600, 1), (1610, 1), (1620, 0), (1630, 1), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 0), (1750, 0), (1760, 1), (1770, 1), (1780, 1), (1790, 0), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 0), (1850, 0), (1860, 1), (1870, 0), (1880, 0), (1890, 1), (1900, 0), (1910, 0), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 0), (1980, 0), (1990, 1), (2000, 1), (2010, 0), (2020, 0), (2030, 0)]
Vdin0_55  din0_55  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 1.8v 249.495n 1.8v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 1.8v 609.495n 1.8v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 1.8v 949.495n 1.8v 949.505n 0.0v 959.495n 0.0v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 0.0v 989.495n 0.0v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 0), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 0), (260, 1), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 1), (330, 1), (340, 1), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 1), (490, 0), (500, 1), (510, 1), (520, 0), (530, 1), (540, 1), (550, 1), (560, 1), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 0), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 0), (850, 1), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 1), (920, 1), (930, 1), (940, 0), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 0), (1030, 0), (1040, 0), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 0), (1160, 1), (1170, 1), (1180, 0), (1190, 0), (1200, 0), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 0), (1290, 0), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 0), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 1), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 1), (1550, 1), (1560, 0), (1570, 0), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 1), (1810, 0), (1820, 0), (1830, 0), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 0), (1900, 0), (1910, 0), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 0), (2000, 0), (2010, 0), (2020, 1), (2030, 1)]
Vdin0_56  din0_56  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 0.0v 59.495n 0.0v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 0.0v 259.495n 0.0v 259.505n 1.8v 269.495n 1.8v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 1.8v 489.495n 1.8v 489.505n 0.0v 499.495n 0.0v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 0.0v 529.495n 0.0v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 0.0v 719.495n 0.0v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 0.0v 849.495n 0.0v 849.505n 1.8v 859.495n 1.8v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 0.0v 949.495n 0.0v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 1), (70, 1), (80, 1), (90, 0), (100, 0), (110, 1), (120, 1), (130, 1), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 1), (210, 1), (220, 1), (230, 1), (240, 0), (250, 1), (260, 1), (270, 0), (280, 1), (290, 1), (300, 1), (310, 1), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 1), (480, 1), (490, 1), (500, 0), (510, 0), (520, 1), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 0), (670, 1), (680, 1), (690, 1), (700, 1), (710, 0), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 0), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 0), (850, 0), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 0), (940, 0), (950, 1), (960, 1), (970, 1), (980, 1), (990, 0), (1000, 1), (1010, 0), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 0), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 0), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 1), (1370, 1), (1380, 0), (1390, 1), (1400, 0), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 1), (1640, 1), (1650, 1), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 0), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 0), (1880, 0), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 1), (2020, 0), (2030, 0)]
Vdin0_57  din0_57  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 0.0v 249.495n 0.0v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 0.0v 279.495n 0.0v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 1.8v 529.495n 1.8v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 0.0v 669.495n 0.0v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 0.0v 719.495n 0.0v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 0.0v 779.495n 0.0v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 0.0v 999.495n 0.0v 999.505n 1.8v 1009.495n 1.8v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 0), (50, 1), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 1), (210, 1), (220, 1), (230, 1), (240, 0), (250, 0), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 1), (480, 1), (490, 0), (500, 0), (510, 0), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 0), (580, 0), (590, 0), (600, 1), (610, 1), (620, 1), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 0), (920, 0), (930, 1), (940, 1), (950, 0), (960, 1), (970, 1), (980, 1), (990, 0), (1000, 1), (1010, 0), (1020, 0), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 0), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 1), (1360, 1), (1370, 1), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 1), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 0), (1630, 0), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 0), (1750, 0), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 1), (1880, 1), (1890, 1), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0)]
Vdin0_58  din0_58  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 0.0v 49.495n 0.0v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 0.0v 959.495n 0.0v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 0.0v 999.495n 0.0v 999.505n 1.8v 1009.495n 1.8v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 1), (50, 1), (60, 1), (70, 1), (80, 1), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 0), (210, 0), (220, 0), (230, 0), (240, 1), (250, 1), (260, 0), (270, 0), (280, 1), (290, 1), (300, 1), (310, 1), (320, 0), (330, 0), (340, 0), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 1), (410, 1), (420, 1), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 1), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 1), (580, 0), (590, 0), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 1), (780, 0), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 0), (1010, 1), (1020, 1), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 0), (1160, 0), (1170, 0), (1180, 1), (1190, 1), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 0), (1370, 0), (1380, 1), (1390, 1), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 1), (1460, 1), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 0), (1800, 0), (1810, 1), (1820, 1), (1830, 1), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0)]
Vdin0_59  din0_59  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 1.8v 489.495n 1.8v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 1.8v 579.495n 1.8v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 1.8v 779.495n 1.8v 779.505n 0.0v 789.495n 0.0v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 0.0v 1009.495n 0.0v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 1), (50, 0), (60, 0), (70, 0), (80, 0), (90, 1), (100, 1), (110, 0), (120, 0), (130, 0), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 0), (210, 0), (220, 0), (230, 0), (240, 1), (250, 0), (260, 0), (270, 0), (280, 1), (290, 1), (300, 1), (310, 1), (320, 0), (330, 0), (340, 0), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 1), (410, 1), (420, 1), (430, 0), (440, 0), (450, 0), (460, 0), (470, 1), (480, 0), (490, 0), (500, 1), (510, 1), (520, 0), (530, 1), (540, 1), (550, 1), (560, 1), (570, 0), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 0), (640, 0), (650, 0), (660, 0), (670, 1), (680, 1), (690, 1), (700, 1), (710, 0), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 0), (850, 1), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 1), (920, 1), (930, 1), (940, 0), (950, 0), (960, 0), (970, 0), (980, 1), (990, 0), (1000, 1), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 0), (1160, 1), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 0), (1370, 0), (1380, 0), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 0), (1460, 1), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 1), (1520, 1), (1530, 1), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 1), (1600, 0), (1610, 0), (1620, 1), (1630, 1), (1640, 0), (1650, 0), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 0), (1750, 0), (1760, 1), (1770, 1), (1780, 1), (1790, 0), (1800, 0), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 0), (1880, 0), (1890, 0), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 0), (2000, 0), (2010, 1), (2020, 0), (2030, 0)]
Vdin0_60  din0_60  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 1.8v 49.495n 1.8v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 1.8v 249.495n 1.8v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 1.8v 479.495n 1.8v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 0.0v 529.495n 0.0v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 0.0v 579.495n 0.0v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 0.0v 719.495n 0.0v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 0.0v 849.495n 0.0v 849.505n 1.8v 859.495n 1.8v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 1.8v 989.495n 1.8v 989.505n 0.0v 999.495n 0.0v 999.505n 1.8v 1009.495n 1.8v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 1), (60, 1), (70, 1), (80, 1), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 0), (210, 0), (220, 0), (230, 0), (240, 1), (250, 0), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 0), (330, 0), (340, 0), (350, 1), (360, 1), (370, 1), (380, 1), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 1), (480, 0), (490, 0), (500, 0), (510, 0), (520, 1), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 1), (600, 1), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 1), (780, 0), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 0), (850, 0), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 0), (960, 1), (970, 1), (980, 1), (990, 0), (1000, 0), (1010, 0), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 1), (1160, 1), (1170, 0), (1180, 1), (1190, 1), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 1), (1370, 1), (1380, 1), (1390, 0), (1400, 0), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 1), (1570, 1), (1580, 0), (1590, 1), (1600, 0), (1610, 0), (1620, 0), (1630, 1), (1640, 0), (1650, 0), (1660, 1), (1670, 1), (1680, 0), (1690, 0), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 0), (1750, 0), (1760, 1), (1770, 1), (1780, 1), (1790, 0), (1800, 0), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 0), (1880, 0), (1890, 0), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 1), (2020, 1), (2030, 1)]
Vdin0_61  din0_61  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 1.8v 249.495n 1.8v 249.505n 0.0v 259.495n 0.0v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 1.8v 479.495n 1.8v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 1.8v 529.495n 1.8v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 1.8v 779.495n 1.8v 779.505n 0.0v 789.495n 0.0v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 0.0v 959.495n 0.0v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 1), (250, 0), (260, 0), (270, 1), (280, 0), (290, 0), (300, 0), (310, 0), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 1), (480, 0), (490, 0), (500, 0), (510, 0), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 1), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 1), (640, 1), (650, 1), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 0), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 0), (850, 1), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 1), (940, 0), (950, 1), (960, 1), (970, 1), (980, 1), (990, 0), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 0), (1160, 0), (1170, 0), (1180, 1), (1190, 1), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 0), (1400, 1), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 1), (1590, 0), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 1), (1690, 1), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 0), (1850, 0), (1860, 0), (1870, 1), (1880, 1), (1890, 0), (1900, 1), (1910, 1), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 1), (2020, 0), (2030, 0)]
Vdin0_62  din0_62  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 1.8v 249.495n 1.8v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 1.8v 279.495n 1.8v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 1.8v 479.495n 1.8v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 0.0v 779.495n 0.0v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 0.0v 849.495n 0.0v 849.505n 1.8v 859.495n 1.8v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 1.8v 939.495n 1.8v 939.505n 0.0v 949.495n 0.0v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 0.0v 999.495n 0.0v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 1), (120, 1), (130, 1), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 1), (210, 1), (220, 1), (230, 1), (240, 0), (250, 0), (260, 1), (270, 0), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 1), (480, 0), (490, 1), (500, 0), (510, 0), (520, 0), (530, 1), (540, 1), (550, 1), (560, 1), (570, 1), (580, 0), (590, 1), (600, 0), (610, 1), (620, 1), (630, 0), (640, 0), (650, 0), (660, 1), (670, 0), (680, 0), (690, 0), (700, 0), (710, 1), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 1), (970, 1), (980, 0), (990, 0), (1000, 1), (1010, 0), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 0), (1160, 0), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 1), (1360, 1), (1370, 1), (1380, 0), (1390, 1), (1400, 1), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 0), (1640, 1), (1650, 1), (1660, 0), (1670, 0), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 1), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 1), (1870, 0), (1880, 0), (1890, 0), (1900, 1), (1910, 1), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 1), (2000, 1), (2010, 1), (2020, 0), (2030, 0)]
Vdin0_63  din0_63  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 1.8v 269.495n 1.8v 269.505n 0.0v 279.495n 0.0v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 1.8v 479.495n 1.8v 479.505n 0.0v 489.495n 0.0v 489.505n 1.8v 499.495n 1.8v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 0.0v 589.495n 0.0v 589.505n 1.8v 599.495n 1.8v 599.505n 0.0v 609.495n 0.0v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 1.8v 669.495n 1.8v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 1.8v 719.495n 1.8v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 1.8v 1009.495n 1.8v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 1), (50, 1), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 1), (250, 1), (260, 1), (270, 1), (280, 0), (290, 0), (300, 0), (310, 0), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 0), (400, 0), (410, 0), (420, 0), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 1), (580, 1), (590, 1), (600, 0), (610, 1), (620, 1), (630, 0), (640, 0), (650, 0), (660, 0), (670, 1), (680, 1), (690, 1), (700, 1), (710, 0), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 1), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 1), (1010, 0), (1020, 1), (1030, 0), (1040, 0), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 0), (1520, 0), (1530, 0), (1540, 1), (1550, 1), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 1), (1630, 0), (1640, 1), (1650, 1), (1660, 0), (1670, 0), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 0), (1750, 0), (1760, 1), (1770, 1), (1780, 1), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 1), (2020, 0), (2030, 0)]
Vdin0_64  din0_64  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 0.0v 609.495n 0.0v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 0.0v 719.495n 0.0v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 1.8v 1009.495n 1.8v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 1), (50, 1), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 1), (260, 1), (270, 1), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 1), (400, 1), (410, 1), (420, 1), (430, 0), (440, 0), (450, 0), (460, 0), (470, 1), (480, 1), (490, 1), (500, 0), (510, 0), (520, 0), (530, 1), (540, 1), (550, 1), (560, 1), (570, 0), (580, 1), (590, 0), (600, 1), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 1), (670, 0), (680, 0), (690, 0), (700, 0), (710, 1), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 1), (940, 0), (950, 1), (960, 1), (970, 1), (980, 0), (990, 1), (1000, 1), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 1), (1160, 1), (1170, 1), (1180, 0), (1190, 0), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 0), (1360, 0), (1370, 0), (1380, 1), (1390, 0), (1400, 0), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 0), (1460, 0), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 1), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 0), (1750, 0), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 0), (1870, 1), (1880, 1), (1890, 1), (1900, 0), (1910, 0), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 0), (1980, 0), (1990, 1), (2000, 1), (2010, 1), (2020, 0), (2030, 0)]
Vdin0_65  din0_65  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 0.0v 579.495n 0.0v 579.505n 1.8v 589.495n 1.8v 589.505n 0.0v 599.495n 0.0v 599.505n 1.8v 609.495n 1.8v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 1.8v 669.495n 1.8v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 1.8v 719.495n 1.8v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 1.8v 939.495n 1.8v 939.505n 0.0v 949.495n 0.0v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 0.0v 989.495n 0.0v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 0), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 0), (210, 0), (220, 0), (230, 0), (240, 1), (250, 0), (260, 1), (270, 1), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 1), (360, 1), (370, 1), (380, 1), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 1), (580, 1), (590, 0), (600, 1), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 1), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 1), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 1), (850, 1), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 0), (1010, 1), (1020, 0), (1030, 0), (1040, 0), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 0), (1460, 1), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 1), (1550, 1), (1560, 0), (1570, 0), (1580, 0), (1590, 1), (1600, 1), (1610, 1), (1620, 0), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 0), (1750, 0), (1760, 1), (1770, 1), (1780, 1), (1790, 0), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 1), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 1), (2000, 1), (2010, 0), (2020, 0), (2030, 0)]
Vdin0_66  din0_66  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 0.0v 59.495n 0.0v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 1.8v 249.495n 1.8v 249.505n 0.0v 259.495n 0.0v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 0.0v 599.495n 0.0v 599.505n 1.8v 609.495n 1.8v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 1.8v 719.495n 1.8v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 1.8v 779.495n 1.8v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 0.0v 1009.495n 0.0v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 1), (50, 1), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 1), (250, 0), (260, 1), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 1), (400, 1), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 0), (480, 0), (490, 0), (500, 1), (510, 1), (520, 1), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 1), (600, 0), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 0), (960, 0), (970, 0), (980, 0), (990, 1), (1000, 0), (1010, 1), (1020, 0), (1030, 0), (1040, 0), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 1), (1160, 0), (1170, 1), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 0), (1360, 1), (1370, 1), (1380, 1), (1390, 0), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 0), (1570, 0), (1580, 1), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 1), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 0), (1770, 0), (1780, 0), (1790, 1), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 1), (1850, 1), (1860, 1), (1870, 0), (1880, 0), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 0), (1980, 0), (1990, 1), (2000, 1), (2010, 1), (2020, 0), (2030, 0)]
Vdin0_67  din0_67  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 1.8v 249.495n 1.8v 249.505n 0.0v 259.495n 0.0v 259.505n 1.8v 269.495n 1.8v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 1.8v 599.495n 1.8v 599.505n 0.0v 609.495n 0.0v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 1.8v 999.495n 1.8v 999.505n 0.0v 1009.495n 0.0v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 1), (50, 0), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 1), (250, 0), (260, 0), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 0), (330, 0), (340, 0), (350, 1), (360, 1), (370, 1), (380, 1), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 1), (500, 1), (510, 1), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 1), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 1), (920, 1), (930, 0), (940, 0), (950, 1), (960, 0), (970, 0), (980, 1), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 1), (1040, 1), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 1), (1170, 0), (1180, 1), (1190, 1), (1200, 1), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 1), (1520, 1), (1530, 1), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 0), (1750, 0), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 0), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 1), (2020, 0), (2030, 0)]
Vdin0_68  din0_68  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 1.8v 49.495n 1.8v 49.505n 0.0v 59.495n 0.0v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 1.8v 249.495n 1.8v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 1.8v 849.495n 1.8v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 1.8v 959.495n 1.8v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 1.8v 989.495n 1.8v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 1), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 1), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 1), (330, 1), (340, 1), (350, 0), (360, 0), (370, 0), (380, 0), (390, 1), (400, 1), (410, 1), (420, 1), (430, 0), (440, 0), (450, 0), (460, 0), (470, 1), (480, 1), (490, 0), (500, 1), (510, 1), (520, 1), (530, 0), (540, 0), (550, 0), (560, 0), (570, 1), (580, 1), (590, 0), (600, 0), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 0), (940, 1), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 1), (1010, 1), (1020, 0), (1030, 1), (1040, 1), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 1), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 1), (1360, 0), (1370, 0), (1380, 0), (1390, 1), (1400, 1), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 1), (1460, 1), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 0), (1590, 1), (1600, 1), (1610, 1), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 1), (1670, 1), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 1), (1750, 1), (1760, 0), (1770, 0), (1780, 0), (1790, 1), (1800, 1), (1810, 0), (1820, 0), (1830, 0), (1840, 1), (1850, 1), (1860, 1), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1)]
Vdin0_69  din0_69  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 1.8v 269.495n 1.8v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 0.0v 499.495n 0.0v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 0.0v 939.495n 0.0v 939.505n 1.8v 949.495n 1.8v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 1), (100, 1), (110, 0), (120, 0), (130, 0), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 1), (580, 1), (590, 1), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 0), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 1), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 1), (1000, 1), (1010, 1), (1020, 0), (1030, 0), (1040, 0), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 0), (1160, 0), (1170, 1), (1180, 0), (1190, 0), (1200, 1), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 0), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 0), (1520, 0), (1530, 0), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 0), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 0), (1690, 0), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 0), (1770, 0), (1780, 0), (1790, 1), (1800, 1), (1810, 0), (1820, 0), (1830, 0), (1840, 1), (1850, 1), (1860, 0), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 1), (1980, 1), (1990, 0), (2000, 0), (2010, 0), (2020, 1), (2030, 1)]
Vdin0_70  din0_70  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 0.0v 779.495n 0.0v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 1.8v 939.495n 1.8v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 1), (260, 1), (270, 0), (280, 1), (290, 1), (300, 1), (310, 1), (320, 0), (330, 0), (340, 0), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 1), (410, 1), (420, 1), (430, 0), (440, 0), (450, 0), (460, 0), (470, 1), (480, 1), (490, 0), (500, 1), (510, 1), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 1), (590, 0), (600, 0), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 1), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 1), (850, 0), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 0), (960, 0), (970, 0), (980, 1), (990, 1), (1000, 1), (1010, 0), (1020, 1), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 0), (1190, 0), (1200, 0), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 1), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 1), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 1), (1520, 1), (1530, 1), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 1), (1650, 1), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 1), (1770, 1), (1780, 1), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 1), (1870, 0), (1880, 0), (1890, 1), (1900, 0), (1910, 0), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 0), (1980, 0), (1990, 1), (2000, 1), (2010, 0), (2020, 0), (2030, 0)]
Vdin0_71  din0_71  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 0.0v 279.495n 0.0v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 0.0v 499.495n 0.0v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 1.8v 589.495n 1.8v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 1.8v 719.495n 1.8v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 1.8v 849.495n 1.8v 849.505n 0.0v 859.495n 0.0v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 1), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 1), (290, 1), (300, 1), (310, 1), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 1), (400, 1), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 0), (480, 0), (490, 1), (500, 0), (510, 0), (520, 0), (530, 1), (540, 1), (550, 1), (560, 1), (570, 0), (580, 1), (590, 0), (600, 0), (610, 0), (620, 0), (630, 1), (640, 1), (650, 1), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 1), (960, 0), (970, 0), (980, 1), (990, 1), (1000, 0), (1010, 0), (1020, 1), (1030, 1), (1040, 1), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 1), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 1), (1360, 1), (1370, 1), (1380, 0), (1390, 1), (1400, 1), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 1), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 1), (1570, 1), (1580, 0), (1590, 1), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 0), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 1), (2020, 0), (2030, 0)]
Vdin0_72  din0_72  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 1.8v 499.495n 1.8v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 0.0v 579.495n 0.0v 579.505n 1.8v 589.495n 1.8v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 1.8v 959.495n 1.8v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 1), (70, 1), (80, 1), (90, 0), (100, 0), (110, 1), (120, 1), (130, 1), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 0), (270, 0), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 0), (360, 0), (370, 0), (380, 0), (390, 1), (400, 1), (410, 1), (420, 1), (430, 0), (440, 0), (450, 0), (460, 0), (470, 1), (480, 0), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 0), (640, 0), (650, 0), (660, 0), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 1), (780, 0), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 0), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 0), (920, 0), (930, 1), (940, 1), (950, 0), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 0), (1020, 0), (1030, 1), (1040, 1), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 0), (1160, 0), (1170, 1), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 0), (1370, 0), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 1), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 0), (1640, 0), (1650, 0), (1660, 1), (1670, 1), (1680, 0), (1690, 0), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 0), (1750, 0), (1760, 1), (1770, 1), (1780, 1), (1790, 0), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 0), (1850, 0), (1860, 0), (1870, 1), (1880, 1), (1890, 0), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 1), (2020, 0), (2030, 0)]
Vdin0_73  din0_73  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 1.8v 479.495n 1.8v 479.505n 0.0v 489.495n 0.0v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 1.8v 779.495n 1.8v 779.505n 0.0v 789.495n 0.0v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 0.0v 849.495n 0.0v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 0.0v 959.495n 0.0v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 0), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 1), (210, 1), (220, 1), (230, 1), (240, 0), (250, 0), (260, 1), (270, 1), (280, 0), (290, 0), (300, 0), (310, 0), (320, 1), (330, 1), (340, 1), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 0), (580, 1), (590, 0), (600, 1), (610, 0), (620, 0), (630, 1), (640, 1), (650, 1), (660, 1), (670, 0), (680, 0), (690, 0), (700, 0), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 0), (1020, 1), (1030, 1), (1040, 1), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 0), (1160, 1), (1170, 1), (1180, 0), (1190, 0), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 0), (1290, 0), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 0), (1390, 1), (1400, 0), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 1), (1520, 1), (1530, 1), (1540, 0), (1550, 0), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 0), (1610, 0), (1620, 0), (1630, 1), (1640, 1), (1650, 1), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 0), (1750, 0), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 0), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 0), (2020, 0), (2030, 0)]
Vdin0_74  din0_74  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 0.0v 59.495n 0.0v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 0.0v 579.495n 0.0v 579.505n 1.8v 589.495n 1.8v 589.505n 0.0v 599.495n 0.0v 599.505n 1.8v 609.495n 1.8v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 0), (210, 0), (220, 0), (230, 0), (240, 1), (250, 0), (260, 0), (270, 0), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 0), (1570, 0), (1580, 1), (1590, 1), (1600, 0), (1610, 0), (1620, 0), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 1), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 0), (1900, 1), (1910, 1), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 1), (1980, 1), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0)]
Vdin0_75  din0_75  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 1.8v 249.495n 1.8v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 1), (50, 0), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 1), (250, 0), (260, 0), (270, 1), (280, 0), (290, 0), (300, 0), (310, 0), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 0), (400, 0), (410, 0), (420, 0), (430, 1), (440, 1), (450, 1), (460, 1), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 1), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 1), (780, 1), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 0), (920, 0), (930, 0), (940, 1), (950, 0), (960, 1), (970, 1), (980, 1), (990, 0), (1000, 1), (1010, 0), (1020, 1), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 0), (1160, 0), (1170, 0), (1180, 1), (1190, 1), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 1), (1360, 1), (1370, 1), (1380, 0), (1390, 1), (1400, 1), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 1), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 0), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 1), (1690, 1), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 0), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 0), (1880, 0), (1890, 0), (1900, 1), (1910, 1), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 1), (2000, 1), (2010, 1), (2020, 0), (2030, 0)]
Vdin0_76  din0_76  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 1.8v 49.495n 1.8v 49.505n 0.0v 59.495n 0.0v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 1.8v 249.495n 1.8v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 1.8v 279.495n 1.8v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 1.8v 719.495n 1.8v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 1.8v 949.495n 1.8v 949.505n 0.0v 959.495n 0.0v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 0.0v 999.495n 0.0v 999.505n 1.8v 1009.495n 1.8v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 0), (260, 0), (270, 1), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 1), (400, 1), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 0), (580, 1), (590, 1), (600, 0), (610, 0), (620, 0), (630, 1), (640, 1), (650, 1), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 1), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 1), (780, 0), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 0), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 0), (950, 0), (960, 0), (970, 0), (980, 1), (990, 1), (1000, 1), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 0), (1160, 0), (1170, 1), (1180, 0), (1190, 0), (1200, 1), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 0), (1590, 1), (1600, 1), (1610, 1), (1620, 0), (1630, 1), (1640, 0), (1650, 0), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 0), (1750, 0), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 0), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 0), (1880, 0), (1890, 1), (1900, 0), (1910, 0), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 0), (2020, 0), (2030, 0)]
Vdin0_77  din0_77  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 1.8v 279.495n 1.8v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 0.0v 579.495n 0.0v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 1.8v 719.495n 1.8v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 1.8v 779.495n 1.8v 779.505n 0.0v 789.495n 0.0v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 0.0v 849.495n 0.0v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 1), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 1), (120, 1), (130, 1), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 1), (270, 1), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 1), (410, 1), (420, 1), (430, 0), (440, 0), (450, 0), (460, 0), (470, 1), (480, 0), (490, 1), (500, 0), (510, 0), (520, 0), (530, 1), (540, 1), (550, 1), (560, 1), (570, 0), (580, 0), (590, 1), (600, 0), (610, 1), (620, 1), (630, 0), (640, 0), (650, 0), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 1), (780, 1), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 1), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 1), (940, 1), (950, 0), (960, 0), (970, 0), (980, 1), (990, 1), (1000, 1), (1010, 0), (1020, 0), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 1), (1170, 1), (1180, 0), (1190, 0), (1200, 0), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 1), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 0), (1460, 0), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 0), (1520, 0), (1530, 0), (1540, 1), (1550, 1), (1560, 0), (1570, 0), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 1), (1800, 1), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 1), (1870, 1), (1880, 1), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 1), (2030, 1)]
Vdin0_78  din0_78  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 1.8v 49.495n 1.8v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 1.8v 479.495n 1.8v 479.505n 0.0v 489.495n 0.0v 489.505n 1.8v 499.495n 1.8v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 1.8v 599.495n 1.8v 599.505n 0.0v 609.495n 0.0v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 1.8v 849.495n 1.8v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 1), (50, 1), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 0), (330, 0), (340, 0), (350, 1), (360, 1), (370, 1), (380, 1), (390, 0), (400, 0), (410, 0), (420, 0), (430, 1), (440, 1), (450, 1), (460, 1), (470, 0), (480, 0), (490, 0), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 1), (640, 1), (650, 1), (660, 1), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 1), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 1), (920, 1), (930, 0), (940, 1), (950, 0), (960, 1), (970, 1), (980, 0), (990, 1), (1000, 1), (1010, 0), (1020, 0), (1030, 1), (1040, 1), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 1), (1290, 1), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 0), (1400, 1), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 0), (1550, 0), (1560, 1), (1570, 1), (1580, 0), (1590, 1), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 1), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1)]
Vdin0_79  din0_79  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 1.8v 849.495n 1.8v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 0.0v 939.495n 0.0v 939.505n 1.8v 949.495n 1.8v 949.505n 0.0v 959.495n 0.0v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 0.0v 989.495n 0.0v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 1), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 1), (360, 0), (370, 0), (380, 0), (390, 1), (400, 1), (410, 1), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 1), (540, 1), (550, 1), (560, 1), (570, 1), (580, 0), (590, 0), (600, 0), (610, 1), (620, 1), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 1), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 1), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 0), (910, 1), (920, 0), (930, 0), (940, 0), (950, 1), (960, 0), (970, 0), (980, 1), (990, 1), (1000, 1), (1010, 0), (1020, 1), (1030, 1), (1040, 0), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 0), (1120, 0), (1130, 1), (1140, 0), (1150, 1), (1160, 1), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 0), (1260, 1), (1270, 1), (1280, 1), (1290, 0), (1300, 1), (1310, 1), (1320, 1), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 1), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 1), (1440, 1), (1450, 1), (1460, 1), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 1), (1550, 1), (1560, 0), (1570, 1), (1580, 0), (1590, 0), (1600, 1), (1610, 1), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 1), (1680, 1), (1690, 1), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 1), (1750, 1), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 0), (1900, 0), (1910, 0), (1920, 1), (1930, 1), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 1), (2020, 0), (2030, 0)]
Va0_0  a0_0  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 1.8v 269.495n 1.8v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 1.8v 359.495n 1.8v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 1.8v 699.495n 1.8v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 1.8v 779.495n 1.8v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 0.0v 909.495n 0.0v 909.505n 1.8v 919.495n 1.8v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 1.8v 959.495n 1.8v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 1), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 0), (270, 0), (280, 1), (290, 1), (300, 0), (310, 0), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 1), (460, 1), (470, 0), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 0), (560, 0), (570, 0), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 0), (640, 1), (650, 1), (660, 0), (670, 1), (680, 1), (690, 1), (700, 0), (710, 0), (720, 0), (730, 0), (740, 1), (750, 1), (760, 0), (770, 1), (780, 1), (790, 0), (800, 0), (810, 0), (820, 1), (830, 1), (840, 1), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 1), (910, 1), (920, 0), (930, 1), (940, 1), (950, 0), (960, 1), (970, 1), (980, 0), (990, 1), (1000, 0), (1010, 0), (1020, 0), (1030, 1), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 1), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 1), (1170, 0), (1180, 1), (1190, 1), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 1), (1260, 1), (1270, 1), (1280, 0), (1290, 0), (1300, 1), (1310, 0), (1320, 0), (1330, 1), (1340, 1), (1350, 0), (1360, 0), (1370, 0), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 0), (1440, 0), (1450, 1), (1460, 1), (1470, 1), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 1), (1540, 1), (1550, 1), (1560, 0), (1570, 1), (1580, 0), (1590, 1), (1600, 0), (1610, 0), (1620, 0), (1630, 1), (1640, 0), (1650, 0), (1660, 1), (1670, 0), (1680, 1), (1690, 1), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 1), (1810, 0), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 0), (1880, 0), (1890, 1), (1900, 1), (1910, 0), (1920, 0), (1930, 0), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 0), (2000, 1), (2010, 0), (2020, 0), (2030, 0)]
Va0_1  a0_1  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 0.0v 479.495n 0.0v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 0.0v 639.495n 0.0v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 0.0v 669.495n 0.0v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 0.0v 769.495n 0.0v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 0.0v 929.495n 0.0v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 0.0v 959.495n 0.0v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 0.0v 989.495n 0.0v 989.505n 1.8v 999.495n 1.8v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 1), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 0), (360, 1), (370, 1), (380, 1), (390, 0), (400, 0), (410, 0), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 0), (490, 0), (500, 1), (510, 1), (520, 0), (530, 0), (540, 0), (550, 1), (560, 1), (570, 1), (580, 0), (590, 0), (600, 1), (610, 0), (620, 0), (630, 1), (640, 1), (650, 1), (660, 1), (670, 0), (680, 0), (690, 0), (700, 1), (710, 1), (720, 0), (730, 0), (740, 0), (750, 0), (760, 1), (770, 0), (780, 0), (790, 1), (800, 0), (810, 0), (820, 1), (830, 1), (840, 1), (850, 1), (860, 1), (870, 1), (880, 0), (890, 0), (900, 1), (910, 0), (920, 1), (930, 0), (940, 0), (950, 1), (960, 0), (970, 1), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 1), (1030, 0), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 0), (1100, 0), (1110, 0), (1120, 1), (1130, 1), (1140, 1), (1150, 0), (1160, 0), (1170, 0), (1180, 1), (1190, 1), (1200, 0), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 1), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 1), (1380, 0), (1390, 0), (1400, 1), (1410, 0), (1420, 0), (1430, 1), (1440, 1), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 1), (1520, 1), (1530, 1), (1540, 0), (1550, 0), (1560, 1), (1570, 0), (1580, 1), (1590, 0), (1600, 0), (1610, 0), (1620, 1), (1630, 1), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 1), (1910, 1), (1920, 0), (1930, 0), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 0), (2020, 1), (2030, 1)]
Va0_2  a0_2  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 0.0v 359.495n 0.0v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 1.8v 609.495n 1.8v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 1.8v 769.495n 1.8v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 1.8v 799.495n 1.8v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 1.8v 909.495n 1.8v 909.505n 0.0v 919.495n 0.0v 919.505n 1.8v 929.495n 1.8v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 1.8v 959.495n 1.8v 959.505n 0.0v 969.495n 0.0v 969.505n 1.8v 979.495n 1.8v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 1), (50, 1), (60, 1), (70, 1), (80, 1), (90, 0), (100, 0), (110, 1), (120, 1), (130, 0), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 0), (200, 1), (210, 1), (220, 1), (230, 1), (240, 0), (250, 1), (260, 1), (270, 0), (280, 1), (290, 1), (300, 0), (310, 0), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 1), (460, 1), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 1), (560, 1), (570, 1), (580, 0), (590, 0), (600, 1), (610, 1), (620, 1), (630, 0), (640, 1), (650, 1), (660, 0), (670, 0), (680, 0), (690, 1), (700, 0), (710, 1), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 1), (780, 0), (790, 1), (800, 0), (810, 0), (820, 1), (830, 1), (840, 1), (850, 1), (860, 1), (870, 1), (880, 0), (890, 0), (900, 1), (910, 0), (920, 0), (930, 0), (940, 0), (950, 1), (960, 0), (970, 0), (980, 1), (990, 1), (1000, 0), (1010, 0), (1020, 1), (1030, 1), (1040, 0), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 0), (1120, 0), (1130, 1), (1140, 0), (1150, 1), (1160, 1), (1170, 0), (1180, 1), (1190, 1), (1200, 0), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 1), (1320, 1), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 1), (1380, 0), (1390, 0), (1400, 1), (1410, 0), (1420, 0), (1430, 1), (1440, 1), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 1), (1540, 0), (1550, 0), (1560, 1), (1570, 1), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 1), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 1), (1800, 0), (1810, 0), (1820, 1), (1830, 1), (1840, 0), (1850, 0), (1860, 1), (1870, 1), (1880, 1), (1890, 0), (1900, 1), (1910, 0), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 0), (1980, 0), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1)]
Va0_3  a0_3  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 0.0v 139.495n 0.0v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 0.0v 199.495n 0.0v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 0.0v 249.495n 0.0v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 0.0v 279.495n 0.0v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 0.0v 639.495n 0.0v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 1.8v 699.495n 1.8v 699.505n 0.0v 709.495n 0.0v 709.505n 1.8v 719.495n 1.8v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 1.8v 779.495n 1.8v 779.505n 0.0v 789.495n 0.0v 789.505n 1.8v 799.495n 1.8v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 1.8v 909.495n 1.8v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 1.8v 959.495n 1.8v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 1), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 0), (260, 0), (270, 0), (280, 1), (290, 1), (300, 0), (310, 0), (320, 0), (330, 0), (340, 1), (350, 0), (360, 0), (370, 0), (380, 0), (390, 1), (400, 1), (410, 1), (420, 0), (430, 0), (440, 0), (450, 1), (460, 1), (470, 0), (480, 1), (490, 0), (500, 1), (510, 1), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 1), (590, 1), (600, 1), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 1), (670, 0), (680, 0), (690, 0), (700, 0), (710, 1), (720, 1), (730, 1), (740, 0), (750, 0), (760, 0), (770, 1), (780, 0), (790, 1), (800, 1), (810, 1), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 0), (880, 1), (890, 1), (900, 0), (910, 0), (920, 0), (930, 0), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 1), (1100, 1), (1110, 0), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 0), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 0), (1270, 0), (1280, 1), (1290, 1), (1300, 0), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 0), (1360, 0), (1370, 1), (1380, 1), (1390, 1), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 1), (1460, 0), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 0), (1520, 0), (1530, 0), (1540, 1), (1550, 1), (1560, 1), (1570, 0), (1580, 0), (1590, 1), (1600, 0), (1610, 0), (1620, 0), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 0), (1770, 0), (1780, 0), (1790, 1), (1800, 1), (1810, 1), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 1), (1880, 1), (1890, 0), (1900, 1), (1910, 0), (1920, 1), (1930, 1), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 1), (2010, 1), (2020, 0), (2030, 0)]
Va0_4  a0_4  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 1.8v 349.495n 1.8v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 0.0v 479.495n 0.0v 479.505n 1.8v 489.495n 1.8v 489.505n 0.0v 499.495n 0.0v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 1.8v 669.495n 1.8v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 1.8v 779.495n 1.8v 779.505n 0.0v 789.495n 0.0v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 1), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 0), (270, 0), (280, 1), (290, 1), (300, 0), (310, 0), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 1), (460, 1), (470, 1), (480, 0), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 0), (670, 1), (680, 1), (690, 1), (700, 1), (710, 0), (720, 1), (730, 1), (740, 1), (750, 1), (760, 0), (770, 1), (780, 1), (790, 0), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 1), (910, 1), (920, 0), (930, 1), (940, 0), (950, 0), (960, 1), (970, 1), (980, 0), (990, 1), (1000, 0), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 1), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 0), (1290, 1), (1300, 1), (1310, 0), (1320, 1), (1330, 1), (1340, 1), (1350, 0), (1360, 0), (1370, 1), (1380, 1), (1390, 0), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 0), (1460, 0), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 0), (1520, 0), (1530, 1), (1540, 0), (1550, 0), (1560, 0), (1570, 1), (1580, 0), (1590, 0), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 0), (1850, 1), (1860, 1), (1870, 0), (1880, 0), (1890, 1), (1900, 1), (1910, 1), (1920, 0), (1930, 0), (1940, 1), (1950, 1), (1960, 1), (1970, 0), (1980, 0), (1990, 1), (2000, 1), (2010, 0), (2020, 1), (2030, 1)]
Va0_5  a0_5  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 0.0v 489.495n 0.0v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 0.0v 669.495n 0.0v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 0.0v 719.495n 0.0v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 0.0v 769.495n 0.0v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 0.0v 799.495n 0.0v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 0.0v 929.495n 0.0v 929.505n 1.8v 939.495n 1.8v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 0.0v 989.495n 0.0v 989.505n 1.8v 999.495n 1.8v 999.505n 0.0v 1009.495n 0.0v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 1), (300, 1), (310, 1), (320, 0), (330, 0), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 0), (410, 0), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 1), (560, 1), (570, 1), (580, 0), (590, 0), (600, 0), (610, 0), (620, 1), (630, 1), (640, 1), (650, 1), (660, 0), (670, 0), (680, 1), (690, 0), (700, 0), (710, 0), (720, 1), (730, 1), (740, 1), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 1), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 1), (940, 1), (950, 1), (960, 1), (970, 0), (980, 1), (990, 0), (1000, 0), (1010, 1), (1020, 0), (1030, 0), (1040, 0), (1050, 1), (1060, 0), (1070, 0), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 0), (1140, 1), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 0), (1330, 1), (1340, 1), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 0), (1630, 0), (1640, 1), (1650, 1), (1660, 1), (1670, 0), (1680, 1), (1690, 1), (1700, 1), (1710, 0), (1720, 0), (1730, 1), (1740, 1), (1750, 1), (1760, 0), (1770, 0), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 1), (2010, 1), (2020, 1), (2030, 1)]
Va1_0  a1_0  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 1.8v 689.495n 1.8v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 1.8v 839.495n 1.8v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 0.0v 979.495n 0.0v 979.505n 1.8v 989.495n 1.8v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 1), (40, 1), (50, 1), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 1), (380, 1), (390, 0), (400, 1), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 0), (690, 1), (700, 0), (710, 0), (720, 1), (730, 1), (740, 0), (750, 1), (760, 1), (770, 1), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 1), (980, 0), (990, 0), (1000, 0), (1010, 1), (1020, 1), (1030, 0), (1040, 0), (1050, 0), (1060, 1), (1070, 1), (1080, 0), (1090, 0), (1100, 0), (1110, 1), (1120, 1), (1130, 0), (1140, 1), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 1), (1200, 1), (1210, 0), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 0), (1340, 0), (1350, 1), (1360, 0), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 1), (1490, 1), (1500, 0), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 0), (1560, 1), (1570, 1), (1580, 1), (1590, 0), (1600, 0), (1610, 0), (1620, 1), (1630, 0), (1640, 0), (1650, 0), (1660, 1), (1670, 1), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 0), (1860, 0), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1)]
Va1_1  a1_1  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 0.0v 399.495n 0.0v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 0.0v 689.495n 0.0v 689.505n 1.8v 699.495n 1.8v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 0.0v 749.495n 0.0v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 1.8v 979.495n 1.8v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 1), (40, 1), (50, 1), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 0), (380, 0), (390, 1), (400, 1), (410, 1), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 1), (590, 1), (600, 1), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 1), (690, 0), (700, 1), (710, 1), (720, 0), (730, 0), (740, 1), (750, 0), (760, 0), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 0), (840, 1), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 0), (980, 1), (990, 0), (1000, 0), (1010, 0), (1020, 1), (1030, 0), (1040, 1), (1050, 0), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 0), (1120, 0), (1130, 1), (1140, 0), (1150, 0), (1160, 0), (1170, 1), (1180, 1), (1190, 1), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 1), (1330, 0), (1340, 0), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 0), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 1), (1510, 0), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 0), (1570, 0), (1580, 0), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 0), (1640, 1), (1650, 1), (1660, 0), (1670, 0), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 1), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 0), (2010, 0), (2020, 0), (2030, 0)]
Va1_2  a1_2  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 1.8v 689.495n 1.8v 689.505n 0.0v 699.495n 0.0v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 1.8v 749.495n 1.8v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 0.0v 839.495n 0.0v 839.505n 1.8v 849.495n 1.8v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 0.0v 979.495n 0.0v 979.505n 1.8v 989.495n 1.8v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 1), (80, 1), (90, 1), (100, 0), (110, 0), (120, 0), (130, 1), (140, 0), (150, 0), (160, 0), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 1), (300, 1), (310, 1), (320, 0), (330, 0), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 0), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 1), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 0), (620, 1), (630, 1), (640, 1), (650, 1), (660, 0), (670, 0), (680, 1), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 1), (750, 0), (760, 0), (770, 0), (780, 1), (790, 1), (800, 0), (810, 0), (820, 0), (830, 0), (840, 1), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 1), (940, 1), (950, 1), (960, 1), (970, 0), (980, 1), (990, 0), (1000, 0), (1010, 1), (1020, 1), (1030, 0), (1040, 0), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 1), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 0), (1340, 0), (1350, 0), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 0), (1410, 0), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 1), (1510, 1), (1520, 0), (1530, 0), (1540, 0), (1550, 1), (1560, 1), (1570, 1), (1580, 0), (1590, 1), (1600, 1), (1610, 1), (1620, 0), (1630, 0), (1640, 1), (1650, 1), (1660, 0), (1670, 0), (1680, 1), (1690, 1), (1700, 1), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 1), (1860, 1), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 1), (2010, 1), (2020, 1), (2030, 1)]
Va1_3  a1_3  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 1.8v 139.495n 1.8v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 0.0v 409.495n 0.0v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 0.0v 619.495n 0.0v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 1.8v 689.495n 1.8v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 1.8v 749.495n 1.8v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 1.8v 849.495n 1.8v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 0.0v 979.495n 0.0v 979.505n 1.8v 989.495n 1.8v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 1), (40, 1), (50, 1), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 0), (190, 0), (200, 0), (210, 0), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 1), (410, 1), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 1), (590, 1), (600, 1), (610, 1), (620, 0), (630, 0), (640, 0), (650, 0), (660, 1), (670, 1), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 0), (810, 0), (820, 0), (830, 1), (840, 1), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 1), (980, 0), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 1), (1120, 1), (1130, 1), (1140, 0), (1150, 1), (1160, 1), (1170, 0), (1180, 0), (1190, 0), (1200, 1), (1210, 0), (1220, 1), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 0), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 0), (1380, 0), (1390, 0), (1400, 1), (1410, 1), (1420, 0), (1430, 0), (1440, 1), (1450, 1), (1460, 1), (1470, 1), (1480, 0), (1490, 0), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 0), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 0), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 0), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 1), (1770, 1), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 1), (1860, 0), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 0), (1930, 0), (1940, 0), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 0), (2010, 0), (2020, 0), (2030, 0)]
Va1_4  a1_4  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 1.8v 979.495n 1.8v 979.505n 0.0v 989.495n 0.0v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 1), (40, 1), (50, 1), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 1), (380, 1), (390, 0), (400, 1), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 0), (620, 1), (630, 1), (640, 1), (650, 1), (660, 0), (670, 0), (680, 0), (690, 1), (700, 0), (710, 0), (720, 1), (730, 1), (740, 0), (750, 0), (760, 0), (770, 1), (780, 0), (790, 0), (800, 0), (810, 1), (820, 1), (830, 0), (840, 0), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 0), (1050, 0), (1060, 1), (1070, 1), (1080, 0), (1090, 0), (1100, 0), (1110, 1), (1120, 1), (1130, 0), (1140, 1), (1150, 1), (1160, 1), (1170, 0), (1180, 0), (1190, 1), (1200, 0), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 0), (1340, 0), (1350, 1), (1360, 0), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 0), (1560, 1), (1570, 1), (1580, 0), (1590, 1), (1600, 0), (1610, 0), (1620, 1), (1630, 1), (1640, 0), (1650, 0), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 0), (1860, 1), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 1), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1)]
Va1_5  a1_5  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 0.0v 399.495n 0.0v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 0.0v 619.495n 0.0v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 1.8v 699.495n 1.8v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 1.8v 779.495n 1.8v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v )

 * Generation of control signals
* (time, data): [(0, 1), (10, 0), (20, 1), (30, 0), (40, 0), (50, 0), (60, 0), (70, 1), (80, 1), (90, 0), (100, 1), (110, 0), (120, 1), (130, 0), (140, 0), (150, 0), (160, 1), (170, 1), (180, 0), (190, 0), (200, 0), (210, 1), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 1), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 1), (380, 1), (390, 0), (400, 0), (410, 1), (420, 0), (430, 0), (440, 1), (450, 0), (460, 1), (470, 0), (480, 0), (490, 0), (500, 0), (510, 1), (520, 0), (530, 0), (540, 1), (550, 0), (560, 1), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 1), (660, 0), (670, 0), (680, 1), (690, 0), (700, 0), (710, 0), (720, 0), (730, 1), (740, 0), (750, 1), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 1), (820, 0), (830, 1), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 1), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 1), (1070, 0), (1080, 1), (1090, 0), (1100, 1), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 1), (1200, 0), (1210, 0), (1220, 1), (1230, 1), (1240, 1), (1250, 0), (1260, 0), (1270, 1), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 1), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 1), (1430, 0), (1440, 1), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 1), (1500, 1), (1510, 0), (1520, 1), (1530, 0), (1540, 0), (1550, 1), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 1), (1620, 0), (1630, 0), (1640, 0), (1650, 1), (1660, 0), (1670, 0), (1680, 0), (1690, 1), (1700, 0), (1710, 1), (1720, 1), (1730, 1), (1740, 0), (1750, 1), (1760, 0), (1770, 1), (1780, 1), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 1), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 1), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 1), (1940, 0), (1950, 1), (1960, 1), (1970, 0), (1980, 1), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 1)]
VCSB0 CSB0 0 PWL (0n 1.8v 9.495n 1.8v 9.505n 0.0v 19.495n 0.0v 19.505n 1.8v 29.495n 1.8v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 0.0v 99.495n 0.0v 99.505n 1.8v 109.495n 1.8v 109.505n 0.0v 119.495n 0.0v 119.505n 1.8v 129.495n 1.8v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 1.8v 219.495n 1.8v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 1.8v 319.495n 1.8v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 1.8v 419.495n 1.8v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 1.8v 449.495n 1.8v 449.505n 0.0v 459.495n 0.0v 459.505n 1.8v 469.495n 1.8v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 1.8v 519.495n 1.8v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 1.8v 549.495n 1.8v 549.505n 0.0v 559.495n 0.0v 559.505n 1.8v 569.495n 1.8v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 1.8v 659.495n 1.8v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 1.8v 689.495n 1.8v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 1.8v 739.495n 1.8v 739.505n 0.0v 749.495n 0.0v 749.505n 1.8v 759.495n 1.8v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 1.8v 819.495n 1.8v 819.505n 0.0v 829.495n 0.0v 829.505n 1.8v 839.495n 1.8v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 1.8v 899.495n 1.8v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 1.8v )
* (time, data): [(0, 1), (10, 1), (20, 0), (30, 0), (40, 1), (50, 1), (60, 1), (70, 0), (80, 1), (90, 1), (100, 0), (110, 0), (120, 1), (130, 0), (140, 0), (150, 0), (160, 1), (170, 0), (180, 0), (190, 1), (200, 1), (210, 1), (220, 0), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 0), (300, 1), (310, 1), (320, 0), (330, 0), (340, 0), (350, 1), (360, 1), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 0), (490, 1), (500, 0), (510, 1), (520, 1), (530, 1), (540, 1), (550, 0), (560, 1), (570, 1), (580, 0), (590, 1), (600, 1), (610, 0), (620, 0), (630, 1), (640, 1), (650, 1), (660, 0), (670, 1), (680, 0), (690, 0), (700, 0), (710, 1), (720, 0), (730, 1), (740, 0), (750, 0), (760, 1), (770, 0), (780, 0), (790, 1), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 1), (870, 0), (880, 1), (890, 1), (900, 1), (910, 0), (920, 0), (930, 0), (940, 1), (950, 1), (960, 1), (970, 0), (980, 0), (990, 0), (1000, 1), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 1), (1080, 0), (1090, 1), (1100, 1), (1110, 0), (1120, 1), (1130, 0), (1140, 0), (1150, 0), (1160, 1), (1170, 0), (1180, 1), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 1), (1250, 1), (1260, 1), (1270, 0), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 0), (1330, 0), (1340, 1), (1350, 0), (1360, 0), (1370, 0), (1380, 1), (1390, 1), (1400, 0), (1410, 0), (1420, 0), (1430, 1), (1440, 0), (1450, 1), (1460, 0), (1470, 1), (1480, 0), (1490, 1), (1500, 0), (1510, 0), (1520, 0), (1530, 1), (1540, 1), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 1), (1660, 0), (1670, 0), (1680, 0), (1690, 1), (1700, 1), (1710, 0), (1720, 1), (1730, 0), (1740, 1), (1750, 1), (1760, 0), (1770, 1), (1780, 0), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 0), (1860, 0), (1870, 0), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 0), (1930, 0), (1940, 1), (1950, 0), (1960, 0), (1970, 1), (1980, 1), (1990, 0), (2000, 0), (2010, 1), (2020, 1), (2030, 1)]
VCSB1 CSB1 0 PWL (0n 1.8v 9.495n 1.8v 9.505n 1.8v 19.495n 1.8v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 0.0v 79.495n 0.0v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 1.8v 129.495n 1.8v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 1.8v 169.495n 1.8v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 0.0v 229.495n 0.0v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 0.0v 299.495n 0.0v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 0.0v 489.495n 0.0v 489.505n 1.8v 499.495n 1.8v 499.505n 0.0v 509.495n 0.0v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 0.0v 559.495n 0.0v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 0.0v 589.495n 0.0v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 0.0v 669.495n 0.0v 669.505n 1.8v 679.495n 1.8v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 1.8v 719.495n 1.8v 719.505n 0.0v 729.495n 0.0v 729.505n 1.8v 739.495n 1.8v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 1.8v 769.495n 1.8v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 1.8v 799.495n 1.8v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 1.8v 869.495n 1.8v 869.505n 0.0v 879.495n 0.0v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 1.8v 1009.495n 1.8v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v )
* (time, data): [(0, 1), (10, 0), (20, 1), (30, 1), (40, 0), (50, 0), (60, 0), (70, 1), (80, 1), (90, 0), (100, 1), (110, 0), (120, 1), (130, 1), (140, 0), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 0), (210, 1), (220, 1), (230, 1), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 1), (300, 1), (310, 1), (320, 0), (330, 1), (340, 1), (350, 0), (360, 1), (370, 1), (380, 1), (390, 0), (400, 1), (410, 1), (420, 1), (430, 0), (440, 1), (450, 1), (460, 1), (470, 0), (480, 0), (490, 0), (500, 0), (510, 1), (520, 0), (530, 0), (540, 1), (550, 1), (560, 1), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 1), (630, 0), (640, 1), (650, 1), (660, 0), (670, 0), (680, 1), (690, 1), (700, 1), (710, 0), (720, 0), (730, 1), (740, 1), (750, 1), (760, 1), (770, 0), (780, 0), (790, 0), (800, 1), (810, 1), (820, 1), (830, 1), (840, 0), (850, 0), (860, 0), (870, 1), (880, 1), (890, 1), (900, 1), (910, 0), (920, 1), (930, 0), (940, 0), (950, 0), (960, 0), (970, 1), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 1), (1050, 0), (1060, 1), (1070, 1), (1080, 1), (1090, 0), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 1), (1200, 0), (1210, 0), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 0), (1290, 1), (1300, 0), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 0), (1360, 0), (1370, 1), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 1), (1430, 1), (1440, 1), (1450, 0), (1460, 0), (1470, 0), (1480, 1), (1490, 1), (1500, 1), (1510, 0), (1520, 1), (1530, 1), (1540, 0), (1550, 1), (1560, 0), (1570, 1), (1580, 0), (1590, 0), (1600, 0), (1610, 1), (1620, 0), (1630, 0), (1640, 0), (1650, 1), (1660, 0), (1670, 1), (1680, 0), (1690, 1), (1700, 0), (1710, 1), (1720, 1), (1730, 1), (1740, 0), (1750, 1), (1760, 0), (1770, 1), (1780, 1), (1790, 0), (1800, 0), (1810, 0), (1820, 1), (1830, 1), (1840, 0), (1850, 1), (1860, 0), (1870, 0), (1880, 1), (1890, 0), (1900, 0), (1910, 1), (1920, 0), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 0), (1980, 1), (1990, 0), (2000, 1), (2010, 0), (2020, 0), (2030, 1)]
VWEB0 WEB0 0 PWL (0n 1.8v 9.495n 1.8v 9.505n 0.0v 19.495n 0.0v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 0.0v 99.495n 0.0v 99.505n 1.8v 109.495n 1.8v 109.505n 0.0v 119.495n 0.0v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 0.0v 149.495n 0.0v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 0.0v 209.495n 0.0v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 0.0v 329.495n 0.0v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 0.0v 359.495n 0.0v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 0.0v 399.495n 0.0v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 0.0v 439.495n 0.0v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 1.8v 519.495n 1.8v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 1.8v 629.495n 1.8v 629.505n 0.0v 639.495n 0.0v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 0.0v 919.495n 0.0v 919.505n 1.8v 929.495n 1.8v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 1.8v 979.495n 1.8v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 1.8v )

* Generation of wmask signals
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 0), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 0), (120, 0), (130, 0), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 0), (330, 0), (340, 0), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 1), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 1), (580, 1), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 1), (670, 0), (680, 0), (690, 0), (700, 0), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 0), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 0), (1010, 1), (1020, 1), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 0), (1190, 0), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 0), (1670, 0), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 1), (1850, 1), (1860, 1), (1870, 0), (1880, 0), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 0), (2020, 0), (2030, 0)]
VWMASK0_0  WMASK0_0  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 0.0v 59.495n 0.0v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 1.8v 669.495n 1.8v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 0.0v 859.495n 0.0v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 0.0v 1009.495n 0.0v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 0), (60, 0), (70, 0), (80, 0), (90, 1), (100, 1), (110, 0), (120, 0), (130, 0), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 1), (410, 1), (420, 1), (430, 0), (440, 0), (450, 0), (460, 0), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 0), (580, 1), (590, 0), (600, 1), (610, 1), (620, 1), (630, 0), (640, 0), (650, 0), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 1), (850, 0), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 0), (920, 0), (930, 0), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 0), (1020, 1), (1030, 0), (1040, 0), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 1), (1160, 1), (1170, 1), (1180, 0), (1190, 0), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 1), (1360, 1), (1370, 1), (1380, 0), (1390, 1), (1400, 1), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 1), (1460, 1), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 1), (1550, 1), (1560, 0), (1570, 0), (1580, 1), (1590, 0), (1600, 1), (1610, 1), (1620, 1), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 0), (1910, 0), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 1), (2020, 0), (2030, 0)]
VWMASK0_1  WMASK0_1  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 0.0v 579.495n 0.0v 579.505n 1.8v 589.495n 1.8v 589.505n 0.0v 599.495n 0.0v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 1.8v 849.495n 1.8v 849.505n 0.0v 859.495n 0.0v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 1), (60, 0), (70, 0), (80, 0), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 1), (260, 1), (270, 1), (280, 0), (290, 0), (300, 0), (310, 0), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 1), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 0), (580, 1), (590, 1), (600, 1), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 1), (670, 0), (680, 0), (690, 0), (700, 0), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 0), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 0), (1040, 0), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 0), (1190, 0), (1200, 0), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 1), (1360, 0), (1370, 0), (1380, 1), (1390, 0), (1400, 0), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 1), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 1), (1570, 1), (1580, 0), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 0), (1690, 0), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 1), (1850, 1), (1860, 0), (1870, 0), (1880, 0), (1890, 1), (1900, 1), (1910, 1), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 1), (1980, 1), (1990, 0), (2000, 0), (2010, 1), (2020, 0), (2030, 0)]
VWMASK0_2  WMASK0_2  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 0.0v 579.495n 0.0v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 1.8v 669.495n 1.8v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 0.0v 789.495n 0.0v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 0), (60, 0), (70, 0), (80, 0), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 0), (210, 0), (220, 0), (230, 0), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 1), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 0), (510, 0), (520, 0), (530, 1), (540, 1), (550, 1), (560, 1), (570, 0), (580, 0), (590, 0), (600, 1), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 1), (670, 0), (680, 0), (690, 0), (700, 0), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 0), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 0), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 0), (1010, 0), (1020, 1), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 1), (1360, 0), (1370, 0), (1380, 1), (1390, 1), (1400, 1), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 1), (1460, 1), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 0), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 0), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 0), (1690, 0), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 1), (1850, 1), (1860, 0), (1870, 0), (1880, 0), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 0), (2000, 0), (2010, 1), (2020, 0), (2030, 0)]
VWMASK0_3  WMASK0_3  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 1.8v 609.495n 1.8v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 1.8v 669.495n 1.8v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 0.0v 859.495n 0.0v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 0.0v 939.495n 0.0v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 0), (60, 0), (70, 0), (80, 0), (90, 1), (100, 1), (110, 0), (120, 0), (130, 0), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 1), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 0), (510, 0), (520, 0), (530, 1), (540, 1), (550, 1), (560, 1), (570, 1), (580, 0), (590, 1), (600, 1), (610, 1), (620, 1), (630, 0), (640, 0), (650, 0), (660, 1), (670, 0), (680, 0), (690, 0), (700, 0), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 0), (850, 0), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 0), (920, 0), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 0), (1190, 0), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 0), (1370, 0), (1380, 1), (1390, 1), (1400, 0), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 1), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 1), (1550, 1), (1560, 0), (1570, 0), (1580, 1), (1590, 0), (1600, 1), (1610, 1), (1620, 1), (1630, 0), (1640, 1), (1650, 1), (1660, 0), (1670, 0), (1680, 1), (1690, 1), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 0), (1880, 0), (1890, 1), (1900, 1), (1910, 1), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 1), (1980, 1), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0)]
VWMASK0_4  WMASK0_4  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 0.0v 589.495n 0.0v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 1.8v 669.495n 1.8v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 0), (60, 0), (70, 0), (80, 0), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 0), (290, 0), (300, 0), (310, 0), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 1), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 0), (580, 0), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 0), (680, 0), (690, 0), (700, 0), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 0), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 0), (1010, 0), (1020, 1), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 0), (1190, 0), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 1), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 1), (1550, 1), (1560, 0), (1570, 0), (1580, 0), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 0), (1640, 0), (1650, 0), (1660, 1), (1670, 1), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 1), (1900, 0), (1910, 0), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 1), (2020, 0), (2030, 0)]
VWMASK0_5  WMASK0_5  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 0.0v 789.495n 0.0v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 1), (60, 1), (70, 1), (80, 1), (90, 0), (100, 0), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 0), (250, 1), (260, 1), (270, 1), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 1), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 0), (530, 1), (540, 1), (550, 1), (560, 1), (570, 1), (580, 1), (590, 0), (600, 0), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 0), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 0), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 0), (1010, 0), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 0), (1370, 0), (1380, 0), (1390, 1), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 1), (1460, 1), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 0), (1600, 1), (1610, 1), (1620, 1), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 0), (2020, 1), (2030, 1)]
VWMASK0_6  WMASK0_6  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 0.0v 249.495n 0.0v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 0.0v 529.495n 0.0v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 0.0v 789.495n 0.0v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 0.0v 849.495n 0.0v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 0), (60, 0), (70, 0), (80, 0), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 0), (210, 0), (220, 0), (230, 0), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 1), (410, 1), (420, 1), (430, 0), (440, 0), (450, 0), (460, 0), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 0), (620, 0), (630, 1), (640, 1), (650, 1), (660, 1), (670, 0), (680, 0), (690, 0), (700, 0), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 0), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 0), (850, 0), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 0), (1020, 1), (1030, 0), (1040, 0), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 0), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 1), (1360, 1), (1370, 1), (1380, 0), (1390, 1), (1400, 1), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 0), (1550, 0), (1560, 1), (1570, 1), (1580, 0), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 1), (1870, 0), (1880, 0), (1890, 1), (1900, 0), (1910, 0), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0)]
VWMASK0_7  WMASK0_7  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 0.0v 789.495n 0.0v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 1), (270, 1), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 1), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 0), (530, 1), (540, 1), (550, 1), (560, 1), (570, 1), (580, 1), (590, 1), (600, 0), (610, 0), (620, 0), (630, 1), (640, 1), (650, 1), (660, 1), (670, 0), (680, 0), (690, 0), (700, 0), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 0), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 0), (920, 0), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 0), (1010, 0), (1020, 1), (1030, 0), (1040, 0), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 1), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 1), (1460, 1), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 0), (1600, 1), (1610, 1), (1620, 1), (1630, 0), (1640, 1), (1650, 1), (1660, 0), (1670, 0), (1680, 1), (1690, 1), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 0), (1910, 0), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 0), (2000, 0), (2010, 1), (2020, 1), (2030, 1)]
VWMASK0_8  WMASK0_8  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 0.0v 529.495n 0.0v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 0.0v 859.495n 0.0v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 1), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 0), (260, 1), (270, 1), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 1), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 0), (580, 0), (590, 1), (600, 0), (610, 0), (620, 0), (630, 1), (640, 1), (650, 1), (660, 1), (670, 0), (680, 0), (690, 0), (700, 0), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 1), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 0), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 0), (1040, 0), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 1), (1160, 1), (1170, 1), (1180, 0), (1190, 0), (1200, 0), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 0), (1400, 0), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 1), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 1), (1520, 1), (1530, 1), (1540, 0), (1550, 0), (1560, 1), (1570, 1), (1580, 0), (1590, 0), (1600, 1), (1610, 1), (1620, 1), (1630, 0), (1640, 1), (1650, 1), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 0), (1820, 0), (1830, 0), (1840, 1), (1850, 1), (1860, 1), (1870, 0), (1880, 0), (1890, 1), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 1), (1980, 1), (1990, 0), (2000, 0), (2010, 1), (2020, 0), (2030, 0)]
VWMASK0_9  WMASK0_9  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 0.0v 259.495n 0.0v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 1.8v 599.495n 1.8v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 0.0v 939.495n 0.0v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v )
* PULSE: period=10
Vclk0 clk0 0 PULSE (0 1.8 10n 0.01n 0.01n 4.99n 10n)
* PULSE: period=10
Vclk1 clk1 0 PULSE (0 1.8 10n 0.01n 0.01n 4.99n 10n)

 * Generation of dout measurements
.meas tran Vdout1_0ck0 AVG v(dout1_0) FROM=29.9n TO=30.1n

.meas tran Vdout1_1ck0 AVG v(dout1_1) FROM=29.9n TO=30.1n

.meas tran Vdout1_2ck0 AVG v(dout1_2) FROM=29.9n TO=30.1n

.meas tran Vdout1_3ck0 AVG v(dout1_3) FROM=29.9n TO=30.1n

.meas tran Vdout1_4ck0 AVG v(dout1_4) FROM=29.9n TO=30.1n

.meas tran Vdout1_5ck0 AVG v(dout1_5) FROM=29.9n TO=30.1n

.meas tran Vdout1_6ck0 AVG v(dout1_6) FROM=29.9n TO=30.1n

.meas tran Vdout1_7ck0 AVG v(dout1_7) FROM=29.9n TO=30.1n

.meas tran Vdout1_8ck0 AVG v(dout1_8) FROM=29.9n TO=30.1n

.meas tran Vdout1_9ck0 AVG v(dout1_9) FROM=29.9n TO=30.1n

.meas tran Vdout1_10ck0 AVG v(dout1_10) FROM=29.9n TO=30.1n

.meas tran Vdout1_11ck0 AVG v(dout1_11) FROM=29.9n TO=30.1n

.meas tran Vdout1_12ck0 AVG v(dout1_12) FROM=29.9n TO=30.1n

.meas tran Vdout1_13ck0 AVG v(dout1_13) FROM=29.9n TO=30.1n

.meas tran Vdout1_14ck0 AVG v(dout1_14) FROM=29.9n TO=30.1n

.meas tran Vdout1_15ck0 AVG v(dout1_15) FROM=29.9n TO=30.1n

.meas tran Vdout1_16ck0 AVG v(dout1_16) FROM=29.9n TO=30.1n

.meas tran Vdout1_17ck0 AVG v(dout1_17) FROM=29.9n TO=30.1n

.meas tran Vdout1_18ck0 AVG v(dout1_18) FROM=29.9n TO=30.1n

.meas tran Vdout1_19ck0 AVG v(dout1_19) FROM=29.9n TO=30.1n

.meas tran Vdout1_20ck0 AVG v(dout1_20) FROM=29.9n TO=30.1n

.meas tran Vdout1_21ck0 AVG v(dout1_21) FROM=29.9n TO=30.1n

.meas tran Vdout1_22ck0 AVG v(dout1_22) FROM=29.9n TO=30.1n

.meas tran Vdout1_23ck0 AVG v(dout1_23) FROM=29.9n TO=30.1n

.meas tran Vdout1_24ck0 AVG v(dout1_24) FROM=29.9n TO=30.1n

.meas tran Vdout1_25ck0 AVG v(dout1_25) FROM=29.9n TO=30.1n

.meas tran Vdout1_26ck0 AVG v(dout1_26) FROM=29.9n TO=30.1n

.meas tran Vdout1_27ck0 AVG v(dout1_27) FROM=29.9n TO=30.1n

.meas tran Vdout1_28ck0 AVG v(dout1_28) FROM=29.9n TO=30.1n

.meas tran Vdout1_29ck0 AVG v(dout1_29) FROM=29.9n TO=30.1n

.meas tran Vdout1_30ck0 AVG v(dout1_30) FROM=29.9n TO=30.1n

.meas tran Vdout1_31ck0 AVG v(dout1_31) FROM=29.9n TO=30.1n

.meas tran Vdout1_32ck0 AVG v(dout1_32) FROM=29.9n TO=30.1n

.meas tran Vdout1_33ck0 AVG v(dout1_33) FROM=29.9n TO=30.1n

.meas tran Vdout1_34ck0 AVG v(dout1_34) FROM=29.9n TO=30.1n

.meas tran Vdout1_35ck0 AVG v(dout1_35) FROM=29.9n TO=30.1n

.meas tran Vdout1_36ck0 AVG v(dout1_36) FROM=29.9n TO=30.1n

.meas tran Vdout1_37ck0 AVG v(dout1_37) FROM=29.9n TO=30.1n

.meas tran Vdout1_38ck0 AVG v(dout1_38) FROM=29.9n TO=30.1n

.meas tran Vdout1_39ck0 AVG v(dout1_39) FROM=29.9n TO=30.1n

.meas tran Vdout1_40ck0 AVG v(dout1_40) FROM=29.9n TO=30.1n

.meas tran Vdout1_41ck0 AVG v(dout1_41) FROM=29.9n TO=30.1n

.meas tran Vdout1_42ck0 AVG v(dout1_42) FROM=29.9n TO=30.1n

.meas tran Vdout1_43ck0 AVG v(dout1_43) FROM=29.9n TO=30.1n

.meas tran Vdout1_44ck0 AVG v(dout1_44) FROM=29.9n TO=30.1n

.meas tran Vdout1_45ck0 AVG v(dout1_45) FROM=29.9n TO=30.1n

.meas tran Vdout1_46ck0 AVG v(dout1_46) FROM=29.9n TO=30.1n

.meas tran Vdout1_47ck0 AVG v(dout1_47) FROM=29.9n TO=30.1n

.meas tran Vdout1_48ck0 AVG v(dout1_48) FROM=29.9n TO=30.1n

.meas tran Vdout1_49ck0 AVG v(dout1_49) FROM=29.9n TO=30.1n

.meas tran Vdout1_50ck0 AVG v(dout1_50) FROM=29.9n TO=30.1n

.meas tran Vdout1_51ck0 AVG v(dout1_51) FROM=29.9n TO=30.1n

.meas tran Vdout1_52ck0 AVG v(dout1_52) FROM=29.9n TO=30.1n

.meas tran Vdout1_53ck0 AVG v(dout1_53) FROM=29.9n TO=30.1n

.meas tran Vdout1_54ck0 AVG v(dout1_54) FROM=29.9n TO=30.1n

.meas tran Vdout1_55ck0 AVG v(dout1_55) FROM=29.9n TO=30.1n

.meas tran Vdout1_56ck0 AVG v(dout1_56) FROM=29.9n TO=30.1n

.meas tran Vdout1_57ck0 AVG v(dout1_57) FROM=29.9n TO=30.1n

.meas tran Vdout1_58ck0 AVG v(dout1_58) FROM=29.9n TO=30.1n

.meas tran Vdout1_59ck0 AVG v(dout1_59) FROM=29.9n TO=30.1n

.meas tran Vdout1_60ck0 AVG v(dout1_60) FROM=29.9n TO=30.1n

.meas tran Vdout1_61ck0 AVG v(dout1_61) FROM=29.9n TO=30.1n

.meas tran Vdout1_62ck0 AVG v(dout1_62) FROM=29.9n TO=30.1n

.meas tran Vdout1_63ck0 AVG v(dout1_63) FROM=29.9n TO=30.1n

.meas tran Vdout1_64ck0 AVG v(dout1_64) FROM=29.9n TO=30.1n

.meas tran Vdout1_65ck0 AVG v(dout1_65) FROM=29.9n TO=30.1n

.meas tran Vdout1_66ck0 AVG v(dout1_66) FROM=29.9n TO=30.1n

.meas tran Vdout1_67ck0 AVG v(dout1_67) FROM=29.9n TO=30.1n

.meas tran Vdout1_68ck0 AVG v(dout1_68) FROM=29.9n TO=30.1n

.meas tran Vdout1_69ck0 AVG v(dout1_69) FROM=29.9n TO=30.1n

.meas tran Vdout1_70ck0 AVG v(dout1_70) FROM=29.9n TO=30.1n

.meas tran Vdout1_71ck0 AVG v(dout1_71) FROM=29.9n TO=30.1n

.meas tran Vdout1_72ck0 AVG v(dout1_72) FROM=29.9n TO=30.1n

.meas tran Vdout1_73ck0 AVG v(dout1_73) FROM=29.9n TO=30.1n

.meas tran Vdout1_74ck0 AVG v(dout1_74) FROM=29.9n TO=30.1n

.meas tran Vdout1_75ck0 AVG v(dout1_75) FROM=29.9n TO=30.1n

.meas tran Vdout1_76ck0 AVG v(dout1_76) FROM=29.9n TO=30.1n

.meas tran Vdout1_77ck0 AVG v(dout1_77) FROM=29.9n TO=30.1n

.meas tran Vdout1_78ck0 AVG v(dout1_78) FROM=29.9n TO=30.1n

.meas tran Vdout1_79ck0 AVG v(dout1_79) FROM=29.9n TO=30.1n

.meas tran Vdout0_0ck1 AVG v(dout0_0) FROM=39.9n TO=40.1n

.meas tran Vdout0_1ck1 AVG v(dout0_1) FROM=39.9n TO=40.1n

.meas tran Vdout0_2ck1 AVG v(dout0_2) FROM=39.9n TO=40.1n

.meas tran Vdout0_3ck1 AVG v(dout0_3) FROM=39.9n TO=40.1n

.meas tran Vdout0_4ck1 AVG v(dout0_4) FROM=39.9n TO=40.1n

.meas tran Vdout0_5ck1 AVG v(dout0_5) FROM=39.9n TO=40.1n

.meas tran Vdout0_6ck1 AVG v(dout0_6) FROM=39.9n TO=40.1n

.meas tran Vdout0_7ck1 AVG v(dout0_7) FROM=39.9n TO=40.1n

.meas tran Vdout0_8ck1 AVG v(dout0_8) FROM=39.9n TO=40.1n

.meas tran Vdout0_9ck1 AVG v(dout0_9) FROM=39.9n TO=40.1n

.meas tran Vdout0_10ck1 AVG v(dout0_10) FROM=39.9n TO=40.1n

.meas tran Vdout0_11ck1 AVG v(dout0_11) FROM=39.9n TO=40.1n

.meas tran Vdout0_12ck1 AVG v(dout0_12) FROM=39.9n TO=40.1n

.meas tran Vdout0_13ck1 AVG v(dout0_13) FROM=39.9n TO=40.1n

.meas tran Vdout0_14ck1 AVG v(dout0_14) FROM=39.9n TO=40.1n

.meas tran Vdout0_15ck1 AVG v(dout0_15) FROM=39.9n TO=40.1n

.meas tran Vdout0_16ck1 AVG v(dout0_16) FROM=39.9n TO=40.1n

.meas tran Vdout0_17ck1 AVG v(dout0_17) FROM=39.9n TO=40.1n

.meas tran Vdout0_18ck1 AVG v(dout0_18) FROM=39.9n TO=40.1n

.meas tran Vdout0_19ck1 AVG v(dout0_19) FROM=39.9n TO=40.1n

.meas tran Vdout0_20ck1 AVG v(dout0_20) FROM=39.9n TO=40.1n

.meas tran Vdout0_21ck1 AVG v(dout0_21) FROM=39.9n TO=40.1n

.meas tran Vdout0_22ck1 AVG v(dout0_22) FROM=39.9n TO=40.1n

.meas tran Vdout0_23ck1 AVG v(dout0_23) FROM=39.9n TO=40.1n

.meas tran Vdout0_24ck1 AVG v(dout0_24) FROM=39.9n TO=40.1n

.meas tran Vdout0_25ck1 AVG v(dout0_25) FROM=39.9n TO=40.1n

.meas tran Vdout0_26ck1 AVG v(dout0_26) FROM=39.9n TO=40.1n

.meas tran Vdout0_27ck1 AVG v(dout0_27) FROM=39.9n TO=40.1n

.meas tran Vdout0_28ck1 AVG v(dout0_28) FROM=39.9n TO=40.1n

.meas tran Vdout0_29ck1 AVG v(dout0_29) FROM=39.9n TO=40.1n

.meas tran Vdout0_30ck1 AVG v(dout0_30) FROM=39.9n TO=40.1n

.meas tran Vdout0_31ck1 AVG v(dout0_31) FROM=39.9n TO=40.1n

.meas tran Vdout0_32ck1 AVG v(dout0_32) FROM=39.9n TO=40.1n

.meas tran Vdout0_33ck1 AVG v(dout0_33) FROM=39.9n TO=40.1n

.meas tran Vdout0_34ck1 AVG v(dout0_34) FROM=39.9n TO=40.1n

.meas tran Vdout0_35ck1 AVG v(dout0_35) FROM=39.9n TO=40.1n

.meas tran Vdout0_36ck1 AVG v(dout0_36) FROM=39.9n TO=40.1n

.meas tran Vdout0_37ck1 AVG v(dout0_37) FROM=39.9n TO=40.1n

.meas tran Vdout0_38ck1 AVG v(dout0_38) FROM=39.9n TO=40.1n

.meas tran Vdout0_39ck1 AVG v(dout0_39) FROM=39.9n TO=40.1n

.meas tran Vdout0_40ck1 AVG v(dout0_40) FROM=39.9n TO=40.1n

.meas tran Vdout0_41ck1 AVG v(dout0_41) FROM=39.9n TO=40.1n

.meas tran Vdout0_42ck1 AVG v(dout0_42) FROM=39.9n TO=40.1n

.meas tran Vdout0_43ck1 AVG v(dout0_43) FROM=39.9n TO=40.1n

.meas tran Vdout0_44ck1 AVG v(dout0_44) FROM=39.9n TO=40.1n

.meas tran Vdout0_45ck1 AVG v(dout0_45) FROM=39.9n TO=40.1n

.meas tran Vdout0_46ck1 AVG v(dout0_46) FROM=39.9n TO=40.1n

.meas tran Vdout0_47ck1 AVG v(dout0_47) FROM=39.9n TO=40.1n

.meas tran Vdout0_48ck1 AVG v(dout0_48) FROM=39.9n TO=40.1n

.meas tran Vdout0_49ck1 AVG v(dout0_49) FROM=39.9n TO=40.1n

.meas tran Vdout0_50ck1 AVG v(dout0_50) FROM=39.9n TO=40.1n

.meas tran Vdout0_51ck1 AVG v(dout0_51) FROM=39.9n TO=40.1n

.meas tran Vdout0_52ck1 AVG v(dout0_52) FROM=39.9n TO=40.1n

.meas tran Vdout0_53ck1 AVG v(dout0_53) FROM=39.9n TO=40.1n

.meas tran Vdout0_54ck1 AVG v(dout0_54) FROM=39.9n TO=40.1n

.meas tran Vdout0_55ck1 AVG v(dout0_55) FROM=39.9n TO=40.1n

.meas tran Vdout0_56ck1 AVG v(dout0_56) FROM=39.9n TO=40.1n

.meas tran Vdout0_57ck1 AVG v(dout0_57) FROM=39.9n TO=40.1n

.meas tran Vdout0_58ck1 AVG v(dout0_58) FROM=39.9n TO=40.1n

.meas tran Vdout0_59ck1 AVG v(dout0_59) FROM=39.9n TO=40.1n

.meas tran Vdout0_60ck1 AVG v(dout0_60) FROM=39.9n TO=40.1n

.meas tran Vdout0_61ck1 AVG v(dout0_61) FROM=39.9n TO=40.1n

.meas tran Vdout0_62ck1 AVG v(dout0_62) FROM=39.9n TO=40.1n

.meas tran Vdout0_63ck1 AVG v(dout0_63) FROM=39.9n TO=40.1n

.meas tran Vdout0_64ck1 AVG v(dout0_64) FROM=39.9n TO=40.1n

.meas tran Vdout0_65ck1 AVG v(dout0_65) FROM=39.9n TO=40.1n

.meas tran Vdout0_66ck1 AVG v(dout0_66) FROM=39.9n TO=40.1n

.meas tran Vdout0_67ck1 AVG v(dout0_67) FROM=39.9n TO=40.1n

.meas tran Vdout0_68ck1 AVG v(dout0_68) FROM=39.9n TO=40.1n

.meas tran Vdout0_69ck1 AVG v(dout0_69) FROM=39.9n TO=40.1n

.meas tran Vdout0_70ck1 AVG v(dout0_70) FROM=39.9n TO=40.1n

.meas tran Vdout0_71ck1 AVG v(dout0_71) FROM=39.9n TO=40.1n

.meas tran Vdout0_72ck1 AVG v(dout0_72) FROM=39.9n TO=40.1n

.meas tran Vdout0_73ck1 AVG v(dout0_73) FROM=39.9n TO=40.1n

.meas tran Vdout0_74ck1 AVG v(dout0_74) FROM=39.9n TO=40.1n

.meas tran Vdout0_75ck1 AVG v(dout0_75) FROM=39.9n TO=40.1n

.meas tran Vdout0_76ck1 AVG v(dout0_76) FROM=39.9n TO=40.1n

.meas tran Vdout0_77ck1 AVG v(dout0_77) FROM=39.9n TO=40.1n

.meas tran Vdout0_78ck1 AVG v(dout0_78) FROM=39.9n TO=40.1n

.meas tran Vdout0_79ck1 AVG v(dout0_79) FROM=39.9n TO=40.1n

.meas tran Vdout1_0ck2 AVG v(dout1_0) FROM=39.9n TO=40.1n

.meas tran Vdout1_1ck2 AVG v(dout1_1) FROM=39.9n TO=40.1n

.meas tran Vdout1_2ck2 AVG v(dout1_2) FROM=39.9n TO=40.1n

.meas tran Vdout1_3ck2 AVG v(dout1_3) FROM=39.9n TO=40.1n

.meas tran Vdout1_4ck2 AVG v(dout1_4) FROM=39.9n TO=40.1n

.meas tran Vdout1_5ck2 AVG v(dout1_5) FROM=39.9n TO=40.1n

.meas tran Vdout1_6ck2 AVG v(dout1_6) FROM=39.9n TO=40.1n

.meas tran Vdout1_7ck2 AVG v(dout1_7) FROM=39.9n TO=40.1n

.meas tran Vdout1_8ck2 AVG v(dout1_8) FROM=39.9n TO=40.1n

.meas tran Vdout1_9ck2 AVG v(dout1_9) FROM=39.9n TO=40.1n

.meas tran Vdout1_10ck2 AVG v(dout1_10) FROM=39.9n TO=40.1n

.meas tran Vdout1_11ck2 AVG v(dout1_11) FROM=39.9n TO=40.1n

.meas tran Vdout1_12ck2 AVG v(dout1_12) FROM=39.9n TO=40.1n

.meas tran Vdout1_13ck2 AVG v(dout1_13) FROM=39.9n TO=40.1n

.meas tran Vdout1_14ck2 AVG v(dout1_14) FROM=39.9n TO=40.1n

.meas tran Vdout1_15ck2 AVG v(dout1_15) FROM=39.9n TO=40.1n

.meas tran Vdout1_16ck2 AVG v(dout1_16) FROM=39.9n TO=40.1n

.meas tran Vdout1_17ck2 AVG v(dout1_17) FROM=39.9n TO=40.1n

.meas tran Vdout1_18ck2 AVG v(dout1_18) FROM=39.9n TO=40.1n

.meas tran Vdout1_19ck2 AVG v(dout1_19) FROM=39.9n TO=40.1n

.meas tran Vdout1_20ck2 AVG v(dout1_20) FROM=39.9n TO=40.1n

.meas tran Vdout1_21ck2 AVG v(dout1_21) FROM=39.9n TO=40.1n

.meas tran Vdout1_22ck2 AVG v(dout1_22) FROM=39.9n TO=40.1n

.meas tran Vdout1_23ck2 AVG v(dout1_23) FROM=39.9n TO=40.1n

.meas tran Vdout1_24ck2 AVG v(dout1_24) FROM=39.9n TO=40.1n

.meas tran Vdout1_25ck2 AVG v(dout1_25) FROM=39.9n TO=40.1n

.meas tran Vdout1_26ck2 AVG v(dout1_26) FROM=39.9n TO=40.1n

.meas tran Vdout1_27ck2 AVG v(dout1_27) FROM=39.9n TO=40.1n

.meas tran Vdout1_28ck2 AVG v(dout1_28) FROM=39.9n TO=40.1n

.meas tran Vdout1_29ck2 AVG v(dout1_29) FROM=39.9n TO=40.1n

.meas tran Vdout1_30ck2 AVG v(dout1_30) FROM=39.9n TO=40.1n

.meas tran Vdout1_31ck2 AVG v(dout1_31) FROM=39.9n TO=40.1n

.meas tran Vdout1_32ck2 AVG v(dout1_32) FROM=39.9n TO=40.1n

.meas tran Vdout1_33ck2 AVG v(dout1_33) FROM=39.9n TO=40.1n

.meas tran Vdout1_34ck2 AVG v(dout1_34) FROM=39.9n TO=40.1n

.meas tran Vdout1_35ck2 AVG v(dout1_35) FROM=39.9n TO=40.1n

.meas tran Vdout1_36ck2 AVG v(dout1_36) FROM=39.9n TO=40.1n

.meas tran Vdout1_37ck2 AVG v(dout1_37) FROM=39.9n TO=40.1n

.meas tran Vdout1_38ck2 AVG v(dout1_38) FROM=39.9n TO=40.1n

.meas tran Vdout1_39ck2 AVG v(dout1_39) FROM=39.9n TO=40.1n

.meas tran Vdout1_40ck2 AVG v(dout1_40) FROM=39.9n TO=40.1n

.meas tran Vdout1_41ck2 AVG v(dout1_41) FROM=39.9n TO=40.1n

.meas tran Vdout1_42ck2 AVG v(dout1_42) FROM=39.9n TO=40.1n

.meas tran Vdout1_43ck2 AVG v(dout1_43) FROM=39.9n TO=40.1n

.meas tran Vdout1_44ck2 AVG v(dout1_44) FROM=39.9n TO=40.1n

.meas tran Vdout1_45ck2 AVG v(dout1_45) FROM=39.9n TO=40.1n

.meas tran Vdout1_46ck2 AVG v(dout1_46) FROM=39.9n TO=40.1n

.meas tran Vdout1_47ck2 AVG v(dout1_47) FROM=39.9n TO=40.1n

.meas tran Vdout1_48ck2 AVG v(dout1_48) FROM=39.9n TO=40.1n

.meas tran Vdout1_49ck2 AVG v(dout1_49) FROM=39.9n TO=40.1n

.meas tran Vdout1_50ck2 AVG v(dout1_50) FROM=39.9n TO=40.1n

.meas tran Vdout1_51ck2 AVG v(dout1_51) FROM=39.9n TO=40.1n

.meas tran Vdout1_52ck2 AVG v(dout1_52) FROM=39.9n TO=40.1n

.meas tran Vdout1_53ck2 AVG v(dout1_53) FROM=39.9n TO=40.1n

.meas tran Vdout1_54ck2 AVG v(dout1_54) FROM=39.9n TO=40.1n

.meas tran Vdout1_55ck2 AVG v(dout1_55) FROM=39.9n TO=40.1n

.meas tran Vdout1_56ck2 AVG v(dout1_56) FROM=39.9n TO=40.1n

.meas tran Vdout1_57ck2 AVG v(dout1_57) FROM=39.9n TO=40.1n

.meas tran Vdout1_58ck2 AVG v(dout1_58) FROM=39.9n TO=40.1n

.meas tran Vdout1_59ck2 AVG v(dout1_59) FROM=39.9n TO=40.1n

.meas tran Vdout1_60ck2 AVG v(dout1_60) FROM=39.9n TO=40.1n

.meas tran Vdout1_61ck2 AVG v(dout1_61) FROM=39.9n TO=40.1n

.meas tran Vdout1_62ck2 AVG v(dout1_62) FROM=39.9n TO=40.1n

.meas tran Vdout1_63ck2 AVG v(dout1_63) FROM=39.9n TO=40.1n

.meas tran Vdout1_64ck2 AVG v(dout1_64) FROM=39.9n TO=40.1n

.meas tran Vdout1_65ck2 AVG v(dout1_65) FROM=39.9n TO=40.1n

.meas tran Vdout1_66ck2 AVG v(dout1_66) FROM=39.9n TO=40.1n

.meas tran Vdout1_67ck2 AVG v(dout1_67) FROM=39.9n TO=40.1n

.meas tran Vdout1_68ck2 AVG v(dout1_68) FROM=39.9n TO=40.1n

.meas tran Vdout1_69ck2 AVG v(dout1_69) FROM=39.9n TO=40.1n

.meas tran Vdout1_70ck2 AVG v(dout1_70) FROM=39.9n TO=40.1n

.meas tran Vdout1_71ck2 AVG v(dout1_71) FROM=39.9n TO=40.1n

.meas tran Vdout1_72ck2 AVG v(dout1_72) FROM=39.9n TO=40.1n

.meas tran Vdout1_73ck2 AVG v(dout1_73) FROM=39.9n TO=40.1n

.meas tran Vdout1_74ck2 AVG v(dout1_74) FROM=39.9n TO=40.1n

.meas tran Vdout1_75ck2 AVG v(dout1_75) FROM=39.9n TO=40.1n

.meas tran Vdout1_76ck2 AVG v(dout1_76) FROM=39.9n TO=40.1n

.meas tran Vdout1_77ck2 AVG v(dout1_77) FROM=39.9n TO=40.1n

.meas tran Vdout1_78ck2 AVG v(dout1_78) FROM=39.9n TO=40.1n

.meas tran Vdout1_79ck2 AVG v(dout1_79) FROM=39.9n TO=40.1n

.meas tran Vdout1_0ck3 AVG v(dout1_0) FROM=79.9n TO=80.1n

.meas tran Vdout1_1ck3 AVG v(dout1_1) FROM=79.9n TO=80.1n

.meas tran Vdout1_2ck3 AVG v(dout1_2) FROM=79.9n TO=80.1n

.meas tran Vdout1_3ck3 AVG v(dout1_3) FROM=79.9n TO=80.1n

.meas tran Vdout1_4ck3 AVG v(dout1_4) FROM=79.9n TO=80.1n

.meas tran Vdout1_5ck3 AVG v(dout1_5) FROM=79.9n TO=80.1n

.meas tran Vdout1_6ck3 AVG v(dout1_6) FROM=79.9n TO=80.1n

.meas tran Vdout1_7ck3 AVG v(dout1_7) FROM=79.9n TO=80.1n

.meas tran Vdout1_8ck3 AVG v(dout1_8) FROM=79.9n TO=80.1n

.meas tran Vdout1_9ck3 AVG v(dout1_9) FROM=79.9n TO=80.1n

.meas tran Vdout1_10ck3 AVG v(dout1_10) FROM=79.9n TO=80.1n

.meas tran Vdout1_11ck3 AVG v(dout1_11) FROM=79.9n TO=80.1n

.meas tran Vdout1_12ck3 AVG v(dout1_12) FROM=79.9n TO=80.1n

.meas tran Vdout1_13ck3 AVG v(dout1_13) FROM=79.9n TO=80.1n

.meas tran Vdout1_14ck3 AVG v(dout1_14) FROM=79.9n TO=80.1n

.meas tran Vdout1_15ck3 AVG v(dout1_15) FROM=79.9n TO=80.1n

.meas tran Vdout1_16ck3 AVG v(dout1_16) FROM=79.9n TO=80.1n

.meas tran Vdout1_17ck3 AVG v(dout1_17) FROM=79.9n TO=80.1n

.meas tran Vdout1_18ck3 AVG v(dout1_18) FROM=79.9n TO=80.1n

.meas tran Vdout1_19ck3 AVG v(dout1_19) FROM=79.9n TO=80.1n

.meas tran Vdout1_20ck3 AVG v(dout1_20) FROM=79.9n TO=80.1n

.meas tran Vdout1_21ck3 AVG v(dout1_21) FROM=79.9n TO=80.1n

.meas tran Vdout1_22ck3 AVG v(dout1_22) FROM=79.9n TO=80.1n

.meas tran Vdout1_23ck3 AVG v(dout1_23) FROM=79.9n TO=80.1n

.meas tran Vdout1_24ck3 AVG v(dout1_24) FROM=79.9n TO=80.1n

.meas tran Vdout1_25ck3 AVG v(dout1_25) FROM=79.9n TO=80.1n

.meas tran Vdout1_26ck3 AVG v(dout1_26) FROM=79.9n TO=80.1n

.meas tran Vdout1_27ck3 AVG v(dout1_27) FROM=79.9n TO=80.1n

.meas tran Vdout1_28ck3 AVG v(dout1_28) FROM=79.9n TO=80.1n

.meas tran Vdout1_29ck3 AVG v(dout1_29) FROM=79.9n TO=80.1n

.meas tran Vdout1_30ck3 AVG v(dout1_30) FROM=79.9n TO=80.1n

.meas tran Vdout1_31ck3 AVG v(dout1_31) FROM=79.9n TO=80.1n

.meas tran Vdout1_32ck3 AVG v(dout1_32) FROM=79.9n TO=80.1n

.meas tran Vdout1_33ck3 AVG v(dout1_33) FROM=79.9n TO=80.1n

.meas tran Vdout1_34ck3 AVG v(dout1_34) FROM=79.9n TO=80.1n

.meas tran Vdout1_35ck3 AVG v(dout1_35) FROM=79.9n TO=80.1n

.meas tran Vdout1_36ck3 AVG v(dout1_36) FROM=79.9n TO=80.1n

.meas tran Vdout1_37ck3 AVG v(dout1_37) FROM=79.9n TO=80.1n

.meas tran Vdout1_38ck3 AVG v(dout1_38) FROM=79.9n TO=80.1n

.meas tran Vdout1_39ck3 AVG v(dout1_39) FROM=79.9n TO=80.1n

.meas tran Vdout1_40ck3 AVG v(dout1_40) FROM=79.9n TO=80.1n

.meas tran Vdout1_41ck3 AVG v(dout1_41) FROM=79.9n TO=80.1n

.meas tran Vdout1_42ck3 AVG v(dout1_42) FROM=79.9n TO=80.1n

.meas tran Vdout1_43ck3 AVG v(dout1_43) FROM=79.9n TO=80.1n

.meas tran Vdout1_44ck3 AVG v(dout1_44) FROM=79.9n TO=80.1n

.meas tran Vdout1_45ck3 AVG v(dout1_45) FROM=79.9n TO=80.1n

.meas tran Vdout1_46ck3 AVG v(dout1_46) FROM=79.9n TO=80.1n

.meas tran Vdout1_47ck3 AVG v(dout1_47) FROM=79.9n TO=80.1n

.meas tran Vdout1_48ck3 AVG v(dout1_48) FROM=79.9n TO=80.1n

.meas tran Vdout1_49ck3 AVG v(dout1_49) FROM=79.9n TO=80.1n

.meas tran Vdout1_50ck3 AVG v(dout1_50) FROM=79.9n TO=80.1n

.meas tran Vdout1_51ck3 AVG v(dout1_51) FROM=79.9n TO=80.1n

.meas tran Vdout1_52ck3 AVG v(dout1_52) FROM=79.9n TO=80.1n

.meas tran Vdout1_53ck3 AVG v(dout1_53) FROM=79.9n TO=80.1n

.meas tran Vdout1_54ck3 AVG v(dout1_54) FROM=79.9n TO=80.1n

.meas tran Vdout1_55ck3 AVG v(dout1_55) FROM=79.9n TO=80.1n

.meas tran Vdout1_56ck3 AVG v(dout1_56) FROM=79.9n TO=80.1n

.meas tran Vdout1_57ck3 AVG v(dout1_57) FROM=79.9n TO=80.1n

.meas tran Vdout1_58ck3 AVG v(dout1_58) FROM=79.9n TO=80.1n

.meas tran Vdout1_59ck3 AVG v(dout1_59) FROM=79.9n TO=80.1n

.meas tran Vdout1_60ck3 AVG v(dout1_60) FROM=79.9n TO=80.1n

.meas tran Vdout1_61ck3 AVG v(dout1_61) FROM=79.9n TO=80.1n

.meas tran Vdout1_62ck3 AVG v(dout1_62) FROM=79.9n TO=80.1n

.meas tran Vdout1_63ck3 AVG v(dout1_63) FROM=79.9n TO=80.1n

.meas tran Vdout1_64ck3 AVG v(dout1_64) FROM=79.9n TO=80.1n

.meas tran Vdout1_65ck3 AVG v(dout1_65) FROM=79.9n TO=80.1n

.meas tran Vdout1_66ck3 AVG v(dout1_66) FROM=79.9n TO=80.1n

.meas tran Vdout1_67ck3 AVG v(dout1_67) FROM=79.9n TO=80.1n

.meas tran Vdout1_68ck3 AVG v(dout1_68) FROM=79.9n TO=80.1n

.meas tran Vdout1_69ck3 AVG v(dout1_69) FROM=79.9n TO=80.1n

.meas tran Vdout1_70ck3 AVG v(dout1_70) FROM=79.9n TO=80.1n

.meas tran Vdout1_71ck3 AVG v(dout1_71) FROM=79.9n TO=80.1n

.meas tran Vdout1_72ck3 AVG v(dout1_72) FROM=79.9n TO=80.1n

.meas tran Vdout1_73ck3 AVG v(dout1_73) FROM=79.9n TO=80.1n

.meas tran Vdout1_74ck3 AVG v(dout1_74) FROM=79.9n TO=80.1n

.meas tran Vdout1_75ck3 AVG v(dout1_75) FROM=79.9n TO=80.1n

.meas tran Vdout1_76ck3 AVG v(dout1_76) FROM=79.9n TO=80.1n

.meas tran Vdout1_77ck3 AVG v(dout1_77) FROM=79.9n TO=80.1n

.meas tran Vdout1_78ck3 AVG v(dout1_78) FROM=79.9n TO=80.1n

.meas tran Vdout1_79ck3 AVG v(dout1_79) FROM=79.9n TO=80.1n

.meas tran Vdout1_0ck4 AVG v(dout1_0) FROM=109.9n TO=110.1n

.meas tran Vdout1_1ck4 AVG v(dout1_1) FROM=109.9n TO=110.1n

.meas tran Vdout1_2ck4 AVG v(dout1_2) FROM=109.9n TO=110.1n

.meas tran Vdout1_3ck4 AVG v(dout1_3) FROM=109.9n TO=110.1n

.meas tran Vdout1_4ck4 AVG v(dout1_4) FROM=109.9n TO=110.1n

.meas tran Vdout1_5ck4 AVG v(dout1_5) FROM=109.9n TO=110.1n

.meas tran Vdout1_6ck4 AVG v(dout1_6) FROM=109.9n TO=110.1n

.meas tran Vdout1_7ck4 AVG v(dout1_7) FROM=109.9n TO=110.1n

.meas tran Vdout1_8ck4 AVG v(dout1_8) FROM=109.9n TO=110.1n

.meas tran Vdout1_9ck4 AVG v(dout1_9) FROM=109.9n TO=110.1n

.meas tran Vdout1_10ck4 AVG v(dout1_10) FROM=109.9n TO=110.1n

.meas tran Vdout1_11ck4 AVG v(dout1_11) FROM=109.9n TO=110.1n

.meas tran Vdout1_12ck4 AVG v(dout1_12) FROM=109.9n TO=110.1n

.meas tran Vdout1_13ck4 AVG v(dout1_13) FROM=109.9n TO=110.1n

.meas tran Vdout1_14ck4 AVG v(dout1_14) FROM=109.9n TO=110.1n

.meas tran Vdout1_15ck4 AVG v(dout1_15) FROM=109.9n TO=110.1n

.meas tran Vdout1_16ck4 AVG v(dout1_16) FROM=109.9n TO=110.1n

.meas tran Vdout1_17ck4 AVG v(dout1_17) FROM=109.9n TO=110.1n

.meas tran Vdout1_18ck4 AVG v(dout1_18) FROM=109.9n TO=110.1n

.meas tran Vdout1_19ck4 AVG v(dout1_19) FROM=109.9n TO=110.1n

.meas tran Vdout1_20ck4 AVG v(dout1_20) FROM=109.9n TO=110.1n

.meas tran Vdout1_21ck4 AVG v(dout1_21) FROM=109.9n TO=110.1n

.meas tran Vdout1_22ck4 AVG v(dout1_22) FROM=109.9n TO=110.1n

.meas tran Vdout1_23ck4 AVG v(dout1_23) FROM=109.9n TO=110.1n

.meas tran Vdout1_24ck4 AVG v(dout1_24) FROM=109.9n TO=110.1n

.meas tran Vdout1_25ck4 AVG v(dout1_25) FROM=109.9n TO=110.1n

.meas tran Vdout1_26ck4 AVG v(dout1_26) FROM=109.9n TO=110.1n

.meas tran Vdout1_27ck4 AVG v(dout1_27) FROM=109.9n TO=110.1n

.meas tran Vdout1_28ck4 AVG v(dout1_28) FROM=109.9n TO=110.1n

.meas tran Vdout1_29ck4 AVG v(dout1_29) FROM=109.9n TO=110.1n

.meas tran Vdout1_30ck4 AVG v(dout1_30) FROM=109.9n TO=110.1n

.meas tran Vdout1_31ck4 AVG v(dout1_31) FROM=109.9n TO=110.1n

.meas tran Vdout1_32ck4 AVG v(dout1_32) FROM=109.9n TO=110.1n

.meas tran Vdout1_33ck4 AVG v(dout1_33) FROM=109.9n TO=110.1n

.meas tran Vdout1_34ck4 AVG v(dout1_34) FROM=109.9n TO=110.1n

.meas tran Vdout1_35ck4 AVG v(dout1_35) FROM=109.9n TO=110.1n

.meas tran Vdout1_36ck4 AVG v(dout1_36) FROM=109.9n TO=110.1n

.meas tran Vdout1_37ck4 AVG v(dout1_37) FROM=109.9n TO=110.1n

.meas tran Vdout1_38ck4 AVG v(dout1_38) FROM=109.9n TO=110.1n

.meas tran Vdout1_39ck4 AVG v(dout1_39) FROM=109.9n TO=110.1n

.meas tran Vdout1_40ck4 AVG v(dout1_40) FROM=109.9n TO=110.1n

.meas tran Vdout1_41ck4 AVG v(dout1_41) FROM=109.9n TO=110.1n

.meas tran Vdout1_42ck4 AVG v(dout1_42) FROM=109.9n TO=110.1n

.meas tran Vdout1_43ck4 AVG v(dout1_43) FROM=109.9n TO=110.1n

.meas tran Vdout1_44ck4 AVG v(dout1_44) FROM=109.9n TO=110.1n

.meas tran Vdout1_45ck4 AVG v(dout1_45) FROM=109.9n TO=110.1n

.meas tran Vdout1_46ck4 AVG v(dout1_46) FROM=109.9n TO=110.1n

.meas tran Vdout1_47ck4 AVG v(dout1_47) FROM=109.9n TO=110.1n

.meas tran Vdout1_48ck4 AVG v(dout1_48) FROM=109.9n TO=110.1n

.meas tran Vdout1_49ck4 AVG v(dout1_49) FROM=109.9n TO=110.1n

.meas tran Vdout1_50ck4 AVG v(dout1_50) FROM=109.9n TO=110.1n

.meas tran Vdout1_51ck4 AVG v(dout1_51) FROM=109.9n TO=110.1n

.meas tran Vdout1_52ck4 AVG v(dout1_52) FROM=109.9n TO=110.1n

.meas tran Vdout1_53ck4 AVG v(dout1_53) FROM=109.9n TO=110.1n

.meas tran Vdout1_54ck4 AVG v(dout1_54) FROM=109.9n TO=110.1n

.meas tran Vdout1_55ck4 AVG v(dout1_55) FROM=109.9n TO=110.1n

.meas tran Vdout1_56ck4 AVG v(dout1_56) FROM=109.9n TO=110.1n

.meas tran Vdout1_57ck4 AVG v(dout1_57) FROM=109.9n TO=110.1n

.meas tran Vdout1_58ck4 AVG v(dout1_58) FROM=109.9n TO=110.1n

.meas tran Vdout1_59ck4 AVG v(dout1_59) FROM=109.9n TO=110.1n

.meas tran Vdout1_60ck4 AVG v(dout1_60) FROM=109.9n TO=110.1n

.meas tran Vdout1_61ck4 AVG v(dout1_61) FROM=109.9n TO=110.1n

.meas tran Vdout1_62ck4 AVG v(dout1_62) FROM=109.9n TO=110.1n

.meas tran Vdout1_63ck4 AVG v(dout1_63) FROM=109.9n TO=110.1n

.meas tran Vdout1_64ck4 AVG v(dout1_64) FROM=109.9n TO=110.1n

.meas tran Vdout1_65ck4 AVG v(dout1_65) FROM=109.9n TO=110.1n

.meas tran Vdout1_66ck4 AVG v(dout1_66) FROM=109.9n TO=110.1n

.meas tran Vdout1_67ck4 AVG v(dout1_67) FROM=109.9n TO=110.1n

.meas tran Vdout1_68ck4 AVG v(dout1_68) FROM=109.9n TO=110.1n

.meas tran Vdout1_69ck4 AVG v(dout1_69) FROM=109.9n TO=110.1n

.meas tran Vdout1_70ck4 AVG v(dout1_70) FROM=109.9n TO=110.1n

.meas tran Vdout1_71ck4 AVG v(dout1_71) FROM=109.9n TO=110.1n

.meas tran Vdout1_72ck4 AVG v(dout1_72) FROM=109.9n TO=110.1n

.meas tran Vdout1_73ck4 AVG v(dout1_73) FROM=109.9n TO=110.1n

.meas tran Vdout1_74ck4 AVG v(dout1_74) FROM=109.9n TO=110.1n

.meas tran Vdout1_75ck4 AVG v(dout1_75) FROM=109.9n TO=110.1n

.meas tran Vdout1_76ck4 AVG v(dout1_76) FROM=109.9n TO=110.1n

.meas tran Vdout1_77ck4 AVG v(dout1_77) FROM=109.9n TO=110.1n

.meas tran Vdout1_78ck4 AVG v(dout1_78) FROM=109.9n TO=110.1n

.meas tran Vdout1_79ck4 AVG v(dout1_79) FROM=109.9n TO=110.1n

.meas tran Vdout1_0ck5 AVG v(dout1_0) FROM=119.9n TO=120.1n

.meas tran Vdout1_1ck5 AVG v(dout1_1) FROM=119.9n TO=120.1n

.meas tran Vdout1_2ck5 AVG v(dout1_2) FROM=119.9n TO=120.1n

.meas tran Vdout1_3ck5 AVG v(dout1_3) FROM=119.9n TO=120.1n

.meas tran Vdout1_4ck5 AVG v(dout1_4) FROM=119.9n TO=120.1n

.meas tran Vdout1_5ck5 AVG v(dout1_5) FROM=119.9n TO=120.1n

.meas tran Vdout1_6ck5 AVG v(dout1_6) FROM=119.9n TO=120.1n

.meas tran Vdout1_7ck5 AVG v(dout1_7) FROM=119.9n TO=120.1n

.meas tran Vdout1_8ck5 AVG v(dout1_8) FROM=119.9n TO=120.1n

.meas tran Vdout1_9ck5 AVG v(dout1_9) FROM=119.9n TO=120.1n

.meas tran Vdout1_10ck5 AVG v(dout1_10) FROM=119.9n TO=120.1n

.meas tran Vdout1_11ck5 AVG v(dout1_11) FROM=119.9n TO=120.1n

.meas tran Vdout1_12ck5 AVG v(dout1_12) FROM=119.9n TO=120.1n

.meas tran Vdout1_13ck5 AVG v(dout1_13) FROM=119.9n TO=120.1n

.meas tran Vdout1_14ck5 AVG v(dout1_14) FROM=119.9n TO=120.1n

.meas tran Vdout1_15ck5 AVG v(dout1_15) FROM=119.9n TO=120.1n

.meas tran Vdout1_16ck5 AVG v(dout1_16) FROM=119.9n TO=120.1n

.meas tran Vdout1_17ck5 AVG v(dout1_17) FROM=119.9n TO=120.1n

.meas tran Vdout1_18ck5 AVG v(dout1_18) FROM=119.9n TO=120.1n

.meas tran Vdout1_19ck5 AVG v(dout1_19) FROM=119.9n TO=120.1n

.meas tran Vdout1_20ck5 AVG v(dout1_20) FROM=119.9n TO=120.1n

.meas tran Vdout1_21ck5 AVG v(dout1_21) FROM=119.9n TO=120.1n

.meas tran Vdout1_22ck5 AVG v(dout1_22) FROM=119.9n TO=120.1n

.meas tran Vdout1_23ck5 AVG v(dout1_23) FROM=119.9n TO=120.1n

.meas tran Vdout1_24ck5 AVG v(dout1_24) FROM=119.9n TO=120.1n

.meas tran Vdout1_25ck5 AVG v(dout1_25) FROM=119.9n TO=120.1n

.meas tran Vdout1_26ck5 AVG v(dout1_26) FROM=119.9n TO=120.1n

.meas tran Vdout1_27ck5 AVG v(dout1_27) FROM=119.9n TO=120.1n

.meas tran Vdout1_28ck5 AVG v(dout1_28) FROM=119.9n TO=120.1n

.meas tran Vdout1_29ck5 AVG v(dout1_29) FROM=119.9n TO=120.1n

.meas tran Vdout1_30ck5 AVG v(dout1_30) FROM=119.9n TO=120.1n

.meas tran Vdout1_31ck5 AVG v(dout1_31) FROM=119.9n TO=120.1n

.meas tran Vdout1_32ck5 AVG v(dout1_32) FROM=119.9n TO=120.1n

.meas tran Vdout1_33ck5 AVG v(dout1_33) FROM=119.9n TO=120.1n

.meas tran Vdout1_34ck5 AVG v(dout1_34) FROM=119.9n TO=120.1n

.meas tran Vdout1_35ck5 AVG v(dout1_35) FROM=119.9n TO=120.1n

.meas tran Vdout1_36ck5 AVG v(dout1_36) FROM=119.9n TO=120.1n

.meas tran Vdout1_37ck5 AVG v(dout1_37) FROM=119.9n TO=120.1n

.meas tran Vdout1_38ck5 AVG v(dout1_38) FROM=119.9n TO=120.1n

.meas tran Vdout1_39ck5 AVG v(dout1_39) FROM=119.9n TO=120.1n

.meas tran Vdout1_40ck5 AVG v(dout1_40) FROM=119.9n TO=120.1n

.meas tran Vdout1_41ck5 AVG v(dout1_41) FROM=119.9n TO=120.1n

.meas tran Vdout1_42ck5 AVG v(dout1_42) FROM=119.9n TO=120.1n

.meas tran Vdout1_43ck5 AVG v(dout1_43) FROM=119.9n TO=120.1n

.meas tran Vdout1_44ck5 AVG v(dout1_44) FROM=119.9n TO=120.1n

.meas tran Vdout1_45ck5 AVG v(dout1_45) FROM=119.9n TO=120.1n

.meas tran Vdout1_46ck5 AVG v(dout1_46) FROM=119.9n TO=120.1n

.meas tran Vdout1_47ck5 AVG v(dout1_47) FROM=119.9n TO=120.1n

.meas tran Vdout1_48ck5 AVG v(dout1_48) FROM=119.9n TO=120.1n

.meas tran Vdout1_49ck5 AVG v(dout1_49) FROM=119.9n TO=120.1n

.meas tran Vdout1_50ck5 AVG v(dout1_50) FROM=119.9n TO=120.1n

.meas tran Vdout1_51ck5 AVG v(dout1_51) FROM=119.9n TO=120.1n

.meas tran Vdout1_52ck5 AVG v(dout1_52) FROM=119.9n TO=120.1n

.meas tran Vdout1_53ck5 AVG v(dout1_53) FROM=119.9n TO=120.1n

.meas tran Vdout1_54ck5 AVG v(dout1_54) FROM=119.9n TO=120.1n

.meas tran Vdout1_55ck5 AVG v(dout1_55) FROM=119.9n TO=120.1n

.meas tran Vdout1_56ck5 AVG v(dout1_56) FROM=119.9n TO=120.1n

.meas tran Vdout1_57ck5 AVG v(dout1_57) FROM=119.9n TO=120.1n

.meas tran Vdout1_58ck5 AVG v(dout1_58) FROM=119.9n TO=120.1n

.meas tran Vdout1_59ck5 AVG v(dout1_59) FROM=119.9n TO=120.1n

.meas tran Vdout1_60ck5 AVG v(dout1_60) FROM=119.9n TO=120.1n

.meas tran Vdout1_61ck5 AVG v(dout1_61) FROM=119.9n TO=120.1n

.meas tran Vdout1_62ck5 AVG v(dout1_62) FROM=119.9n TO=120.1n

.meas tran Vdout1_63ck5 AVG v(dout1_63) FROM=119.9n TO=120.1n

.meas tran Vdout1_64ck5 AVG v(dout1_64) FROM=119.9n TO=120.1n

.meas tran Vdout1_65ck5 AVG v(dout1_65) FROM=119.9n TO=120.1n

.meas tran Vdout1_66ck5 AVG v(dout1_66) FROM=119.9n TO=120.1n

.meas tran Vdout1_67ck5 AVG v(dout1_67) FROM=119.9n TO=120.1n

.meas tran Vdout1_68ck5 AVG v(dout1_68) FROM=119.9n TO=120.1n

.meas tran Vdout1_69ck5 AVG v(dout1_69) FROM=119.9n TO=120.1n

.meas tran Vdout1_70ck5 AVG v(dout1_70) FROM=119.9n TO=120.1n

.meas tran Vdout1_71ck5 AVG v(dout1_71) FROM=119.9n TO=120.1n

.meas tran Vdout1_72ck5 AVG v(dout1_72) FROM=119.9n TO=120.1n

.meas tran Vdout1_73ck5 AVG v(dout1_73) FROM=119.9n TO=120.1n

.meas tran Vdout1_74ck5 AVG v(dout1_74) FROM=119.9n TO=120.1n

.meas tran Vdout1_75ck5 AVG v(dout1_75) FROM=119.9n TO=120.1n

.meas tran Vdout1_76ck5 AVG v(dout1_76) FROM=119.9n TO=120.1n

.meas tran Vdout1_77ck5 AVG v(dout1_77) FROM=119.9n TO=120.1n

.meas tran Vdout1_78ck5 AVG v(dout1_78) FROM=119.9n TO=120.1n

.meas tran Vdout1_79ck5 AVG v(dout1_79) FROM=119.9n TO=120.1n

.meas tran Vdout0_0ck6 AVG v(dout0_0) FROM=139.9n TO=140.1n

.meas tran Vdout0_1ck6 AVG v(dout0_1) FROM=139.9n TO=140.1n

.meas tran Vdout0_2ck6 AVG v(dout0_2) FROM=139.9n TO=140.1n

.meas tran Vdout0_3ck6 AVG v(dout0_3) FROM=139.9n TO=140.1n

.meas tran Vdout0_4ck6 AVG v(dout0_4) FROM=139.9n TO=140.1n

.meas tran Vdout0_5ck6 AVG v(dout0_5) FROM=139.9n TO=140.1n

.meas tran Vdout0_6ck6 AVG v(dout0_6) FROM=139.9n TO=140.1n

.meas tran Vdout0_7ck6 AVG v(dout0_7) FROM=139.9n TO=140.1n

.meas tran Vdout0_8ck6 AVG v(dout0_8) FROM=139.9n TO=140.1n

.meas tran Vdout0_9ck6 AVG v(dout0_9) FROM=139.9n TO=140.1n

.meas tran Vdout0_10ck6 AVG v(dout0_10) FROM=139.9n TO=140.1n

.meas tran Vdout0_11ck6 AVG v(dout0_11) FROM=139.9n TO=140.1n

.meas tran Vdout0_12ck6 AVG v(dout0_12) FROM=139.9n TO=140.1n

.meas tran Vdout0_13ck6 AVG v(dout0_13) FROM=139.9n TO=140.1n

.meas tran Vdout0_14ck6 AVG v(dout0_14) FROM=139.9n TO=140.1n

.meas tran Vdout0_15ck6 AVG v(dout0_15) FROM=139.9n TO=140.1n

.meas tran Vdout0_16ck6 AVG v(dout0_16) FROM=139.9n TO=140.1n

.meas tran Vdout0_17ck6 AVG v(dout0_17) FROM=139.9n TO=140.1n

.meas tran Vdout0_18ck6 AVG v(dout0_18) FROM=139.9n TO=140.1n

.meas tran Vdout0_19ck6 AVG v(dout0_19) FROM=139.9n TO=140.1n

.meas tran Vdout0_20ck6 AVG v(dout0_20) FROM=139.9n TO=140.1n

.meas tran Vdout0_21ck6 AVG v(dout0_21) FROM=139.9n TO=140.1n

.meas tran Vdout0_22ck6 AVG v(dout0_22) FROM=139.9n TO=140.1n

.meas tran Vdout0_23ck6 AVG v(dout0_23) FROM=139.9n TO=140.1n

.meas tran Vdout0_24ck6 AVG v(dout0_24) FROM=139.9n TO=140.1n

.meas tran Vdout0_25ck6 AVG v(dout0_25) FROM=139.9n TO=140.1n

.meas tran Vdout0_26ck6 AVG v(dout0_26) FROM=139.9n TO=140.1n

.meas tran Vdout0_27ck6 AVG v(dout0_27) FROM=139.9n TO=140.1n

.meas tran Vdout0_28ck6 AVG v(dout0_28) FROM=139.9n TO=140.1n

.meas tran Vdout0_29ck6 AVG v(dout0_29) FROM=139.9n TO=140.1n

.meas tran Vdout0_30ck6 AVG v(dout0_30) FROM=139.9n TO=140.1n

.meas tran Vdout0_31ck6 AVG v(dout0_31) FROM=139.9n TO=140.1n

.meas tran Vdout0_32ck6 AVG v(dout0_32) FROM=139.9n TO=140.1n

.meas tran Vdout0_33ck6 AVG v(dout0_33) FROM=139.9n TO=140.1n

.meas tran Vdout0_34ck6 AVG v(dout0_34) FROM=139.9n TO=140.1n

.meas tran Vdout0_35ck6 AVG v(dout0_35) FROM=139.9n TO=140.1n

.meas tran Vdout0_36ck6 AVG v(dout0_36) FROM=139.9n TO=140.1n

.meas tran Vdout0_37ck6 AVG v(dout0_37) FROM=139.9n TO=140.1n

.meas tran Vdout0_38ck6 AVG v(dout0_38) FROM=139.9n TO=140.1n

.meas tran Vdout0_39ck6 AVG v(dout0_39) FROM=139.9n TO=140.1n

.meas tran Vdout0_40ck6 AVG v(dout0_40) FROM=139.9n TO=140.1n

.meas tran Vdout0_41ck6 AVG v(dout0_41) FROM=139.9n TO=140.1n

.meas tran Vdout0_42ck6 AVG v(dout0_42) FROM=139.9n TO=140.1n

.meas tran Vdout0_43ck6 AVG v(dout0_43) FROM=139.9n TO=140.1n

.meas tran Vdout0_44ck6 AVG v(dout0_44) FROM=139.9n TO=140.1n

.meas tran Vdout0_45ck6 AVG v(dout0_45) FROM=139.9n TO=140.1n

.meas tran Vdout0_46ck6 AVG v(dout0_46) FROM=139.9n TO=140.1n

.meas tran Vdout0_47ck6 AVG v(dout0_47) FROM=139.9n TO=140.1n

.meas tran Vdout0_48ck6 AVG v(dout0_48) FROM=139.9n TO=140.1n

.meas tran Vdout0_49ck6 AVG v(dout0_49) FROM=139.9n TO=140.1n

.meas tran Vdout0_50ck6 AVG v(dout0_50) FROM=139.9n TO=140.1n

.meas tran Vdout0_51ck6 AVG v(dout0_51) FROM=139.9n TO=140.1n

.meas tran Vdout0_52ck6 AVG v(dout0_52) FROM=139.9n TO=140.1n

.meas tran Vdout0_53ck6 AVG v(dout0_53) FROM=139.9n TO=140.1n

.meas tran Vdout0_54ck6 AVG v(dout0_54) FROM=139.9n TO=140.1n

.meas tran Vdout0_55ck6 AVG v(dout0_55) FROM=139.9n TO=140.1n

.meas tran Vdout0_56ck6 AVG v(dout0_56) FROM=139.9n TO=140.1n

.meas tran Vdout0_57ck6 AVG v(dout0_57) FROM=139.9n TO=140.1n

.meas tran Vdout0_58ck6 AVG v(dout0_58) FROM=139.9n TO=140.1n

.meas tran Vdout0_59ck6 AVG v(dout0_59) FROM=139.9n TO=140.1n

.meas tran Vdout0_60ck6 AVG v(dout0_60) FROM=139.9n TO=140.1n

.meas tran Vdout0_61ck6 AVG v(dout0_61) FROM=139.9n TO=140.1n

.meas tran Vdout0_62ck6 AVG v(dout0_62) FROM=139.9n TO=140.1n

.meas tran Vdout0_63ck6 AVG v(dout0_63) FROM=139.9n TO=140.1n

.meas tran Vdout0_64ck6 AVG v(dout0_64) FROM=139.9n TO=140.1n

.meas tran Vdout0_65ck6 AVG v(dout0_65) FROM=139.9n TO=140.1n

.meas tran Vdout0_66ck6 AVG v(dout0_66) FROM=139.9n TO=140.1n

.meas tran Vdout0_67ck6 AVG v(dout0_67) FROM=139.9n TO=140.1n

.meas tran Vdout0_68ck6 AVG v(dout0_68) FROM=139.9n TO=140.1n

.meas tran Vdout0_69ck6 AVG v(dout0_69) FROM=139.9n TO=140.1n

.meas tran Vdout0_70ck6 AVG v(dout0_70) FROM=139.9n TO=140.1n

.meas tran Vdout0_71ck6 AVG v(dout0_71) FROM=139.9n TO=140.1n

.meas tran Vdout0_72ck6 AVG v(dout0_72) FROM=139.9n TO=140.1n

.meas tran Vdout0_73ck6 AVG v(dout0_73) FROM=139.9n TO=140.1n

.meas tran Vdout0_74ck6 AVG v(dout0_74) FROM=139.9n TO=140.1n

.meas tran Vdout0_75ck6 AVG v(dout0_75) FROM=139.9n TO=140.1n

.meas tran Vdout0_76ck6 AVG v(dout0_76) FROM=139.9n TO=140.1n

.meas tran Vdout0_77ck6 AVG v(dout0_77) FROM=139.9n TO=140.1n

.meas tran Vdout0_78ck6 AVG v(dout0_78) FROM=139.9n TO=140.1n

.meas tran Vdout0_79ck6 AVG v(dout0_79) FROM=139.9n TO=140.1n

.meas tran Vdout1_0ck7 AVG v(dout1_0) FROM=139.9n TO=140.1n

.meas tran Vdout1_1ck7 AVG v(dout1_1) FROM=139.9n TO=140.1n

.meas tran Vdout1_2ck7 AVG v(dout1_2) FROM=139.9n TO=140.1n

.meas tran Vdout1_3ck7 AVG v(dout1_3) FROM=139.9n TO=140.1n

.meas tran Vdout1_4ck7 AVG v(dout1_4) FROM=139.9n TO=140.1n

.meas tran Vdout1_5ck7 AVG v(dout1_5) FROM=139.9n TO=140.1n

.meas tran Vdout1_6ck7 AVG v(dout1_6) FROM=139.9n TO=140.1n

.meas tran Vdout1_7ck7 AVG v(dout1_7) FROM=139.9n TO=140.1n

.meas tran Vdout1_8ck7 AVG v(dout1_8) FROM=139.9n TO=140.1n

.meas tran Vdout1_9ck7 AVG v(dout1_9) FROM=139.9n TO=140.1n

.meas tran Vdout1_10ck7 AVG v(dout1_10) FROM=139.9n TO=140.1n

.meas tran Vdout1_11ck7 AVG v(dout1_11) FROM=139.9n TO=140.1n

.meas tran Vdout1_12ck7 AVG v(dout1_12) FROM=139.9n TO=140.1n

.meas tran Vdout1_13ck7 AVG v(dout1_13) FROM=139.9n TO=140.1n

.meas tran Vdout1_14ck7 AVG v(dout1_14) FROM=139.9n TO=140.1n

.meas tran Vdout1_15ck7 AVG v(dout1_15) FROM=139.9n TO=140.1n

.meas tran Vdout1_16ck7 AVG v(dout1_16) FROM=139.9n TO=140.1n

.meas tran Vdout1_17ck7 AVG v(dout1_17) FROM=139.9n TO=140.1n

.meas tran Vdout1_18ck7 AVG v(dout1_18) FROM=139.9n TO=140.1n

.meas tran Vdout1_19ck7 AVG v(dout1_19) FROM=139.9n TO=140.1n

.meas tran Vdout1_20ck7 AVG v(dout1_20) FROM=139.9n TO=140.1n

.meas tran Vdout1_21ck7 AVG v(dout1_21) FROM=139.9n TO=140.1n

.meas tran Vdout1_22ck7 AVG v(dout1_22) FROM=139.9n TO=140.1n

.meas tran Vdout1_23ck7 AVG v(dout1_23) FROM=139.9n TO=140.1n

.meas tran Vdout1_24ck7 AVG v(dout1_24) FROM=139.9n TO=140.1n

.meas tran Vdout1_25ck7 AVG v(dout1_25) FROM=139.9n TO=140.1n

.meas tran Vdout1_26ck7 AVG v(dout1_26) FROM=139.9n TO=140.1n

.meas tran Vdout1_27ck7 AVG v(dout1_27) FROM=139.9n TO=140.1n

.meas tran Vdout1_28ck7 AVG v(dout1_28) FROM=139.9n TO=140.1n

.meas tran Vdout1_29ck7 AVG v(dout1_29) FROM=139.9n TO=140.1n

.meas tran Vdout1_30ck7 AVG v(dout1_30) FROM=139.9n TO=140.1n

.meas tran Vdout1_31ck7 AVG v(dout1_31) FROM=139.9n TO=140.1n

.meas tran Vdout1_32ck7 AVG v(dout1_32) FROM=139.9n TO=140.1n

.meas tran Vdout1_33ck7 AVG v(dout1_33) FROM=139.9n TO=140.1n

.meas tran Vdout1_34ck7 AVG v(dout1_34) FROM=139.9n TO=140.1n

.meas tran Vdout1_35ck7 AVG v(dout1_35) FROM=139.9n TO=140.1n

.meas tran Vdout1_36ck7 AVG v(dout1_36) FROM=139.9n TO=140.1n

.meas tran Vdout1_37ck7 AVG v(dout1_37) FROM=139.9n TO=140.1n

.meas tran Vdout1_38ck7 AVG v(dout1_38) FROM=139.9n TO=140.1n

.meas tran Vdout1_39ck7 AVG v(dout1_39) FROM=139.9n TO=140.1n

.meas tran Vdout1_40ck7 AVG v(dout1_40) FROM=139.9n TO=140.1n

.meas tran Vdout1_41ck7 AVG v(dout1_41) FROM=139.9n TO=140.1n

.meas tran Vdout1_42ck7 AVG v(dout1_42) FROM=139.9n TO=140.1n

.meas tran Vdout1_43ck7 AVG v(dout1_43) FROM=139.9n TO=140.1n

.meas tran Vdout1_44ck7 AVG v(dout1_44) FROM=139.9n TO=140.1n

.meas tran Vdout1_45ck7 AVG v(dout1_45) FROM=139.9n TO=140.1n

.meas tran Vdout1_46ck7 AVG v(dout1_46) FROM=139.9n TO=140.1n

.meas tran Vdout1_47ck7 AVG v(dout1_47) FROM=139.9n TO=140.1n

.meas tran Vdout1_48ck7 AVG v(dout1_48) FROM=139.9n TO=140.1n

.meas tran Vdout1_49ck7 AVG v(dout1_49) FROM=139.9n TO=140.1n

.meas tran Vdout1_50ck7 AVG v(dout1_50) FROM=139.9n TO=140.1n

.meas tran Vdout1_51ck7 AVG v(dout1_51) FROM=139.9n TO=140.1n

.meas tran Vdout1_52ck7 AVG v(dout1_52) FROM=139.9n TO=140.1n

.meas tran Vdout1_53ck7 AVG v(dout1_53) FROM=139.9n TO=140.1n

.meas tran Vdout1_54ck7 AVG v(dout1_54) FROM=139.9n TO=140.1n

.meas tran Vdout1_55ck7 AVG v(dout1_55) FROM=139.9n TO=140.1n

.meas tran Vdout1_56ck7 AVG v(dout1_56) FROM=139.9n TO=140.1n

.meas tran Vdout1_57ck7 AVG v(dout1_57) FROM=139.9n TO=140.1n

.meas tran Vdout1_58ck7 AVG v(dout1_58) FROM=139.9n TO=140.1n

.meas tran Vdout1_59ck7 AVG v(dout1_59) FROM=139.9n TO=140.1n

.meas tran Vdout1_60ck7 AVG v(dout1_60) FROM=139.9n TO=140.1n

.meas tran Vdout1_61ck7 AVG v(dout1_61) FROM=139.9n TO=140.1n

.meas tran Vdout1_62ck7 AVG v(dout1_62) FROM=139.9n TO=140.1n

.meas tran Vdout1_63ck7 AVG v(dout1_63) FROM=139.9n TO=140.1n

.meas tran Vdout1_64ck7 AVG v(dout1_64) FROM=139.9n TO=140.1n

.meas tran Vdout1_65ck7 AVG v(dout1_65) FROM=139.9n TO=140.1n

.meas tran Vdout1_66ck7 AVG v(dout1_66) FROM=139.9n TO=140.1n

.meas tran Vdout1_67ck7 AVG v(dout1_67) FROM=139.9n TO=140.1n

.meas tran Vdout1_68ck7 AVG v(dout1_68) FROM=139.9n TO=140.1n

.meas tran Vdout1_69ck7 AVG v(dout1_69) FROM=139.9n TO=140.1n

.meas tran Vdout1_70ck7 AVG v(dout1_70) FROM=139.9n TO=140.1n

.meas tran Vdout1_71ck7 AVG v(dout1_71) FROM=139.9n TO=140.1n

.meas tran Vdout1_72ck7 AVG v(dout1_72) FROM=139.9n TO=140.1n

.meas tran Vdout1_73ck7 AVG v(dout1_73) FROM=139.9n TO=140.1n

.meas tran Vdout1_74ck7 AVG v(dout1_74) FROM=139.9n TO=140.1n

.meas tran Vdout1_75ck7 AVG v(dout1_75) FROM=139.9n TO=140.1n

.meas tran Vdout1_76ck7 AVG v(dout1_76) FROM=139.9n TO=140.1n

.meas tran Vdout1_77ck7 AVG v(dout1_77) FROM=139.9n TO=140.1n

.meas tran Vdout1_78ck7 AVG v(dout1_78) FROM=139.9n TO=140.1n

.meas tran Vdout1_79ck7 AVG v(dout1_79) FROM=139.9n TO=140.1n

.meas tran Vdout1_0ck8 AVG v(dout1_0) FROM=149.9n TO=150.1n

.meas tran Vdout1_1ck8 AVG v(dout1_1) FROM=149.9n TO=150.1n

.meas tran Vdout1_2ck8 AVG v(dout1_2) FROM=149.9n TO=150.1n

.meas tran Vdout1_3ck8 AVG v(dout1_3) FROM=149.9n TO=150.1n

.meas tran Vdout1_4ck8 AVG v(dout1_4) FROM=149.9n TO=150.1n

.meas tran Vdout1_5ck8 AVG v(dout1_5) FROM=149.9n TO=150.1n

.meas tran Vdout1_6ck8 AVG v(dout1_6) FROM=149.9n TO=150.1n

.meas tran Vdout1_7ck8 AVG v(dout1_7) FROM=149.9n TO=150.1n

.meas tran Vdout1_8ck8 AVG v(dout1_8) FROM=149.9n TO=150.1n

.meas tran Vdout1_9ck8 AVG v(dout1_9) FROM=149.9n TO=150.1n

.meas tran Vdout1_10ck8 AVG v(dout1_10) FROM=149.9n TO=150.1n

.meas tran Vdout1_11ck8 AVG v(dout1_11) FROM=149.9n TO=150.1n

.meas tran Vdout1_12ck8 AVG v(dout1_12) FROM=149.9n TO=150.1n

.meas tran Vdout1_13ck8 AVG v(dout1_13) FROM=149.9n TO=150.1n

.meas tran Vdout1_14ck8 AVG v(dout1_14) FROM=149.9n TO=150.1n

.meas tran Vdout1_15ck8 AVG v(dout1_15) FROM=149.9n TO=150.1n

.meas tran Vdout1_16ck8 AVG v(dout1_16) FROM=149.9n TO=150.1n

.meas tran Vdout1_17ck8 AVG v(dout1_17) FROM=149.9n TO=150.1n

.meas tran Vdout1_18ck8 AVG v(dout1_18) FROM=149.9n TO=150.1n

.meas tran Vdout1_19ck8 AVG v(dout1_19) FROM=149.9n TO=150.1n

.meas tran Vdout1_20ck8 AVG v(dout1_20) FROM=149.9n TO=150.1n

.meas tran Vdout1_21ck8 AVG v(dout1_21) FROM=149.9n TO=150.1n

.meas tran Vdout1_22ck8 AVG v(dout1_22) FROM=149.9n TO=150.1n

.meas tran Vdout1_23ck8 AVG v(dout1_23) FROM=149.9n TO=150.1n

.meas tran Vdout1_24ck8 AVG v(dout1_24) FROM=149.9n TO=150.1n

.meas tran Vdout1_25ck8 AVG v(dout1_25) FROM=149.9n TO=150.1n

.meas tran Vdout1_26ck8 AVG v(dout1_26) FROM=149.9n TO=150.1n

.meas tran Vdout1_27ck8 AVG v(dout1_27) FROM=149.9n TO=150.1n

.meas tran Vdout1_28ck8 AVG v(dout1_28) FROM=149.9n TO=150.1n

.meas tran Vdout1_29ck8 AVG v(dout1_29) FROM=149.9n TO=150.1n

.meas tran Vdout1_30ck8 AVG v(dout1_30) FROM=149.9n TO=150.1n

.meas tran Vdout1_31ck8 AVG v(dout1_31) FROM=149.9n TO=150.1n

.meas tran Vdout1_32ck8 AVG v(dout1_32) FROM=149.9n TO=150.1n

.meas tran Vdout1_33ck8 AVG v(dout1_33) FROM=149.9n TO=150.1n

.meas tran Vdout1_34ck8 AVG v(dout1_34) FROM=149.9n TO=150.1n

.meas tran Vdout1_35ck8 AVG v(dout1_35) FROM=149.9n TO=150.1n

.meas tran Vdout1_36ck8 AVG v(dout1_36) FROM=149.9n TO=150.1n

.meas tran Vdout1_37ck8 AVG v(dout1_37) FROM=149.9n TO=150.1n

.meas tran Vdout1_38ck8 AVG v(dout1_38) FROM=149.9n TO=150.1n

.meas tran Vdout1_39ck8 AVG v(dout1_39) FROM=149.9n TO=150.1n

.meas tran Vdout1_40ck8 AVG v(dout1_40) FROM=149.9n TO=150.1n

.meas tran Vdout1_41ck8 AVG v(dout1_41) FROM=149.9n TO=150.1n

.meas tran Vdout1_42ck8 AVG v(dout1_42) FROM=149.9n TO=150.1n

.meas tran Vdout1_43ck8 AVG v(dout1_43) FROM=149.9n TO=150.1n

.meas tran Vdout1_44ck8 AVG v(dout1_44) FROM=149.9n TO=150.1n

.meas tran Vdout1_45ck8 AVG v(dout1_45) FROM=149.9n TO=150.1n

.meas tran Vdout1_46ck8 AVG v(dout1_46) FROM=149.9n TO=150.1n

.meas tran Vdout1_47ck8 AVG v(dout1_47) FROM=149.9n TO=150.1n

.meas tran Vdout1_48ck8 AVG v(dout1_48) FROM=149.9n TO=150.1n

.meas tran Vdout1_49ck8 AVG v(dout1_49) FROM=149.9n TO=150.1n

.meas tran Vdout1_50ck8 AVG v(dout1_50) FROM=149.9n TO=150.1n

.meas tran Vdout1_51ck8 AVG v(dout1_51) FROM=149.9n TO=150.1n

.meas tran Vdout1_52ck8 AVG v(dout1_52) FROM=149.9n TO=150.1n

.meas tran Vdout1_53ck8 AVG v(dout1_53) FROM=149.9n TO=150.1n

.meas tran Vdout1_54ck8 AVG v(dout1_54) FROM=149.9n TO=150.1n

.meas tran Vdout1_55ck8 AVG v(dout1_55) FROM=149.9n TO=150.1n

.meas tran Vdout1_56ck8 AVG v(dout1_56) FROM=149.9n TO=150.1n

.meas tran Vdout1_57ck8 AVG v(dout1_57) FROM=149.9n TO=150.1n

.meas tran Vdout1_58ck8 AVG v(dout1_58) FROM=149.9n TO=150.1n

.meas tran Vdout1_59ck8 AVG v(dout1_59) FROM=149.9n TO=150.1n

.meas tran Vdout1_60ck8 AVG v(dout1_60) FROM=149.9n TO=150.1n

.meas tran Vdout1_61ck8 AVG v(dout1_61) FROM=149.9n TO=150.1n

.meas tran Vdout1_62ck8 AVG v(dout1_62) FROM=149.9n TO=150.1n

.meas tran Vdout1_63ck8 AVG v(dout1_63) FROM=149.9n TO=150.1n

.meas tran Vdout1_64ck8 AVG v(dout1_64) FROM=149.9n TO=150.1n

.meas tran Vdout1_65ck8 AVG v(dout1_65) FROM=149.9n TO=150.1n

.meas tran Vdout1_66ck8 AVG v(dout1_66) FROM=149.9n TO=150.1n

.meas tran Vdout1_67ck8 AVG v(dout1_67) FROM=149.9n TO=150.1n

.meas tran Vdout1_68ck8 AVG v(dout1_68) FROM=149.9n TO=150.1n

.meas tran Vdout1_69ck8 AVG v(dout1_69) FROM=149.9n TO=150.1n

.meas tran Vdout1_70ck8 AVG v(dout1_70) FROM=149.9n TO=150.1n

.meas tran Vdout1_71ck8 AVG v(dout1_71) FROM=149.9n TO=150.1n

.meas tran Vdout1_72ck8 AVG v(dout1_72) FROM=149.9n TO=150.1n

.meas tran Vdout1_73ck8 AVG v(dout1_73) FROM=149.9n TO=150.1n

.meas tran Vdout1_74ck8 AVG v(dout1_74) FROM=149.9n TO=150.1n

.meas tran Vdout1_75ck8 AVG v(dout1_75) FROM=149.9n TO=150.1n

.meas tran Vdout1_76ck8 AVG v(dout1_76) FROM=149.9n TO=150.1n

.meas tran Vdout1_77ck8 AVG v(dout1_77) FROM=149.9n TO=150.1n

.meas tran Vdout1_78ck8 AVG v(dout1_78) FROM=149.9n TO=150.1n

.meas tran Vdout1_79ck8 AVG v(dout1_79) FROM=149.9n TO=150.1n

.meas tran Vdout0_0ck9 AVG v(dout0_0) FROM=159.9n TO=160.1n

.meas tran Vdout0_1ck9 AVG v(dout0_1) FROM=159.9n TO=160.1n

.meas tran Vdout0_2ck9 AVG v(dout0_2) FROM=159.9n TO=160.1n

.meas tran Vdout0_3ck9 AVG v(dout0_3) FROM=159.9n TO=160.1n

.meas tran Vdout0_4ck9 AVG v(dout0_4) FROM=159.9n TO=160.1n

.meas tran Vdout0_5ck9 AVG v(dout0_5) FROM=159.9n TO=160.1n

.meas tran Vdout0_6ck9 AVG v(dout0_6) FROM=159.9n TO=160.1n

.meas tran Vdout0_7ck9 AVG v(dout0_7) FROM=159.9n TO=160.1n

.meas tran Vdout0_8ck9 AVG v(dout0_8) FROM=159.9n TO=160.1n

.meas tran Vdout0_9ck9 AVG v(dout0_9) FROM=159.9n TO=160.1n

.meas tran Vdout0_10ck9 AVG v(dout0_10) FROM=159.9n TO=160.1n

.meas tran Vdout0_11ck9 AVG v(dout0_11) FROM=159.9n TO=160.1n

.meas tran Vdout0_12ck9 AVG v(dout0_12) FROM=159.9n TO=160.1n

.meas tran Vdout0_13ck9 AVG v(dout0_13) FROM=159.9n TO=160.1n

.meas tran Vdout0_14ck9 AVG v(dout0_14) FROM=159.9n TO=160.1n

.meas tran Vdout0_15ck9 AVG v(dout0_15) FROM=159.9n TO=160.1n

.meas tran Vdout0_16ck9 AVG v(dout0_16) FROM=159.9n TO=160.1n

.meas tran Vdout0_17ck9 AVG v(dout0_17) FROM=159.9n TO=160.1n

.meas tran Vdout0_18ck9 AVG v(dout0_18) FROM=159.9n TO=160.1n

.meas tran Vdout0_19ck9 AVG v(dout0_19) FROM=159.9n TO=160.1n

.meas tran Vdout0_20ck9 AVG v(dout0_20) FROM=159.9n TO=160.1n

.meas tran Vdout0_21ck9 AVG v(dout0_21) FROM=159.9n TO=160.1n

.meas tran Vdout0_22ck9 AVG v(dout0_22) FROM=159.9n TO=160.1n

.meas tran Vdout0_23ck9 AVG v(dout0_23) FROM=159.9n TO=160.1n

.meas tran Vdout0_24ck9 AVG v(dout0_24) FROM=159.9n TO=160.1n

.meas tran Vdout0_25ck9 AVG v(dout0_25) FROM=159.9n TO=160.1n

.meas tran Vdout0_26ck9 AVG v(dout0_26) FROM=159.9n TO=160.1n

.meas tran Vdout0_27ck9 AVG v(dout0_27) FROM=159.9n TO=160.1n

.meas tran Vdout0_28ck9 AVG v(dout0_28) FROM=159.9n TO=160.1n

.meas tran Vdout0_29ck9 AVG v(dout0_29) FROM=159.9n TO=160.1n

.meas tran Vdout0_30ck9 AVG v(dout0_30) FROM=159.9n TO=160.1n

.meas tran Vdout0_31ck9 AVG v(dout0_31) FROM=159.9n TO=160.1n

.meas tran Vdout0_32ck9 AVG v(dout0_32) FROM=159.9n TO=160.1n

.meas tran Vdout0_33ck9 AVG v(dout0_33) FROM=159.9n TO=160.1n

.meas tran Vdout0_34ck9 AVG v(dout0_34) FROM=159.9n TO=160.1n

.meas tran Vdout0_35ck9 AVG v(dout0_35) FROM=159.9n TO=160.1n

.meas tran Vdout0_36ck9 AVG v(dout0_36) FROM=159.9n TO=160.1n

.meas tran Vdout0_37ck9 AVG v(dout0_37) FROM=159.9n TO=160.1n

.meas tran Vdout0_38ck9 AVG v(dout0_38) FROM=159.9n TO=160.1n

.meas tran Vdout0_39ck9 AVG v(dout0_39) FROM=159.9n TO=160.1n

.meas tran Vdout0_40ck9 AVG v(dout0_40) FROM=159.9n TO=160.1n

.meas tran Vdout0_41ck9 AVG v(dout0_41) FROM=159.9n TO=160.1n

.meas tran Vdout0_42ck9 AVG v(dout0_42) FROM=159.9n TO=160.1n

.meas tran Vdout0_43ck9 AVG v(dout0_43) FROM=159.9n TO=160.1n

.meas tran Vdout0_44ck9 AVG v(dout0_44) FROM=159.9n TO=160.1n

.meas tran Vdout0_45ck9 AVG v(dout0_45) FROM=159.9n TO=160.1n

.meas tran Vdout0_46ck9 AVG v(dout0_46) FROM=159.9n TO=160.1n

.meas tran Vdout0_47ck9 AVG v(dout0_47) FROM=159.9n TO=160.1n

.meas tran Vdout0_48ck9 AVG v(dout0_48) FROM=159.9n TO=160.1n

.meas tran Vdout0_49ck9 AVG v(dout0_49) FROM=159.9n TO=160.1n

.meas tran Vdout0_50ck9 AVG v(dout0_50) FROM=159.9n TO=160.1n

.meas tran Vdout0_51ck9 AVG v(dout0_51) FROM=159.9n TO=160.1n

.meas tran Vdout0_52ck9 AVG v(dout0_52) FROM=159.9n TO=160.1n

.meas tran Vdout0_53ck9 AVG v(dout0_53) FROM=159.9n TO=160.1n

.meas tran Vdout0_54ck9 AVG v(dout0_54) FROM=159.9n TO=160.1n

.meas tran Vdout0_55ck9 AVG v(dout0_55) FROM=159.9n TO=160.1n

.meas tran Vdout0_56ck9 AVG v(dout0_56) FROM=159.9n TO=160.1n

.meas tran Vdout0_57ck9 AVG v(dout0_57) FROM=159.9n TO=160.1n

.meas tran Vdout0_58ck9 AVG v(dout0_58) FROM=159.9n TO=160.1n

.meas tran Vdout0_59ck9 AVG v(dout0_59) FROM=159.9n TO=160.1n

.meas tran Vdout0_60ck9 AVG v(dout0_60) FROM=159.9n TO=160.1n

.meas tran Vdout0_61ck9 AVG v(dout0_61) FROM=159.9n TO=160.1n

.meas tran Vdout0_62ck9 AVG v(dout0_62) FROM=159.9n TO=160.1n

.meas tran Vdout0_63ck9 AVG v(dout0_63) FROM=159.9n TO=160.1n

.meas tran Vdout0_64ck9 AVG v(dout0_64) FROM=159.9n TO=160.1n

.meas tran Vdout0_65ck9 AVG v(dout0_65) FROM=159.9n TO=160.1n

.meas tran Vdout0_66ck9 AVG v(dout0_66) FROM=159.9n TO=160.1n

.meas tran Vdout0_67ck9 AVG v(dout0_67) FROM=159.9n TO=160.1n

.meas tran Vdout0_68ck9 AVG v(dout0_68) FROM=159.9n TO=160.1n

.meas tran Vdout0_69ck9 AVG v(dout0_69) FROM=159.9n TO=160.1n

.meas tran Vdout0_70ck9 AVG v(dout0_70) FROM=159.9n TO=160.1n

.meas tran Vdout0_71ck9 AVG v(dout0_71) FROM=159.9n TO=160.1n

.meas tran Vdout0_72ck9 AVG v(dout0_72) FROM=159.9n TO=160.1n

.meas tran Vdout0_73ck9 AVG v(dout0_73) FROM=159.9n TO=160.1n

.meas tran Vdout0_74ck9 AVG v(dout0_74) FROM=159.9n TO=160.1n

.meas tran Vdout0_75ck9 AVG v(dout0_75) FROM=159.9n TO=160.1n

.meas tran Vdout0_76ck9 AVG v(dout0_76) FROM=159.9n TO=160.1n

.meas tran Vdout0_77ck9 AVG v(dout0_77) FROM=159.9n TO=160.1n

.meas tran Vdout0_78ck9 AVG v(dout0_78) FROM=159.9n TO=160.1n

.meas tran Vdout0_79ck9 AVG v(dout0_79) FROM=159.9n TO=160.1n

.meas tran Vdout1_0ck10 AVG v(dout1_0) FROM=159.9n TO=160.1n

.meas tran Vdout1_1ck10 AVG v(dout1_1) FROM=159.9n TO=160.1n

.meas tran Vdout1_2ck10 AVG v(dout1_2) FROM=159.9n TO=160.1n

.meas tran Vdout1_3ck10 AVG v(dout1_3) FROM=159.9n TO=160.1n

.meas tran Vdout1_4ck10 AVG v(dout1_4) FROM=159.9n TO=160.1n

.meas tran Vdout1_5ck10 AVG v(dout1_5) FROM=159.9n TO=160.1n

.meas tran Vdout1_6ck10 AVG v(dout1_6) FROM=159.9n TO=160.1n

.meas tran Vdout1_7ck10 AVG v(dout1_7) FROM=159.9n TO=160.1n

.meas tran Vdout1_8ck10 AVG v(dout1_8) FROM=159.9n TO=160.1n

.meas tran Vdout1_9ck10 AVG v(dout1_9) FROM=159.9n TO=160.1n

.meas tran Vdout1_10ck10 AVG v(dout1_10) FROM=159.9n TO=160.1n

.meas tran Vdout1_11ck10 AVG v(dout1_11) FROM=159.9n TO=160.1n

.meas tran Vdout1_12ck10 AVG v(dout1_12) FROM=159.9n TO=160.1n

.meas tran Vdout1_13ck10 AVG v(dout1_13) FROM=159.9n TO=160.1n

.meas tran Vdout1_14ck10 AVG v(dout1_14) FROM=159.9n TO=160.1n

.meas tran Vdout1_15ck10 AVG v(dout1_15) FROM=159.9n TO=160.1n

.meas tran Vdout1_16ck10 AVG v(dout1_16) FROM=159.9n TO=160.1n

.meas tran Vdout1_17ck10 AVG v(dout1_17) FROM=159.9n TO=160.1n

.meas tran Vdout1_18ck10 AVG v(dout1_18) FROM=159.9n TO=160.1n

.meas tran Vdout1_19ck10 AVG v(dout1_19) FROM=159.9n TO=160.1n

.meas tran Vdout1_20ck10 AVG v(dout1_20) FROM=159.9n TO=160.1n

.meas tran Vdout1_21ck10 AVG v(dout1_21) FROM=159.9n TO=160.1n

.meas tran Vdout1_22ck10 AVG v(dout1_22) FROM=159.9n TO=160.1n

.meas tran Vdout1_23ck10 AVG v(dout1_23) FROM=159.9n TO=160.1n

.meas tran Vdout1_24ck10 AVG v(dout1_24) FROM=159.9n TO=160.1n

.meas tran Vdout1_25ck10 AVG v(dout1_25) FROM=159.9n TO=160.1n

.meas tran Vdout1_26ck10 AVG v(dout1_26) FROM=159.9n TO=160.1n

.meas tran Vdout1_27ck10 AVG v(dout1_27) FROM=159.9n TO=160.1n

.meas tran Vdout1_28ck10 AVG v(dout1_28) FROM=159.9n TO=160.1n

.meas tran Vdout1_29ck10 AVG v(dout1_29) FROM=159.9n TO=160.1n

.meas tran Vdout1_30ck10 AVG v(dout1_30) FROM=159.9n TO=160.1n

.meas tran Vdout1_31ck10 AVG v(dout1_31) FROM=159.9n TO=160.1n

.meas tran Vdout1_32ck10 AVG v(dout1_32) FROM=159.9n TO=160.1n

.meas tran Vdout1_33ck10 AVG v(dout1_33) FROM=159.9n TO=160.1n

.meas tran Vdout1_34ck10 AVG v(dout1_34) FROM=159.9n TO=160.1n

.meas tran Vdout1_35ck10 AVG v(dout1_35) FROM=159.9n TO=160.1n

.meas tran Vdout1_36ck10 AVG v(dout1_36) FROM=159.9n TO=160.1n

.meas tran Vdout1_37ck10 AVG v(dout1_37) FROM=159.9n TO=160.1n

.meas tran Vdout1_38ck10 AVG v(dout1_38) FROM=159.9n TO=160.1n

.meas tran Vdout1_39ck10 AVG v(dout1_39) FROM=159.9n TO=160.1n

.meas tran Vdout1_40ck10 AVG v(dout1_40) FROM=159.9n TO=160.1n

.meas tran Vdout1_41ck10 AVG v(dout1_41) FROM=159.9n TO=160.1n

.meas tran Vdout1_42ck10 AVG v(dout1_42) FROM=159.9n TO=160.1n

.meas tran Vdout1_43ck10 AVG v(dout1_43) FROM=159.9n TO=160.1n

.meas tran Vdout1_44ck10 AVG v(dout1_44) FROM=159.9n TO=160.1n

.meas tran Vdout1_45ck10 AVG v(dout1_45) FROM=159.9n TO=160.1n

.meas tran Vdout1_46ck10 AVG v(dout1_46) FROM=159.9n TO=160.1n

.meas tran Vdout1_47ck10 AVG v(dout1_47) FROM=159.9n TO=160.1n

.meas tran Vdout1_48ck10 AVG v(dout1_48) FROM=159.9n TO=160.1n

.meas tran Vdout1_49ck10 AVG v(dout1_49) FROM=159.9n TO=160.1n

.meas tran Vdout1_50ck10 AVG v(dout1_50) FROM=159.9n TO=160.1n

.meas tran Vdout1_51ck10 AVG v(dout1_51) FROM=159.9n TO=160.1n

.meas tran Vdout1_52ck10 AVG v(dout1_52) FROM=159.9n TO=160.1n

.meas tran Vdout1_53ck10 AVG v(dout1_53) FROM=159.9n TO=160.1n

.meas tran Vdout1_54ck10 AVG v(dout1_54) FROM=159.9n TO=160.1n

.meas tran Vdout1_55ck10 AVG v(dout1_55) FROM=159.9n TO=160.1n

.meas tran Vdout1_56ck10 AVG v(dout1_56) FROM=159.9n TO=160.1n

.meas tran Vdout1_57ck10 AVG v(dout1_57) FROM=159.9n TO=160.1n

.meas tran Vdout1_58ck10 AVG v(dout1_58) FROM=159.9n TO=160.1n

.meas tran Vdout1_59ck10 AVG v(dout1_59) FROM=159.9n TO=160.1n

.meas tran Vdout1_60ck10 AVG v(dout1_60) FROM=159.9n TO=160.1n

.meas tran Vdout1_61ck10 AVG v(dout1_61) FROM=159.9n TO=160.1n

.meas tran Vdout1_62ck10 AVG v(dout1_62) FROM=159.9n TO=160.1n

.meas tran Vdout1_63ck10 AVG v(dout1_63) FROM=159.9n TO=160.1n

.meas tran Vdout1_64ck10 AVG v(dout1_64) FROM=159.9n TO=160.1n

.meas tran Vdout1_65ck10 AVG v(dout1_65) FROM=159.9n TO=160.1n

.meas tran Vdout1_66ck10 AVG v(dout1_66) FROM=159.9n TO=160.1n

.meas tran Vdout1_67ck10 AVG v(dout1_67) FROM=159.9n TO=160.1n

.meas tran Vdout1_68ck10 AVG v(dout1_68) FROM=159.9n TO=160.1n

.meas tran Vdout1_69ck10 AVG v(dout1_69) FROM=159.9n TO=160.1n

.meas tran Vdout1_70ck10 AVG v(dout1_70) FROM=159.9n TO=160.1n

.meas tran Vdout1_71ck10 AVG v(dout1_71) FROM=159.9n TO=160.1n

.meas tran Vdout1_72ck10 AVG v(dout1_72) FROM=159.9n TO=160.1n

.meas tran Vdout1_73ck10 AVG v(dout1_73) FROM=159.9n TO=160.1n

.meas tran Vdout1_74ck10 AVG v(dout1_74) FROM=159.9n TO=160.1n

.meas tran Vdout1_75ck10 AVG v(dout1_75) FROM=159.9n TO=160.1n

.meas tran Vdout1_76ck10 AVG v(dout1_76) FROM=159.9n TO=160.1n

.meas tran Vdout1_77ck10 AVG v(dout1_77) FROM=159.9n TO=160.1n

.meas tran Vdout1_78ck10 AVG v(dout1_78) FROM=159.9n TO=160.1n

.meas tran Vdout1_79ck10 AVG v(dout1_79) FROM=159.9n TO=160.1n

.meas tran Vdout1_0ck11 AVG v(dout1_0) FROM=179.9n TO=180.1n

.meas tran Vdout1_1ck11 AVG v(dout1_1) FROM=179.9n TO=180.1n

.meas tran Vdout1_2ck11 AVG v(dout1_2) FROM=179.9n TO=180.1n

.meas tran Vdout1_3ck11 AVG v(dout1_3) FROM=179.9n TO=180.1n

.meas tran Vdout1_4ck11 AVG v(dout1_4) FROM=179.9n TO=180.1n

.meas tran Vdout1_5ck11 AVG v(dout1_5) FROM=179.9n TO=180.1n

.meas tran Vdout1_6ck11 AVG v(dout1_6) FROM=179.9n TO=180.1n

.meas tran Vdout1_7ck11 AVG v(dout1_7) FROM=179.9n TO=180.1n

.meas tran Vdout1_8ck11 AVG v(dout1_8) FROM=179.9n TO=180.1n

.meas tran Vdout1_9ck11 AVG v(dout1_9) FROM=179.9n TO=180.1n

.meas tran Vdout1_10ck11 AVG v(dout1_10) FROM=179.9n TO=180.1n

.meas tran Vdout1_11ck11 AVG v(dout1_11) FROM=179.9n TO=180.1n

.meas tran Vdout1_12ck11 AVG v(dout1_12) FROM=179.9n TO=180.1n

.meas tran Vdout1_13ck11 AVG v(dout1_13) FROM=179.9n TO=180.1n

.meas tran Vdout1_14ck11 AVG v(dout1_14) FROM=179.9n TO=180.1n

.meas tran Vdout1_15ck11 AVG v(dout1_15) FROM=179.9n TO=180.1n

.meas tran Vdout1_16ck11 AVG v(dout1_16) FROM=179.9n TO=180.1n

.meas tran Vdout1_17ck11 AVG v(dout1_17) FROM=179.9n TO=180.1n

.meas tran Vdout1_18ck11 AVG v(dout1_18) FROM=179.9n TO=180.1n

.meas tran Vdout1_19ck11 AVG v(dout1_19) FROM=179.9n TO=180.1n

.meas tran Vdout1_20ck11 AVG v(dout1_20) FROM=179.9n TO=180.1n

.meas tran Vdout1_21ck11 AVG v(dout1_21) FROM=179.9n TO=180.1n

.meas tran Vdout1_22ck11 AVG v(dout1_22) FROM=179.9n TO=180.1n

.meas tran Vdout1_23ck11 AVG v(dout1_23) FROM=179.9n TO=180.1n

.meas tran Vdout1_24ck11 AVG v(dout1_24) FROM=179.9n TO=180.1n

.meas tran Vdout1_25ck11 AVG v(dout1_25) FROM=179.9n TO=180.1n

.meas tran Vdout1_26ck11 AVG v(dout1_26) FROM=179.9n TO=180.1n

.meas tran Vdout1_27ck11 AVG v(dout1_27) FROM=179.9n TO=180.1n

.meas tran Vdout1_28ck11 AVG v(dout1_28) FROM=179.9n TO=180.1n

.meas tran Vdout1_29ck11 AVG v(dout1_29) FROM=179.9n TO=180.1n

.meas tran Vdout1_30ck11 AVG v(dout1_30) FROM=179.9n TO=180.1n

.meas tran Vdout1_31ck11 AVG v(dout1_31) FROM=179.9n TO=180.1n

.meas tran Vdout1_32ck11 AVG v(dout1_32) FROM=179.9n TO=180.1n

.meas tran Vdout1_33ck11 AVG v(dout1_33) FROM=179.9n TO=180.1n

.meas tran Vdout1_34ck11 AVG v(dout1_34) FROM=179.9n TO=180.1n

.meas tran Vdout1_35ck11 AVG v(dout1_35) FROM=179.9n TO=180.1n

.meas tran Vdout1_36ck11 AVG v(dout1_36) FROM=179.9n TO=180.1n

.meas tran Vdout1_37ck11 AVG v(dout1_37) FROM=179.9n TO=180.1n

.meas tran Vdout1_38ck11 AVG v(dout1_38) FROM=179.9n TO=180.1n

.meas tran Vdout1_39ck11 AVG v(dout1_39) FROM=179.9n TO=180.1n

.meas tran Vdout1_40ck11 AVG v(dout1_40) FROM=179.9n TO=180.1n

.meas tran Vdout1_41ck11 AVG v(dout1_41) FROM=179.9n TO=180.1n

.meas tran Vdout1_42ck11 AVG v(dout1_42) FROM=179.9n TO=180.1n

.meas tran Vdout1_43ck11 AVG v(dout1_43) FROM=179.9n TO=180.1n

.meas tran Vdout1_44ck11 AVG v(dout1_44) FROM=179.9n TO=180.1n

.meas tran Vdout1_45ck11 AVG v(dout1_45) FROM=179.9n TO=180.1n

.meas tran Vdout1_46ck11 AVG v(dout1_46) FROM=179.9n TO=180.1n

.meas tran Vdout1_47ck11 AVG v(dout1_47) FROM=179.9n TO=180.1n

.meas tran Vdout1_48ck11 AVG v(dout1_48) FROM=179.9n TO=180.1n

.meas tran Vdout1_49ck11 AVG v(dout1_49) FROM=179.9n TO=180.1n

.meas tran Vdout1_50ck11 AVG v(dout1_50) FROM=179.9n TO=180.1n

.meas tran Vdout1_51ck11 AVG v(dout1_51) FROM=179.9n TO=180.1n

.meas tran Vdout1_52ck11 AVG v(dout1_52) FROM=179.9n TO=180.1n

.meas tran Vdout1_53ck11 AVG v(dout1_53) FROM=179.9n TO=180.1n

.meas tran Vdout1_54ck11 AVG v(dout1_54) FROM=179.9n TO=180.1n

.meas tran Vdout1_55ck11 AVG v(dout1_55) FROM=179.9n TO=180.1n

.meas tran Vdout1_56ck11 AVG v(dout1_56) FROM=179.9n TO=180.1n

.meas tran Vdout1_57ck11 AVG v(dout1_57) FROM=179.9n TO=180.1n

.meas tran Vdout1_58ck11 AVG v(dout1_58) FROM=179.9n TO=180.1n

.meas tran Vdout1_59ck11 AVG v(dout1_59) FROM=179.9n TO=180.1n

.meas tran Vdout1_60ck11 AVG v(dout1_60) FROM=179.9n TO=180.1n

.meas tran Vdout1_61ck11 AVG v(dout1_61) FROM=179.9n TO=180.1n

.meas tran Vdout1_62ck11 AVG v(dout1_62) FROM=179.9n TO=180.1n

.meas tran Vdout1_63ck11 AVG v(dout1_63) FROM=179.9n TO=180.1n

.meas tran Vdout1_64ck11 AVG v(dout1_64) FROM=179.9n TO=180.1n

.meas tran Vdout1_65ck11 AVG v(dout1_65) FROM=179.9n TO=180.1n

.meas tran Vdout1_66ck11 AVG v(dout1_66) FROM=179.9n TO=180.1n

.meas tran Vdout1_67ck11 AVG v(dout1_67) FROM=179.9n TO=180.1n

.meas tran Vdout1_68ck11 AVG v(dout1_68) FROM=179.9n TO=180.1n

.meas tran Vdout1_69ck11 AVG v(dout1_69) FROM=179.9n TO=180.1n

.meas tran Vdout1_70ck11 AVG v(dout1_70) FROM=179.9n TO=180.1n

.meas tran Vdout1_71ck11 AVG v(dout1_71) FROM=179.9n TO=180.1n

.meas tran Vdout1_72ck11 AVG v(dout1_72) FROM=179.9n TO=180.1n

.meas tran Vdout1_73ck11 AVG v(dout1_73) FROM=179.9n TO=180.1n

.meas tran Vdout1_74ck11 AVG v(dout1_74) FROM=179.9n TO=180.1n

.meas tran Vdout1_75ck11 AVG v(dout1_75) FROM=179.9n TO=180.1n

.meas tran Vdout1_76ck11 AVG v(dout1_76) FROM=179.9n TO=180.1n

.meas tran Vdout1_77ck11 AVG v(dout1_77) FROM=179.9n TO=180.1n

.meas tran Vdout1_78ck11 AVG v(dout1_78) FROM=179.9n TO=180.1n

.meas tran Vdout1_79ck11 AVG v(dout1_79) FROM=179.9n TO=180.1n

.meas tran Vdout0_0ck12 AVG v(dout0_0) FROM=189.9n TO=190.1n

.meas tran Vdout0_1ck12 AVG v(dout0_1) FROM=189.9n TO=190.1n

.meas tran Vdout0_2ck12 AVG v(dout0_2) FROM=189.9n TO=190.1n

.meas tran Vdout0_3ck12 AVG v(dout0_3) FROM=189.9n TO=190.1n

.meas tran Vdout0_4ck12 AVG v(dout0_4) FROM=189.9n TO=190.1n

.meas tran Vdout0_5ck12 AVG v(dout0_5) FROM=189.9n TO=190.1n

.meas tran Vdout0_6ck12 AVG v(dout0_6) FROM=189.9n TO=190.1n

.meas tran Vdout0_7ck12 AVG v(dout0_7) FROM=189.9n TO=190.1n

.meas tran Vdout0_8ck12 AVG v(dout0_8) FROM=189.9n TO=190.1n

.meas tran Vdout0_9ck12 AVG v(dout0_9) FROM=189.9n TO=190.1n

.meas tran Vdout0_10ck12 AVG v(dout0_10) FROM=189.9n TO=190.1n

.meas tran Vdout0_11ck12 AVG v(dout0_11) FROM=189.9n TO=190.1n

.meas tran Vdout0_12ck12 AVG v(dout0_12) FROM=189.9n TO=190.1n

.meas tran Vdout0_13ck12 AVG v(dout0_13) FROM=189.9n TO=190.1n

.meas tran Vdout0_14ck12 AVG v(dout0_14) FROM=189.9n TO=190.1n

.meas tran Vdout0_15ck12 AVG v(dout0_15) FROM=189.9n TO=190.1n

.meas tran Vdout0_16ck12 AVG v(dout0_16) FROM=189.9n TO=190.1n

.meas tran Vdout0_17ck12 AVG v(dout0_17) FROM=189.9n TO=190.1n

.meas tran Vdout0_18ck12 AVG v(dout0_18) FROM=189.9n TO=190.1n

.meas tran Vdout0_19ck12 AVG v(dout0_19) FROM=189.9n TO=190.1n

.meas tran Vdout0_20ck12 AVG v(dout0_20) FROM=189.9n TO=190.1n

.meas tran Vdout0_21ck12 AVG v(dout0_21) FROM=189.9n TO=190.1n

.meas tran Vdout0_22ck12 AVG v(dout0_22) FROM=189.9n TO=190.1n

.meas tran Vdout0_23ck12 AVG v(dout0_23) FROM=189.9n TO=190.1n

.meas tran Vdout0_24ck12 AVG v(dout0_24) FROM=189.9n TO=190.1n

.meas tran Vdout0_25ck12 AVG v(dout0_25) FROM=189.9n TO=190.1n

.meas tran Vdout0_26ck12 AVG v(dout0_26) FROM=189.9n TO=190.1n

.meas tran Vdout0_27ck12 AVG v(dout0_27) FROM=189.9n TO=190.1n

.meas tran Vdout0_28ck12 AVG v(dout0_28) FROM=189.9n TO=190.1n

.meas tran Vdout0_29ck12 AVG v(dout0_29) FROM=189.9n TO=190.1n

.meas tran Vdout0_30ck12 AVG v(dout0_30) FROM=189.9n TO=190.1n

.meas tran Vdout0_31ck12 AVG v(dout0_31) FROM=189.9n TO=190.1n

.meas tran Vdout0_32ck12 AVG v(dout0_32) FROM=189.9n TO=190.1n

.meas tran Vdout0_33ck12 AVG v(dout0_33) FROM=189.9n TO=190.1n

.meas tran Vdout0_34ck12 AVG v(dout0_34) FROM=189.9n TO=190.1n

.meas tran Vdout0_35ck12 AVG v(dout0_35) FROM=189.9n TO=190.1n

.meas tran Vdout0_36ck12 AVG v(dout0_36) FROM=189.9n TO=190.1n

.meas tran Vdout0_37ck12 AVG v(dout0_37) FROM=189.9n TO=190.1n

.meas tran Vdout0_38ck12 AVG v(dout0_38) FROM=189.9n TO=190.1n

.meas tran Vdout0_39ck12 AVG v(dout0_39) FROM=189.9n TO=190.1n

.meas tran Vdout0_40ck12 AVG v(dout0_40) FROM=189.9n TO=190.1n

.meas tran Vdout0_41ck12 AVG v(dout0_41) FROM=189.9n TO=190.1n

.meas tran Vdout0_42ck12 AVG v(dout0_42) FROM=189.9n TO=190.1n

.meas tran Vdout0_43ck12 AVG v(dout0_43) FROM=189.9n TO=190.1n

.meas tran Vdout0_44ck12 AVG v(dout0_44) FROM=189.9n TO=190.1n

.meas tran Vdout0_45ck12 AVG v(dout0_45) FROM=189.9n TO=190.1n

.meas tran Vdout0_46ck12 AVG v(dout0_46) FROM=189.9n TO=190.1n

.meas tran Vdout0_47ck12 AVG v(dout0_47) FROM=189.9n TO=190.1n

.meas tran Vdout0_48ck12 AVG v(dout0_48) FROM=189.9n TO=190.1n

.meas tran Vdout0_49ck12 AVG v(dout0_49) FROM=189.9n TO=190.1n

.meas tran Vdout0_50ck12 AVG v(dout0_50) FROM=189.9n TO=190.1n

.meas tran Vdout0_51ck12 AVG v(dout0_51) FROM=189.9n TO=190.1n

.meas tran Vdout0_52ck12 AVG v(dout0_52) FROM=189.9n TO=190.1n

.meas tran Vdout0_53ck12 AVG v(dout0_53) FROM=189.9n TO=190.1n

.meas tran Vdout0_54ck12 AVG v(dout0_54) FROM=189.9n TO=190.1n

.meas tran Vdout0_55ck12 AVG v(dout0_55) FROM=189.9n TO=190.1n

.meas tran Vdout0_56ck12 AVG v(dout0_56) FROM=189.9n TO=190.1n

.meas tran Vdout0_57ck12 AVG v(dout0_57) FROM=189.9n TO=190.1n

.meas tran Vdout0_58ck12 AVG v(dout0_58) FROM=189.9n TO=190.1n

.meas tran Vdout0_59ck12 AVG v(dout0_59) FROM=189.9n TO=190.1n

.meas tran Vdout0_60ck12 AVG v(dout0_60) FROM=189.9n TO=190.1n

.meas tran Vdout0_61ck12 AVG v(dout0_61) FROM=189.9n TO=190.1n

.meas tran Vdout0_62ck12 AVG v(dout0_62) FROM=189.9n TO=190.1n

.meas tran Vdout0_63ck12 AVG v(dout0_63) FROM=189.9n TO=190.1n

.meas tran Vdout0_64ck12 AVG v(dout0_64) FROM=189.9n TO=190.1n

.meas tran Vdout0_65ck12 AVG v(dout0_65) FROM=189.9n TO=190.1n

.meas tran Vdout0_66ck12 AVG v(dout0_66) FROM=189.9n TO=190.1n

.meas tran Vdout0_67ck12 AVG v(dout0_67) FROM=189.9n TO=190.1n

.meas tran Vdout0_68ck12 AVG v(dout0_68) FROM=189.9n TO=190.1n

.meas tran Vdout0_69ck12 AVG v(dout0_69) FROM=189.9n TO=190.1n

.meas tran Vdout0_70ck12 AVG v(dout0_70) FROM=189.9n TO=190.1n

.meas tran Vdout0_71ck12 AVG v(dout0_71) FROM=189.9n TO=190.1n

.meas tran Vdout0_72ck12 AVG v(dout0_72) FROM=189.9n TO=190.1n

.meas tran Vdout0_73ck12 AVG v(dout0_73) FROM=189.9n TO=190.1n

.meas tran Vdout0_74ck12 AVG v(dout0_74) FROM=189.9n TO=190.1n

.meas tran Vdout0_75ck12 AVG v(dout0_75) FROM=189.9n TO=190.1n

.meas tran Vdout0_76ck12 AVG v(dout0_76) FROM=189.9n TO=190.1n

.meas tran Vdout0_77ck12 AVG v(dout0_77) FROM=189.9n TO=190.1n

.meas tran Vdout0_78ck12 AVG v(dout0_78) FROM=189.9n TO=190.1n

.meas tran Vdout0_79ck12 AVG v(dout0_79) FROM=189.9n TO=190.1n

.meas tran Vdout1_0ck13 AVG v(dout1_0) FROM=189.9n TO=190.1n

.meas tran Vdout1_1ck13 AVG v(dout1_1) FROM=189.9n TO=190.1n

.meas tran Vdout1_2ck13 AVG v(dout1_2) FROM=189.9n TO=190.1n

.meas tran Vdout1_3ck13 AVG v(dout1_3) FROM=189.9n TO=190.1n

.meas tran Vdout1_4ck13 AVG v(dout1_4) FROM=189.9n TO=190.1n

.meas tran Vdout1_5ck13 AVG v(dout1_5) FROM=189.9n TO=190.1n

.meas tran Vdout1_6ck13 AVG v(dout1_6) FROM=189.9n TO=190.1n

.meas tran Vdout1_7ck13 AVG v(dout1_7) FROM=189.9n TO=190.1n

.meas tran Vdout1_8ck13 AVG v(dout1_8) FROM=189.9n TO=190.1n

.meas tran Vdout1_9ck13 AVG v(dout1_9) FROM=189.9n TO=190.1n

.meas tran Vdout1_10ck13 AVG v(dout1_10) FROM=189.9n TO=190.1n

.meas tran Vdout1_11ck13 AVG v(dout1_11) FROM=189.9n TO=190.1n

.meas tran Vdout1_12ck13 AVG v(dout1_12) FROM=189.9n TO=190.1n

.meas tran Vdout1_13ck13 AVG v(dout1_13) FROM=189.9n TO=190.1n

.meas tran Vdout1_14ck13 AVG v(dout1_14) FROM=189.9n TO=190.1n

.meas tran Vdout1_15ck13 AVG v(dout1_15) FROM=189.9n TO=190.1n

.meas tran Vdout1_16ck13 AVG v(dout1_16) FROM=189.9n TO=190.1n

.meas tran Vdout1_17ck13 AVG v(dout1_17) FROM=189.9n TO=190.1n

.meas tran Vdout1_18ck13 AVG v(dout1_18) FROM=189.9n TO=190.1n

.meas tran Vdout1_19ck13 AVG v(dout1_19) FROM=189.9n TO=190.1n

.meas tran Vdout1_20ck13 AVG v(dout1_20) FROM=189.9n TO=190.1n

.meas tran Vdout1_21ck13 AVG v(dout1_21) FROM=189.9n TO=190.1n

.meas tran Vdout1_22ck13 AVG v(dout1_22) FROM=189.9n TO=190.1n

.meas tran Vdout1_23ck13 AVG v(dout1_23) FROM=189.9n TO=190.1n

.meas tran Vdout1_24ck13 AVG v(dout1_24) FROM=189.9n TO=190.1n

.meas tran Vdout1_25ck13 AVG v(dout1_25) FROM=189.9n TO=190.1n

.meas tran Vdout1_26ck13 AVG v(dout1_26) FROM=189.9n TO=190.1n

.meas tran Vdout1_27ck13 AVG v(dout1_27) FROM=189.9n TO=190.1n

.meas tran Vdout1_28ck13 AVG v(dout1_28) FROM=189.9n TO=190.1n

.meas tran Vdout1_29ck13 AVG v(dout1_29) FROM=189.9n TO=190.1n

.meas tran Vdout1_30ck13 AVG v(dout1_30) FROM=189.9n TO=190.1n

.meas tran Vdout1_31ck13 AVG v(dout1_31) FROM=189.9n TO=190.1n

.meas tran Vdout1_32ck13 AVG v(dout1_32) FROM=189.9n TO=190.1n

.meas tran Vdout1_33ck13 AVG v(dout1_33) FROM=189.9n TO=190.1n

.meas tran Vdout1_34ck13 AVG v(dout1_34) FROM=189.9n TO=190.1n

.meas tran Vdout1_35ck13 AVG v(dout1_35) FROM=189.9n TO=190.1n

.meas tran Vdout1_36ck13 AVG v(dout1_36) FROM=189.9n TO=190.1n

.meas tran Vdout1_37ck13 AVG v(dout1_37) FROM=189.9n TO=190.1n

.meas tran Vdout1_38ck13 AVG v(dout1_38) FROM=189.9n TO=190.1n

.meas tran Vdout1_39ck13 AVG v(dout1_39) FROM=189.9n TO=190.1n

.meas tran Vdout1_40ck13 AVG v(dout1_40) FROM=189.9n TO=190.1n

.meas tran Vdout1_41ck13 AVG v(dout1_41) FROM=189.9n TO=190.1n

.meas tran Vdout1_42ck13 AVG v(dout1_42) FROM=189.9n TO=190.1n

.meas tran Vdout1_43ck13 AVG v(dout1_43) FROM=189.9n TO=190.1n

.meas tran Vdout1_44ck13 AVG v(dout1_44) FROM=189.9n TO=190.1n

.meas tran Vdout1_45ck13 AVG v(dout1_45) FROM=189.9n TO=190.1n

.meas tran Vdout1_46ck13 AVG v(dout1_46) FROM=189.9n TO=190.1n

.meas tran Vdout1_47ck13 AVG v(dout1_47) FROM=189.9n TO=190.1n

.meas tran Vdout1_48ck13 AVG v(dout1_48) FROM=189.9n TO=190.1n

.meas tran Vdout1_49ck13 AVG v(dout1_49) FROM=189.9n TO=190.1n

.meas tran Vdout1_50ck13 AVG v(dout1_50) FROM=189.9n TO=190.1n

.meas tran Vdout1_51ck13 AVG v(dout1_51) FROM=189.9n TO=190.1n

.meas tran Vdout1_52ck13 AVG v(dout1_52) FROM=189.9n TO=190.1n

.meas tran Vdout1_53ck13 AVG v(dout1_53) FROM=189.9n TO=190.1n

.meas tran Vdout1_54ck13 AVG v(dout1_54) FROM=189.9n TO=190.1n

.meas tran Vdout1_55ck13 AVG v(dout1_55) FROM=189.9n TO=190.1n

.meas tran Vdout1_56ck13 AVG v(dout1_56) FROM=189.9n TO=190.1n

.meas tran Vdout1_57ck13 AVG v(dout1_57) FROM=189.9n TO=190.1n

.meas tran Vdout1_58ck13 AVG v(dout1_58) FROM=189.9n TO=190.1n

.meas tran Vdout1_59ck13 AVG v(dout1_59) FROM=189.9n TO=190.1n

.meas tran Vdout1_60ck13 AVG v(dout1_60) FROM=189.9n TO=190.1n

.meas tran Vdout1_61ck13 AVG v(dout1_61) FROM=189.9n TO=190.1n

.meas tran Vdout1_62ck13 AVG v(dout1_62) FROM=189.9n TO=190.1n

.meas tran Vdout1_63ck13 AVG v(dout1_63) FROM=189.9n TO=190.1n

.meas tran Vdout1_64ck13 AVG v(dout1_64) FROM=189.9n TO=190.1n

.meas tran Vdout1_65ck13 AVG v(dout1_65) FROM=189.9n TO=190.1n

.meas tran Vdout1_66ck13 AVG v(dout1_66) FROM=189.9n TO=190.1n

.meas tran Vdout1_67ck13 AVG v(dout1_67) FROM=189.9n TO=190.1n

.meas tran Vdout1_68ck13 AVG v(dout1_68) FROM=189.9n TO=190.1n

.meas tran Vdout1_69ck13 AVG v(dout1_69) FROM=189.9n TO=190.1n

.meas tran Vdout1_70ck13 AVG v(dout1_70) FROM=189.9n TO=190.1n

.meas tran Vdout1_71ck13 AVG v(dout1_71) FROM=189.9n TO=190.1n

.meas tran Vdout1_72ck13 AVG v(dout1_72) FROM=189.9n TO=190.1n

.meas tran Vdout1_73ck13 AVG v(dout1_73) FROM=189.9n TO=190.1n

.meas tran Vdout1_74ck13 AVG v(dout1_74) FROM=189.9n TO=190.1n

.meas tran Vdout1_75ck13 AVG v(dout1_75) FROM=189.9n TO=190.1n

.meas tran Vdout1_76ck13 AVG v(dout1_76) FROM=189.9n TO=190.1n

.meas tran Vdout1_77ck13 AVG v(dout1_77) FROM=189.9n TO=190.1n

.meas tran Vdout1_78ck13 AVG v(dout1_78) FROM=189.9n TO=190.1n

.meas tran Vdout1_79ck13 AVG v(dout1_79) FROM=189.9n TO=190.1n

.meas tran Vdout0_0ck14 AVG v(dout0_0) FROM=199.9n TO=200.1n

.meas tran Vdout0_1ck14 AVG v(dout0_1) FROM=199.9n TO=200.1n

.meas tran Vdout0_2ck14 AVG v(dout0_2) FROM=199.9n TO=200.1n

.meas tran Vdout0_3ck14 AVG v(dout0_3) FROM=199.9n TO=200.1n

.meas tran Vdout0_4ck14 AVG v(dout0_4) FROM=199.9n TO=200.1n

.meas tran Vdout0_5ck14 AVG v(dout0_5) FROM=199.9n TO=200.1n

.meas tran Vdout0_6ck14 AVG v(dout0_6) FROM=199.9n TO=200.1n

.meas tran Vdout0_7ck14 AVG v(dout0_7) FROM=199.9n TO=200.1n

.meas tran Vdout0_8ck14 AVG v(dout0_8) FROM=199.9n TO=200.1n

.meas tran Vdout0_9ck14 AVG v(dout0_9) FROM=199.9n TO=200.1n

.meas tran Vdout0_10ck14 AVG v(dout0_10) FROM=199.9n TO=200.1n

.meas tran Vdout0_11ck14 AVG v(dout0_11) FROM=199.9n TO=200.1n

.meas tran Vdout0_12ck14 AVG v(dout0_12) FROM=199.9n TO=200.1n

.meas tran Vdout0_13ck14 AVG v(dout0_13) FROM=199.9n TO=200.1n

.meas tran Vdout0_14ck14 AVG v(dout0_14) FROM=199.9n TO=200.1n

.meas tran Vdout0_15ck14 AVG v(dout0_15) FROM=199.9n TO=200.1n

.meas tran Vdout0_16ck14 AVG v(dout0_16) FROM=199.9n TO=200.1n

.meas tran Vdout0_17ck14 AVG v(dout0_17) FROM=199.9n TO=200.1n

.meas tran Vdout0_18ck14 AVG v(dout0_18) FROM=199.9n TO=200.1n

.meas tran Vdout0_19ck14 AVG v(dout0_19) FROM=199.9n TO=200.1n

.meas tran Vdout0_20ck14 AVG v(dout0_20) FROM=199.9n TO=200.1n

.meas tran Vdout0_21ck14 AVG v(dout0_21) FROM=199.9n TO=200.1n

.meas tran Vdout0_22ck14 AVG v(dout0_22) FROM=199.9n TO=200.1n

.meas tran Vdout0_23ck14 AVG v(dout0_23) FROM=199.9n TO=200.1n

.meas tran Vdout0_24ck14 AVG v(dout0_24) FROM=199.9n TO=200.1n

.meas tran Vdout0_25ck14 AVG v(dout0_25) FROM=199.9n TO=200.1n

.meas tran Vdout0_26ck14 AVG v(dout0_26) FROM=199.9n TO=200.1n

.meas tran Vdout0_27ck14 AVG v(dout0_27) FROM=199.9n TO=200.1n

.meas tran Vdout0_28ck14 AVG v(dout0_28) FROM=199.9n TO=200.1n

.meas tran Vdout0_29ck14 AVG v(dout0_29) FROM=199.9n TO=200.1n

.meas tran Vdout0_30ck14 AVG v(dout0_30) FROM=199.9n TO=200.1n

.meas tran Vdout0_31ck14 AVG v(dout0_31) FROM=199.9n TO=200.1n

.meas tran Vdout0_32ck14 AVG v(dout0_32) FROM=199.9n TO=200.1n

.meas tran Vdout0_33ck14 AVG v(dout0_33) FROM=199.9n TO=200.1n

.meas tran Vdout0_34ck14 AVG v(dout0_34) FROM=199.9n TO=200.1n

.meas tran Vdout0_35ck14 AVG v(dout0_35) FROM=199.9n TO=200.1n

.meas tran Vdout0_36ck14 AVG v(dout0_36) FROM=199.9n TO=200.1n

.meas tran Vdout0_37ck14 AVG v(dout0_37) FROM=199.9n TO=200.1n

.meas tran Vdout0_38ck14 AVG v(dout0_38) FROM=199.9n TO=200.1n

.meas tran Vdout0_39ck14 AVG v(dout0_39) FROM=199.9n TO=200.1n

.meas tran Vdout0_40ck14 AVG v(dout0_40) FROM=199.9n TO=200.1n

.meas tran Vdout0_41ck14 AVG v(dout0_41) FROM=199.9n TO=200.1n

.meas tran Vdout0_42ck14 AVG v(dout0_42) FROM=199.9n TO=200.1n

.meas tran Vdout0_43ck14 AVG v(dout0_43) FROM=199.9n TO=200.1n

.meas tran Vdout0_44ck14 AVG v(dout0_44) FROM=199.9n TO=200.1n

.meas tran Vdout0_45ck14 AVG v(dout0_45) FROM=199.9n TO=200.1n

.meas tran Vdout0_46ck14 AVG v(dout0_46) FROM=199.9n TO=200.1n

.meas tran Vdout0_47ck14 AVG v(dout0_47) FROM=199.9n TO=200.1n

.meas tran Vdout0_48ck14 AVG v(dout0_48) FROM=199.9n TO=200.1n

.meas tran Vdout0_49ck14 AVG v(dout0_49) FROM=199.9n TO=200.1n

.meas tran Vdout0_50ck14 AVG v(dout0_50) FROM=199.9n TO=200.1n

.meas tran Vdout0_51ck14 AVG v(dout0_51) FROM=199.9n TO=200.1n

.meas tran Vdout0_52ck14 AVG v(dout0_52) FROM=199.9n TO=200.1n

.meas tran Vdout0_53ck14 AVG v(dout0_53) FROM=199.9n TO=200.1n

.meas tran Vdout0_54ck14 AVG v(dout0_54) FROM=199.9n TO=200.1n

.meas tran Vdout0_55ck14 AVG v(dout0_55) FROM=199.9n TO=200.1n

.meas tran Vdout0_56ck14 AVG v(dout0_56) FROM=199.9n TO=200.1n

.meas tran Vdout0_57ck14 AVG v(dout0_57) FROM=199.9n TO=200.1n

.meas tran Vdout0_58ck14 AVG v(dout0_58) FROM=199.9n TO=200.1n

.meas tran Vdout0_59ck14 AVG v(dout0_59) FROM=199.9n TO=200.1n

.meas tran Vdout0_60ck14 AVG v(dout0_60) FROM=199.9n TO=200.1n

.meas tran Vdout0_61ck14 AVG v(dout0_61) FROM=199.9n TO=200.1n

.meas tran Vdout0_62ck14 AVG v(dout0_62) FROM=199.9n TO=200.1n

.meas tran Vdout0_63ck14 AVG v(dout0_63) FROM=199.9n TO=200.1n

.meas tran Vdout0_64ck14 AVG v(dout0_64) FROM=199.9n TO=200.1n

.meas tran Vdout0_65ck14 AVG v(dout0_65) FROM=199.9n TO=200.1n

.meas tran Vdout0_66ck14 AVG v(dout0_66) FROM=199.9n TO=200.1n

.meas tran Vdout0_67ck14 AVG v(dout0_67) FROM=199.9n TO=200.1n

.meas tran Vdout0_68ck14 AVG v(dout0_68) FROM=199.9n TO=200.1n

.meas tran Vdout0_69ck14 AVG v(dout0_69) FROM=199.9n TO=200.1n

.meas tran Vdout0_70ck14 AVG v(dout0_70) FROM=199.9n TO=200.1n

.meas tran Vdout0_71ck14 AVG v(dout0_71) FROM=199.9n TO=200.1n

.meas tran Vdout0_72ck14 AVG v(dout0_72) FROM=199.9n TO=200.1n

.meas tran Vdout0_73ck14 AVG v(dout0_73) FROM=199.9n TO=200.1n

.meas tran Vdout0_74ck14 AVG v(dout0_74) FROM=199.9n TO=200.1n

.meas tran Vdout0_75ck14 AVG v(dout0_75) FROM=199.9n TO=200.1n

.meas tran Vdout0_76ck14 AVG v(dout0_76) FROM=199.9n TO=200.1n

.meas tran Vdout0_77ck14 AVG v(dout0_77) FROM=199.9n TO=200.1n

.meas tran Vdout0_78ck14 AVG v(dout0_78) FROM=199.9n TO=200.1n

.meas tran Vdout0_79ck14 AVG v(dout0_79) FROM=199.9n TO=200.1n

.meas tran Vdout0_0ck15 AVG v(dout0_0) FROM=229.9n TO=230.1n

.meas tran Vdout0_1ck15 AVG v(dout0_1) FROM=229.9n TO=230.1n

.meas tran Vdout0_2ck15 AVG v(dout0_2) FROM=229.9n TO=230.1n

.meas tran Vdout0_3ck15 AVG v(dout0_3) FROM=229.9n TO=230.1n

.meas tran Vdout0_4ck15 AVG v(dout0_4) FROM=229.9n TO=230.1n

.meas tran Vdout0_5ck15 AVG v(dout0_5) FROM=229.9n TO=230.1n

.meas tran Vdout0_6ck15 AVG v(dout0_6) FROM=229.9n TO=230.1n

.meas tran Vdout0_7ck15 AVG v(dout0_7) FROM=229.9n TO=230.1n

.meas tran Vdout0_8ck15 AVG v(dout0_8) FROM=229.9n TO=230.1n

.meas tran Vdout0_9ck15 AVG v(dout0_9) FROM=229.9n TO=230.1n

.meas tran Vdout0_10ck15 AVG v(dout0_10) FROM=229.9n TO=230.1n

.meas tran Vdout0_11ck15 AVG v(dout0_11) FROM=229.9n TO=230.1n

.meas tran Vdout0_12ck15 AVG v(dout0_12) FROM=229.9n TO=230.1n

.meas tran Vdout0_13ck15 AVG v(dout0_13) FROM=229.9n TO=230.1n

.meas tran Vdout0_14ck15 AVG v(dout0_14) FROM=229.9n TO=230.1n

.meas tran Vdout0_15ck15 AVG v(dout0_15) FROM=229.9n TO=230.1n

.meas tran Vdout0_16ck15 AVG v(dout0_16) FROM=229.9n TO=230.1n

.meas tran Vdout0_17ck15 AVG v(dout0_17) FROM=229.9n TO=230.1n

.meas tran Vdout0_18ck15 AVG v(dout0_18) FROM=229.9n TO=230.1n

.meas tran Vdout0_19ck15 AVG v(dout0_19) FROM=229.9n TO=230.1n

.meas tran Vdout0_20ck15 AVG v(dout0_20) FROM=229.9n TO=230.1n

.meas tran Vdout0_21ck15 AVG v(dout0_21) FROM=229.9n TO=230.1n

.meas tran Vdout0_22ck15 AVG v(dout0_22) FROM=229.9n TO=230.1n

.meas tran Vdout0_23ck15 AVG v(dout0_23) FROM=229.9n TO=230.1n

.meas tran Vdout0_24ck15 AVG v(dout0_24) FROM=229.9n TO=230.1n

.meas tran Vdout0_25ck15 AVG v(dout0_25) FROM=229.9n TO=230.1n

.meas tran Vdout0_26ck15 AVG v(dout0_26) FROM=229.9n TO=230.1n

.meas tran Vdout0_27ck15 AVG v(dout0_27) FROM=229.9n TO=230.1n

.meas tran Vdout0_28ck15 AVG v(dout0_28) FROM=229.9n TO=230.1n

.meas tran Vdout0_29ck15 AVG v(dout0_29) FROM=229.9n TO=230.1n

.meas tran Vdout0_30ck15 AVG v(dout0_30) FROM=229.9n TO=230.1n

.meas tran Vdout0_31ck15 AVG v(dout0_31) FROM=229.9n TO=230.1n

.meas tran Vdout0_32ck15 AVG v(dout0_32) FROM=229.9n TO=230.1n

.meas tran Vdout0_33ck15 AVG v(dout0_33) FROM=229.9n TO=230.1n

.meas tran Vdout0_34ck15 AVG v(dout0_34) FROM=229.9n TO=230.1n

.meas tran Vdout0_35ck15 AVG v(dout0_35) FROM=229.9n TO=230.1n

.meas tran Vdout0_36ck15 AVG v(dout0_36) FROM=229.9n TO=230.1n

.meas tran Vdout0_37ck15 AVG v(dout0_37) FROM=229.9n TO=230.1n

.meas tran Vdout0_38ck15 AVG v(dout0_38) FROM=229.9n TO=230.1n

.meas tran Vdout0_39ck15 AVG v(dout0_39) FROM=229.9n TO=230.1n

.meas tran Vdout0_40ck15 AVG v(dout0_40) FROM=229.9n TO=230.1n

.meas tran Vdout0_41ck15 AVG v(dout0_41) FROM=229.9n TO=230.1n

.meas tran Vdout0_42ck15 AVG v(dout0_42) FROM=229.9n TO=230.1n

.meas tran Vdout0_43ck15 AVG v(dout0_43) FROM=229.9n TO=230.1n

.meas tran Vdout0_44ck15 AVG v(dout0_44) FROM=229.9n TO=230.1n

.meas tran Vdout0_45ck15 AVG v(dout0_45) FROM=229.9n TO=230.1n

.meas tran Vdout0_46ck15 AVG v(dout0_46) FROM=229.9n TO=230.1n

.meas tran Vdout0_47ck15 AVG v(dout0_47) FROM=229.9n TO=230.1n

.meas tran Vdout0_48ck15 AVG v(dout0_48) FROM=229.9n TO=230.1n

.meas tran Vdout0_49ck15 AVG v(dout0_49) FROM=229.9n TO=230.1n

.meas tran Vdout0_50ck15 AVG v(dout0_50) FROM=229.9n TO=230.1n

.meas tran Vdout0_51ck15 AVG v(dout0_51) FROM=229.9n TO=230.1n

.meas tran Vdout0_52ck15 AVG v(dout0_52) FROM=229.9n TO=230.1n

.meas tran Vdout0_53ck15 AVG v(dout0_53) FROM=229.9n TO=230.1n

.meas tran Vdout0_54ck15 AVG v(dout0_54) FROM=229.9n TO=230.1n

.meas tran Vdout0_55ck15 AVG v(dout0_55) FROM=229.9n TO=230.1n

.meas tran Vdout0_56ck15 AVG v(dout0_56) FROM=229.9n TO=230.1n

.meas tran Vdout0_57ck15 AVG v(dout0_57) FROM=229.9n TO=230.1n

.meas tran Vdout0_58ck15 AVG v(dout0_58) FROM=229.9n TO=230.1n

.meas tran Vdout0_59ck15 AVG v(dout0_59) FROM=229.9n TO=230.1n

.meas tran Vdout0_60ck15 AVG v(dout0_60) FROM=229.9n TO=230.1n

.meas tran Vdout0_61ck15 AVG v(dout0_61) FROM=229.9n TO=230.1n

.meas tran Vdout0_62ck15 AVG v(dout0_62) FROM=229.9n TO=230.1n

.meas tran Vdout0_63ck15 AVG v(dout0_63) FROM=229.9n TO=230.1n

.meas tran Vdout0_64ck15 AVG v(dout0_64) FROM=229.9n TO=230.1n

.meas tran Vdout0_65ck15 AVG v(dout0_65) FROM=229.9n TO=230.1n

.meas tran Vdout0_66ck15 AVG v(dout0_66) FROM=229.9n TO=230.1n

.meas tran Vdout0_67ck15 AVG v(dout0_67) FROM=229.9n TO=230.1n

.meas tran Vdout0_68ck15 AVG v(dout0_68) FROM=229.9n TO=230.1n

.meas tran Vdout0_69ck15 AVG v(dout0_69) FROM=229.9n TO=230.1n

.meas tran Vdout0_70ck15 AVG v(dout0_70) FROM=229.9n TO=230.1n

.meas tran Vdout0_71ck15 AVG v(dout0_71) FROM=229.9n TO=230.1n

.meas tran Vdout0_72ck15 AVG v(dout0_72) FROM=229.9n TO=230.1n

.meas tran Vdout0_73ck15 AVG v(dout0_73) FROM=229.9n TO=230.1n

.meas tran Vdout0_74ck15 AVG v(dout0_74) FROM=229.9n TO=230.1n

.meas tran Vdout0_75ck15 AVG v(dout0_75) FROM=229.9n TO=230.1n

.meas tran Vdout0_76ck15 AVG v(dout0_76) FROM=229.9n TO=230.1n

.meas tran Vdout0_77ck15 AVG v(dout0_77) FROM=229.9n TO=230.1n

.meas tran Vdout0_78ck15 AVG v(dout0_78) FROM=229.9n TO=230.1n

.meas tran Vdout0_79ck15 AVG v(dout0_79) FROM=229.9n TO=230.1n

.meas tran Vdout1_0ck16 AVG v(dout1_0) FROM=229.9n TO=230.1n

.meas tran Vdout1_1ck16 AVG v(dout1_1) FROM=229.9n TO=230.1n

.meas tran Vdout1_2ck16 AVG v(dout1_2) FROM=229.9n TO=230.1n

.meas tran Vdout1_3ck16 AVG v(dout1_3) FROM=229.9n TO=230.1n

.meas tran Vdout1_4ck16 AVG v(dout1_4) FROM=229.9n TO=230.1n

.meas tran Vdout1_5ck16 AVG v(dout1_5) FROM=229.9n TO=230.1n

.meas tran Vdout1_6ck16 AVG v(dout1_6) FROM=229.9n TO=230.1n

.meas tran Vdout1_7ck16 AVG v(dout1_7) FROM=229.9n TO=230.1n

.meas tran Vdout1_8ck16 AVG v(dout1_8) FROM=229.9n TO=230.1n

.meas tran Vdout1_9ck16 AVG v(dout1_9) FROM=229.9n TO=230.1n

.meas tran Vdout1_10ck16 AVG v(dout1_10) FROM=229.9n TO=230.1n

.meas tran Vdout1_11ck16 AVG v(dout1_11) FROM=229.9n TO=230.1n

.meas tran Vdout1_12ck16 AVG v(dout1_12) FROM=229.9n TO=230.1n

.meas tran Vdout1_13ck16 AVG v(dout1_13) FROM=229.9n TO=230.1n

.meas tran Vdout1_14ck16 AVG v(dout1_14) FROM=229.9n TO=230.1n

.meas tran Vdout1_15ck16 AVG v(dout1_15) FROM=229.9n TO=230.1n

.meas tran Vdout1_16ck16 AVG v(dout1_16) FROM=229.9n TO=230.1n

.meas tran Vdout1_17ck16 AVG v(dout1_17) FROM=229.9n TO=230.1n

.meas tran Vdout1_18ck16 AVG v(dout1_18) FROM=229.9n TO=230.1n

.meas tran Vdout1_19ck16 AVG v(dout1_19) FROM=229.9n TO=230.1n

.meas tran Vdout1_20ck16 AVG v(dout1_20) FROM=229.9n TO=230.1n

.meas tran Vdout1_21ck16 AVG v(dout1_21) FROM=229.9n TO=230.1n

.meas tran Vdout1_22ck16 AVG v(dout1_22) FROM=229.9n TO=230.1n

.meas tran Vdout1_23ck16 AVG v(dout1_23) FROM=229.9n TO=230.1n

.meas tran Vdout1_24ck16 AVG v(dout1_24) FROM=229.9n TO=230.1n

.meas tran Vdout1_25ck16 AVG v(dout1_25) FROM=229.9n TO=230.1n

.meas tran Vdout1_26ck16 AVG v(dout1_26) FROM=229.9n TO=230.1n

.meas tran Vdout1_27ck16 AVG v(dout1_27) FROM=229.9n TO=230.1n

.meas tran Vdout1_28ck16 AVG v(dout1_28) FROM=229.9n TO=230.1n

.meas tran Vdout1_29ck16 AVG v(dout1_29) FROM=229.9n TO=230.1n

.meas tran Vdout1_30ck16 AVG v(dout1_30) FROM=229.9n TO=230.1n

.meas tran Vdout1_31ck16 AVG v(dout1_31) FROM=229.9n TO=230.1n

.meas tran Vdout1_32ck16 AVG v(dout1_32) FROM=229.9n TO=230.1n

.meas tran Vdout1_33ck16 AVG v(dout1_33) FROM=229.9n TO=230.1n

.meas tran Vdout1_34ck16 AVG v(dout1_34) FROM=229.9n TO=230.1n

.meas tran Vdout1_35ck16 AVG v(dout1_35) FROM=229.9n TO=230.1n

.meas tran Vdout1_36ck16 AVG v(dout1_36) FROM=229.9n TO=230.1n

.meas tran Vdout1_37ck16 AVG v(dout1_37) FROM=229.9n TO=230.1n

.meas tran Vdout1_38ck16 AVG v(dout1_38) FROM=229.9n TO=230.1n

.meas tran Vdout1_39ck16 AVG v(dout1_39) FROM=229.9n TO=230.1n

.meas tran Vdout1_40ck16 AVG v(dout1_40) FROM=229.9n TO=230.1n

.meas tran Vdout1_41ck16 AVG v(dout1_41) FROM=229.9n TO=230.1n

.meas tran Vdout1_42ck16 AVG v(dout1_42) FROM=229.9n TO=230.1n

.meas tran Vdout1_43ck16 AVG v(dout1_43) FROM=229.9n TO=230.1n

.meas tran Vdout1_44ck16 AVG v(dout1_44) FROM=229.9n TO=230.1n

.meas tran Vdout1_45ck16 AVG v(dout1_45) FROM=229.9n TO=230.1n

.meas tran Vdout1_46ck16 AVG v(dout1_46) FROM=229.9n TO=230.1n

.meas tran Vdout1_47ck16 AVG v(dout1_47) FROM=229.9n TO=230.1n

.meas tran Vdout1_48ck16 AVG v(dout1_48) FROM=229.9n TO=230.1n

.meas tran Vdout1_49ck16 AVG v(dout1_49) FROM=229.9n TO=230.1n

.meas tran Vdout1_50ck16 AVG v(dout1_50) FROM=229.9n TO=230.1n

.meas tran Vdout1_51ck16 AVG v(dout1_51) FROM=229.9n TO=230.1n

.meas tran Vdout1_52ck16 AVG v(dout1_52) FROM=229.9n TO=230.1n

.meas tran Vdout1_53ck16 AVG v(dout1_53) FROM=229.9n TO=230.1n

.meas tran Vdout1_54ck16 AVG v(dout1_54) FROM=229.9n TO=230.1n

.meas tran Vdout1_55ck16 AVG v(dout1_55) FROM=229.9n TO=230.1n

.meas tran Vdout1_56ck16 AVG v(dout1_56) FROM=229.9n TO=230.1n

.meas tran Vdout1_57ck16 AVG v(dout1_57) FROM=229.9n TO=230.1n

.meas tran Vdout1_58ck16 AVG v(dout1_58) FROM=229.9n TO=230.1n

.meas tran Vdout1_59ck16 AVG v(dout1_59) FROM=229.9n TO=230.1n

.meas tran Vdout1_60ck16 AVG v(dout1_60) FROM=229.9n TO=230.1n

.meas tran Vdout1_61ck16 AVG v(dout1_61) FROM=229.9n TO=230.1n

.meas tran Vdout1_62ck16 AVG v(dout1_62) FROM=229.9n TO=230.1n

.meas tran Vdout1_63ck16 AVG v(dout1_63) FROM=229.9n TO=230.1n

.meas tran Vdout1_64ck16 AVG v(dout1_64) FROM=229.9n TO=230.1n

.meas tran Vdout1_65ck16 AVG v(dout1_65) FROM=229.9n TO=230.1n

.meas tran Vdout1_66ck16 AVG v(dout1_66) FROM=229.9n TO=230.1n

.meas tran Vdout1_67ck16 AVG v(dout1_67) FROM=229.9n TO=230.1n

.meas tran Vdout1_68ck16 AVG v(dout1_68) FROM=229.9n TO=230.1n

.meas tran Vdout1_69ck16 AVG v(dout1_69) FROM=229.9n TO=230.1n

.meas tran Vdout1_70ck16 AVG v(dout1_70) FROM=229.9n TO=230.1n

.meas tran Vdout1_71ck16 AVG v(dout1_71) FROM=229.9n TO=230.1n

.meas tran Vdout1_72ck16 AVG v(dout1_72) FROM=229.9n TO=230.1n

.meas tran Vdout1_73ck16 AVG v(dout1_73) FROM=229.9n TO=230.1n

.meas tran Vdout1_74ck16 AVG v(dout1_74) FROM=229.9n TO=230.1n

.meas tran Vdout1_75ck16 AVG v(dout1_75) FROM=229.9n TO=230.1n

.meas tran Vdout1_76ck16 AVG v(dout1_76) FROM=229.9n TO=230.1n

.meas tran Vdout1_77ck16 AVG v(dout1_77) FROM=229.9n TO=230.1n

.meas tran Vdout1_78ck16 AVG v(dout1_78) FROM=229.9n TO=230.1n

.meas tran Vdout1_79ck16 AVG v(dout1_79) FROM=229.9n TO=230.1n

.meas tran Vdout0_0ck17 AVG v(dout0_0) FROM=239.9n TO=240.1n

.meas tran Vdout0_1ck17 AVG v(dout0_1) FROM=239.9n TO=240.1n

.meas tran Vdout0_2ck17 AVG v(dout0_2) FROM=239.9n TO=240.1n

.meas tran Vdout0_3ck17 AVG v(dout0_3) FROM=239.9n TO=240.1n

.meas tran Vdout0_4ck17 AVG v(dout0_4) FROM=239.9n TO=240.1n

.meas tran Vdout0_5ck17 AVG v(dout0_5) FROM=239.9n TO=240.1n

.meas tran Vdout0_6ck17 AVG v(dout0_6) FROM=239.9n TO=240.1n

.meas tran Vdout0_7ck17 AVG v(dout0_7) FROM=239.9n TO=240.1n

.meas tran Vdout0_8ck17 AVG v(dout0_8) FROM=239.9n TO=240.1n

.meas tran Vdout0_9ck17 AVG v(dout0_9) FROM=239.9n TO=240.1n

.meas tran Vdout0_10ck17 AVG v(dout0_10) FROM=239.9n TO=240.1n

.meas tran Vdout0_11ck17 AVG v(dout0_11) FROM=239.9n TO=240.1n

.meas tran Vdout0_12ck17 AVG v(dout0_12) FROM=239.9n TO=240.1n

.meas tran Vdout0_13ck17 AVG v(dout0_13) FROM=239.9n TO=240.1n

.meas tran Vdout0_14ck17 AVG v(dout0_14) FROM=239.9n TO=240.1n

.meas tran Vdout0_15ck17 AVG v(dout0_15) FROM=239.9n TO=240.1n

.meas tran Vdout0_16ck17 AVG v(dout0_16) FROM=239.9n TO=240.1n

.meas tran Vdout0_17ck17 AVG v(dout0_17) FROM=239.9n TO=240.1n

.meas tran Vdout0_18ck17 AVG v(dout0_18) FROM=239.9n TO=240.1n

.meas tran Vdout0_19ck17 AVG v(dout0_19) FROM=239.9n TO=240.1n

.meas tran Vdout0_20ck17 AVG v(dout0_20) FROM=239.9n TO=240.1n

.meas tran Vdout0_21ck17 AVG v(dout0_21) FROM=239.9n TO=240.1n

.meas tran Vdout0_22ck17 AVG v(dout0_22) FROM=239.9n TO=240.1n

.meas tran Vdout0_23ck17 AVG v(dout0_23) FROM=239.9n TO=240.1n

.meas tran Vdout0_24ck17 AVG v(dout0_24) FROM=239.9n TO=240.1n

.meas tran Vdout0_25ck17 AVG v(dout0_25) FROM=239.9n TO=240.1n

.meas tran Vdout0_26ck17 AVG v(dout0_26) FROM=239.9n TO=240.1n

.meas tran Vdout0_27ck17 AVG v(dout0_27) FROM=239.9n TO=240.1n

.meas tran Vdout0_28ck17 AVG v(dout0_28) FROM=239.9n TO=240.1n

.meas tran Vdout0_29ck17 AVG v(dout0_29) FROM=239.9n TO=240.1n

.meas tran Vdout0_30ck17 AVG v(dout0_30) FROM=239.9n TO=240.1n

.meas tran Vdout0_31ck17 AVG v(dout0_31) FROM=239.9n TO=240.1n

.meas tran Vdout0_32ck17 AVG v(dout0_32) FROM=239.9n TO=240.1n

.meas tran Vdout0_33ck17 AVG v(dout0_33) FROM=239.9n TO=240.1n

.meas tran Vdout0_34ck17 AVG v(dout0_34) FROM=239.9n TO=240.1n

.meas tran Vdout0_35ck17 AVG v(dout0_35) FROM=239.9n TO=240.1n

.meas tran Vdout0_36ck17 AVG v(dout0_36) FROM=239.9n TO=240.1n

.meas tran Vdout0_37ck17 AVG v(dout0_37) FROM=239.9n TO=240.1n

.meas tran Vdout0_38ck17 AVG v(dout0_38) FROM=239.9n TO=240.1n

.meas tran Vdout0_39ck17 AVG v(dout0_39) FROM=239.9n TO=240.1n

.meas tran Vdout0_40ck17 AVG v(dout0_40) FROM=239.9n TO=240.1n

.meas tran Vdout0_41ck17 AVG v(dout0_41) FROM=239.9n TO=240.1n

.meas tran Vdout0_42ck17 AVG v(dout0_42) FROM=239.9n TO=240.1n

.meas tran Vdout0_43ck17 AVG v(dout0_43) FROM=239.9n TO=240.1n

.meas tran Vdout0_44ck17 AVG v(dout0_44) FROM=239.9n TO=240.1n

.meas tran Vdout0_45ck17 AVG v(dout0_45) FROM=239.9n TO=240.1n

.meas tran Vdout0_46ck17 AVG v(dout0_46) FROM=239.9n TO=240.1n

.meas tran Vdout0_47ck17 AVG v(dout0_47) FROM=239.9n TO=240.1n

.meas tran Vdout0_48ck17 AVG v(dout0_48) FROM=239.9n TO=240.1n

.meas tran Vdout0_49ck17 AVG v(dout0_49) FROM=239.9n TO=240.1n

.meas tran Vdout0_50ck17 AVG v(dout0_50) FROM=239.9n TO=240.1n

.meas tran Vdout0_51ck17 AVG v(dout0_51) FROM=239.9n TO=240.1n

.meas tran Vdout0_52ck17 AVG v(dout0_52) FROM=239.9n TO=240.1n

.meas tran Vdout0_53ck17 AVG v(dout0_53) FROM=239.9n TO=240.1n

.meas tran Vdout0_54ck17 AVG v(dout0_54) FROM=239.9n TO=240.1n

.meas tran Vdout0_55ck17 AVG v(dout0_55) FROM=239.9n TO=240.1n

.meas tran Vdout0_56ck17 AVG v(dout0_56) FROM=239.9n TO=240.1n

.meas tran Vdout0_57ck17 AVG v(dout0_57) FROM=239.9n TO=240.1n

.meas tran Vdout0_58ck17 AVG v(dout0_58) FROM=239.9n TO=240.1n

.meas tran Vdout0_59ck17 AVG v(dout0_59) FROM=239.9n TO=240.1n

.meas tran Vdout0_60ck17 AVG v(dout0_60) FROM=239.9n TO=240.1n

.meas tran Vdout0_61ck17 AVG v(dout0_61) FROM=239.9n TO=240.1n

.meas tran Vdout0_62ck17 AVG v(dout0_62) FROM=239.9n TO=240.1n

.meas tran Vdout0_63ck17 AVG v(dout0_63) FROM=239.9n TO=240.1n

.meas tran Vdout0_64ck17 AVG v(dout0_64) FROM=239.9n TO=240.1n

.meas tran Vdout0_65ck17 AVG v(dout0_65) FROM=239.9n TO=240.1n

.meas tran Vdout0_66ck17 AVG v(dout0_66) FROM=239.9n TO=240.1n

.meas tran Vdout0_67ck17 AVG v(dout0_67) FROM=239.9n TO=240.1n

.meas tran Vdout0_68ck17 AVG v(dout0_68) FROM=239.9n TO=240.1n

.meas tran Vdout0_69ck17 AVG v(dout0_69) FROM=239.9n TO=240.1n

.meas tran Vdout0_70ck17 AVG v(dout0_70) FROM=239.9n TO=240.1n

.meas tran Vdout0_71ck17 AVG v(dout0_71) FROM=239.9n TO=240.1n

.meas tran Vdout0_72ck17 AVG v(dout0_72) FROM=239.9n TO=240.1n

.meas tran Vdout0_73ck17 AVG v(dout0_73) FROM=239.9n TO=240.1n

.meas tran Vdout0_74ck17 AVG v(dout0_74) FROM=239.9n TO=240.1n

.meas tran Vdout0_75ck17 AVG v(dout0_75) FROM=239.9n TO=240.1n

.meas tran Vdout0_76ck17 AVG v(dout0_76) FROM=239.9n TO=240.1n

.meas tran Vdout0_77ck17 AVG v(dout0_77) FROM=239.9n TO=240.1n

.meas tran Vdout0_78ck17 AVG v(dout0_78) FROM=239.9n TO=240.1n

.meas tran Vdout0_79ck17 AVG v(dout0_79) FROM=239.9n TO=240.1n

.meas tran Vdout0_0ck18 AVG v(dout0_0) FROM=299.9n TO=300.1n

.meas tran Vdout0_1ck18 AVG v(dout0_1) FROM=299.9n TO=300.1n

.meas tran Vdout0_2ck18 AVG v(dout0_2) FROM=299.9n TO=300.1n

.meas tran Vdout0_3ck18 AVG v(dout0_3) FROM=299.9n TO=300.1n

.meas tran Vdout0_4ck18 AVG v(dout0_4) FROM=299.9n TO=300.1n

.meas tran Vdout0_5ck18 AVG v(dout0_5) FROM=299.9n TO=300.1n

.meas tran Vdout0_6ck18 AVG v(dout0_6) FROM=299.9n TO=300.1n

.meas tran Vdout0_7ck18 AVG v(dout0_7) FROM=299.9n TO=300.1n

.meas tran Vdout0_8ck18 AVG v(dout0_8) FROM=299.9n TO=300.1n

.meas tran Vdout0_9ck18 AVG v(dout0_9) FROM=299.9n TO=300.1n

.meas tran Vdout0_10ck18 AVG v(dout0_10) FROM=299.9n TO=300.1n

.meas tran Vdout0_11ck18 AVG v(dout0_11) FROM=299.9n TO=300.1n

.meas tran Vdout0_12ck18 AVG v(dout0_12) FROM=299.9n TO=300.1n

.meas tran Vdout0_13ck18 AVG v(dout0_13) FROM=299.9n TO=300.1n

.meas tran Vdout0_14ck18 AVG v(dout0_14) FROM=299.9n TO=300.1n

.meas tran Vdout0_15ck18 AVG v(dout0_15) FROM=299.9n TO=300.1n

.meas tran Vdout0_16ck18 AVG v(dout0_16) FROM=299.9n TO=300.1n

.meas tran Vdout0_17ck18 AVG v(dout0_17) FROM=299.9n TO=300.1n

.meas tran Vdout0_18ck18 AVG v(dout0_18) FROM=299.9n TO=300.1n

.meas tran Vdout0_19ck18 AVG v(dout0_19) FROM=299.9n TO=300.1n

.meas tran Vdout0_20ck18 AVG v(dout0_20) FROM=299.9n TO=300.1n

.meas tran Vdout0_21ck18 AVG v(dout0_21) FROM=299.9n TO=300.1n

.meas tran Vdout0_22ck18 AVG v(dout0_22) FROM=299.9n TO=300.1n

.meas tran Vdout0_23ck18 AVG v(dout0_23) FROM=299.9n TO=300.1n

.meas tran Vdout0_24ck18 AVG v(dout0_24) FROM=299.9n TO=300.1n

.meas tran Vdout0_25ck18 AVG v(dout0_25) FROM=299.9n TO=300.1n

.meas tran Vdout0_26ck18 AVG v(dout0_26) FROM=299.9n TO=300.1n

.meas tran Vdout0_27ck18 AVG v(dout0_27) FROM=299.9n TO=300.1n

.meas tran Vdout0_28ck18 AVG v(dout0_28) FROM=299.9n TO=300.1n

.meas tran Vdout0_29ck18 AVG v(dout0_29) FROM=299.9n TO=300.1n

.meas tran Vdout0_30ck18 AVG v(dout0_30) FROM=299.9n TO=300.1n

.meas tran Vdout0_31ck18 AVG v(dout0_31) FROM=299.9n TO=300.1n

.meas tran Vdout0_32ck18 AVG v(dout0_32) FROM=299.9n TO=300.1n

.meas tran Vdout0_33ck18 AVG v(dout0_33) FROM=299.9n TO=300.1n

.meas tran Vdout0_34ck18 AVG v(dout0_34) FROM=299.9n TO=300.1n

.meas tran Vdout0_35ck18 AVG v(dout0_35) FROM=299.9n TO=300.1n

.meas tran Vdout0_36ck18 AVG v(dout0_36) FROM=299.9n TO=300.1n

.meas tran Vdout0_37ck18 AVG v(dout0_37) FROM=299.9n TO=300.1n

.meas tran Vdout0_38ck18 AVG v(dout0_38) FROM=299.9n TO=300.1n

.meas tran Vdout0_39ck18 AVG v(dout0_39) FROM=299.9n TO=300.1n

.meas tran Vdout0_40ck18 AVG v(dout0_40) FROM=299.9n TO=300.1n

.meas tran Vdout0_41ck18 AVG v(dout0_41) FROM=299.9n TO=300.1n

.meas tran Vdout0_42ck18 AVG v(dout0_42) FROM=299.9n TO=300.1n

.meas tran Vdout0_43ck18 AVG v(dout0_43) FROM=299.9n TO=300.1n

.meas tran Vdout0_44ck18 AVG v(dout0_44) FROM=299.9n TO=300.1n

.meas tran Vdout0_45ck18 AVG v(dout0_45) FROM=299.9n TO=300.1n

.meas tran Vdout0_46ck18 AVG v(dout0_46) FROM=299.9n TO=300.1n

.meas tran Vdout0_47ck18 AVG v(dout0_47) FROM=299.9n TO=300.1n

.meas tran Vdout0_48ck18 AVG v(dout0_48) FROM=299.9n TO=300.1n

.meas tran Vdout0_49ck18 AVG v(dout0_49) FROM=299.9n TO=300.1n

.meas tran Vdout0_50ck18 AVG v(dout0_50) FROM=299.9n TO=300.1n

.meas tran Vdout0_51ck18 AVG v(dout0_51) FROM=299.9n TO=300.1n

.meas tran Vdout0_52ck18 AVG v(dout0_52) FROM=299.9n TO=300.1n

.meas tran Vdout0_53ck18 AVG v(dout0_53) FROM=299.9n TO=300.1n

.meas tran Vdout0_54ck18 AVG v(dout0_54) FROM=299.9n TO=300.1n

.meas tran Vdout0_55ck18 AVG v(dout0_55) FROM=299.9n TO=300.1n

.meas tran Vdout0_56ck18 AVG v(dout0_56) FROM=299.9n TO=300.1n

.meas tran Vdout0_57ck18 AVG v(dout0_57) FROM=299.9n TO=300.1n

.meas tran Vdout0_58ck18 AVG v(dout0_58) FROM=299.9n TO=300.1n

.meas tran Vdout0_59ck18 AVG v(dout0_59) FROM=299.9n TO=300.1n

.meas tran Vdout0_60ck18 AVG v(dout0_60) FROM=299.9n TO=300.1n

.meas tran Vdout0_61ck18 AVG v(dout0_61) FROM=299.9n TO=300.1n

.meas tran Vdout0_62ck18 AVG v(dout0_62) FROM=299.9n TO=300.1n

.meas tran Vdout0_63ck18 AVG v(dout0_63) FROM=299.9n TO=300.1n

.meas tran Vdout0_64ck18 AVG v(dout0_64) FROM=299.9n TO=300.1n

.meas tran Vdout0_65ck18 AVG v(dout0_65) FROM=299.9n TO=300.1n

.meas tran Vdout0_66ck18 AVG v(dout0_66) FROM=299.9n TO=300.1n

.meas tran Vdout0_67ck18 AVG v(dout0_67) FROM=299.9n TO=300.1n

.meas tran Vdout0_68ck18 AVG v(dout0_68) FROM=299.9n TO=300.1n

.meas tran Vdout0_69ck18 AVG v(dout0_69) FROM=299.9n TO=300.1n

.meas tran Vdout0_70ck18 AVG v(dout0_70) FROM=299.9n TO=300.1n

.meas tran Vdout0_71ck18 AVG v(dout0_71) FROM=299.9n TO=300.1n

.meas tran Vdout0_72ck18 AVG v(dout0_72) FROM=299.9n TO=300.1n

.meas tran Vdout0_73ck18 AVG v(dout0_73) FROM=299.9n TO=300.1n

.meas tran Vdout0_74ck18 AVG v(dout0_74) FROM=299.9n TO=300.1n

.meas tran Vdout0_75ck18 AVG v(dout0_75) FROM=299.9n TO=300.1n

.meas tran Vdout0_76ck18 AVG v(dout0_76) FROM=299.9n TO=300.1n

.meas tran Vdout0_77ck18 AVG v(dout0_77) FROM=299.9n TO=300.1n

.meas tran Vdout0_78ck18 AVG v(dout0_78) FROM=299.9n TO=300.1n

.meas tran Vdout0_79ck18 AVG v(dout0_79) FROM=299.9n TO=300.1n

.meas tran Vdout1_0ck19 AVG v(dout1_0) FROM=299.9n TO=300.1n

.meas tran Vdout1_1ck19 AVG v(dout1_1) FROM=299.9n TO=300.1n

.meas tran Vdout1_2ck19 AVG v(dout1_2) FROM=299.9n TO=300.1n

.meas tran Vdout1_3ck19 AVG v(dout1_3) FROM=299.9n TO=300.1n

.meas tran Vdout1_4ck19 AVG v(dout1_4) FROM=299.9n TO=300.1n

.meas tran Vdout1_5ck19 AVG v(dout1_5) FROM=299.9n TO=300.1n

.meas tran Vdout1_6ck19 AVG v(dout1_6) FROM=299.9n TO=300.1n

.meas tran Vdout1_7ck19 AVG v(dout1_7) FROM=299.9n TO=300.1n

.meas tran Vdout1_8ck19 AVG v(dout1_8) FROM=299.9n TO=300.1n

.meas tran Vdout1_9ck19 AVG v(dout1_9) FROM=299.9n TO=300.1n

.meas tran Vdout1_10ck19 AVG v(dout1_10) FROM=299.9n TO=300.1n

.meas tran Vdout1_11ck19 AVG v(dout1_11) FROM=299.9n TO=300.1n

.meas tran Vdout1_12ck19 AVG v(dout1_12) FROM=299.9n TO=300.1n

.meas tran Vdout1_13ck19 AVG v(dout1_13) FROM=299.9n TO=300.1n

.meas tran Vdout1_14ck19 AVG v(dout1_14) FROM=299.9n TO=300.1n

.meas tran Vdout1_15ck19 AVG v(dout1_15) FROM=299.9n TO=300.1n

.meas tran Vdout1_16ck19 AVG v(dout1_16) FROM=299.9n TO=300.1n

.meas tran Vdout1_17ck19 AVG v(dout1_17) FROM=299.9n TO=300.1n

.meas tran Vdout1_18ck19 AVG v(dout1_18) FROM=299.9n TO=300.1n

.meas tran Vdout1_19ck19 AVG v(dout1_19) FROM=299.9n TO=300.1n

.meas tran Vdout1_20ck19 AVG v(dout1_20) FROM=299.9n TO=300.1n

.meas tran Vdout1_21ck19 AVG v(dout1_21) FROM=299.9n TO=300.1n

.meas tran Vdout1_22ck19 AVG v(dout1_22) FROM=299.9n TO=300.1n

.meas tran Vdout1_23ck19 AVG v(dout1_23) FROM=299.9n TO=300.1n

.meas tran Vdout1_24ck19 AVG v(dout1_24) FROM=299.9n TO=300.1n

.meas tran Vdout1_25ck19 AVG v(dout1_25) FROM=299.9n TO=300.1n

.meas tran Vdout1_26ck19 AVG v(dout1_26) FROM=299.9n TO=300.1n

.meas tran Vdout1_27ck19 AVG v(dout1_27) FROM=299.9n TO=300.1n

.meas tran Vdout1_28ck19 AVG v(dout1_28) FROM=299.9n TO=300.1n

.meas tran Vdout1_29ck19 AVG v(dout1_29) FROM=299.9n TO=300.1n

.meas tran Vdout1_30ck19 AVG v(dout1_30) FROM=299.9n TO=300.1n

.meas tran Vdout1_31ck19 AVG v(dout1_31) FROM=299.9n TO=300.1n

.meas tran Vdout1_32ck19 AVG v(dout1_32) FROM=299.9n TO=300.1n

.meas tran Vdout1_33ck19 AVG v(dout1_33) FROM=299.9n TO=300.1n

.meas tran Vdout1_34ck19 AVG v(dout1_34) FROM=299.9n TO=300.1n

.meas tran Vdout1_35ck19 AVG v(dout1_35) FROM=299.9n TO=300.1n

.meas tran Vdout1_36ck19 AVG v(dout1_36) FROM=299.9n TO=300.1n

.meas tran Vdout1_37ck19 AVG v(dout1_37) FROM=299.9n TO=300.1n

.meas tran Vdout1_38ck19 AVG v(dout1_38) FROM=299.9n TO=300.1n

.meas tran Vdout1_39ck19 AVG v(dout1_39) FROM=299.9n TO=300.1n

.meas tran Vdout1_40ck19 AVG v(dout1_40) FROM=299.9n TO=300.1n

.meas tran Vdout1_41ck19 AVG v(dout1_41) FROM=299.9n TO=300.1n

.meas tran Vdout1_42ck19 AVG v(dout1_42) FROM=299.9n TO=300.1n

.meas tran Vdout1_43ck19 AVG v(dout1_43) FROM=299.9n TO=300.1n

.meas tran Vdout1_44ck19 AVG v(dout1_44) FROM=299.9n TO=300.1n

.meas tran Vdout1_45ck19 AVG v(dout1_45) FROM=299.9n TO=300.1n

.meas tran Vdout1_46ck19 AVG v(dout1_46) FROM=299.9n TO=300.1n

.meas tran Vdout1_47ck19 AVG v(dout1_47) FROM=299.9n TO=300.1n

.meas tran Vdout1_48ck19 AVG v(dout1_48) FROM=299.9n TO=300.1n

.meas tran Vdout1_49ck19 AVG v(dout1_49) FROM=299.9n TO=300.1n

.meas tran Vdout1_50ck19 AVG v(dout1_50) FROM=299.9n TO=300.1n

.meas tran Vdout1_51ck19 AVG v(dout1_51) FROM=299.9n TO=300.1n

.meas tran Vdout1_52ck19 AVG v(dout1_52) FROM=299.9n TO=300.1n

.meas tran Vdout1_53ck19 AVG v(dout1_53) FROM=299.9n TO=300.1n

.meas tran Vdout1_54ck19 AVG v(dout1_54) FROM=299.9n TO=300.1n

.meas tran Vdout1_55ck19 AVG v(dout1_55) FROM=299.9n TO=300.1n

.meas tran Vdout1_56ck19 AVG v(dout1_56) FROM=299.9n TO=300.1n

.meas tran Vdout1_57ck19 AVG v(dout1_57) FROM=299.9n TO=300.1n

.meas tran Vdout1_58ck19 AVG v(dout1_58) FROM=299.9n TO=300.1n

.meas tran Vdout1_59ck19 AVG v(dout1_59) FROM=299.9n TO=300.1n

.meas tran Vdout1_60ck19 AVG v(dout1_60) FROM=299.9n TO=300.1n

.meas tran Vdout1_61ck19 AVG v(dout1_61) FROM=299.9n TO=300.1n

.meas tran Vdout1_62ck19 AVG v(dout1_62) FROM=299.9n TO=300.1n

.meas tran Vdout1_63ck19 AVG v(dout1_63) FROM=299.9n TO=300.1n

.meas tran Vdout1_64ck19 AVG v(dout1_64) FROM=299.9n TO=300.1n

.meas tran Vdout1_65ck19 AVG v(dout1_65) FROM=299.9n TO=300.1n

.meas tran Vdout1_66ck19 AVG v(dout1_66) FROM=299.9n TO=300.1n

.meas tran Vdout1_67ck19 AVG v(dout1_67) FROM=299.9n TO=300.1n

.meas tran Vdout1_68ck19 AVG v(dout1_68) FROM=299.9n TO=300.1n

.meas tran Vdout1_69ck19 AVG v(dout1_69) FROM=299.9n TO=300.1n

.meas tran Vdout1_70ck19 AVG v(dout1_70) FROM=299.9n TO=300.1n

.meas tran Vdout1_71ck19 AVG v(dout1_71) FROM=299.9n TO=300.1n

.meas tran Vdout1_72ck19 AVG v(dout1_72) FROM=299.9n TO=300.1n

.meas tran Vdout1_73ck19 AVG v(dout1_73) FROM=299.9n TO=300.1n

.meas tran Vdout1_74ck19 AVG v(dout1_74) FROM=299.9n TO=300.1n

.meas tran Vdout1_75ck19 AVG v(dout1_75) FROM=299.9n TO=300.1n

.meas tran Vdout1_76ck19 AVG v(dout1_76) FROM=299.9n TO=300.1n

.meas tran Vdout1_77ck19 AVG v(dout1_77) FROM=299.9n TO=300.1n

.meas tran Vdout1_78ck19 AVG v(dout1_78) FROM=299.9n TO=300.1n

.meas tran Vdout1_79ck19 AVG v(dout1_79) FROM=299.9n TO=300.1n

.meas tran Vdout0_0ck20 AVG v(dout0_0) FROM=309.9n TO=310.1n

.meas tran Vdout0_1ck20 AVG v(dout0_1) FROM=309.9n TO=310.1n

.meas tran Vdout0_2ck20 AVG v(dout0_2) FROM=309.9n TO=310.1n

.meas tran Vdout0_3ck20 AVG v(dout0_3) FROM=309.9n TO=310.1n

.meas tran Vdout0_4ck20 AVG v(dout0_4) FROM=309.9n TO=310.1n

.meas tran Vdout0_5ck20 AVG v(dout0_5) FROM=309.9n TO=310.1n

.meas tran Vdout0_6ck20 AVG v(dout0_6) FROM=309.9n TO=310.1n

.meas tran Vdout0_7ck20 AVG v(dout0_7) FROM=309.9n TO=310.1n

.meas tran Vdout0_8ck20 AVG v(dout0_8) FROM=309.9n TO=310.1n

.meas tran Vdout0_9ck20 AVG v(dout0_9) FROM=309.9n TO=310.1n

.meas tran Vdout0_10ck20 AVG v(dout0_10) FROM=309.9n TO=310.1n

.meas tran Vdout0_11ck20 AVG v(dout0_11) FROM=309.9n TO=310.1n

.meas tran Vdout0_12ck20 AVG v(dout0_12) FROM=309.9n TO=310.1n

.meas tran Vdout0_13ck20 AVG v(dout0_13) FROM=309.9n TO=310.1n

.meas tran Vdout0_14ck20 AVG v(dout0_14) FROM=309.9n TO=310.1n

.meas tran Vdout0_15ck20 AVG v(dout0_15) FROM=309.9n TO=310.1n

.meas tran Vdout0_16ck20 AVG v(dout0_16) FROM=309.9n TO=310.1n

.meas tran Vdout0_17ck20 AVG v(dout0_17) FROM=309.9n TO=310.1n

.meas tran Vdout0_18ck20 AVG v(dout0_18) FROM=309.9n TO=310.1n

.meas tran Vdout0_19ck20 AVG v(dout0_19) FROM=309.9n TO=310.1n

.meas tran Vdout0_20ck20 AVG v(dout0_20) FROM=309.9n TO=310.1n

.meas tran Vdout0_21ck20 AVG v(dout0_21) FROM=309.9n TO=310.1n

.meas tran Vdout0_22ck20 AVG v(dout0_22) FROM=309.9n TO=310.1n

.meas tran Vdout0_23ck20 AVG v(dout0_23) FROM=309.9n TO=310.1n

.meas tran Vdout0_24ck20 AVG v(dout0_24) FROM=309.9n TO=310.1n

.meas tran Vdout0_25ck20 AVG v(dout0_25) FROM=309.9n TO=310.1n

.meas tran Vdout0_26ck20 AVG v(dout0_26) FROM=309.9n TO=310.1n

.meas tran Vdout0_27ck20 AVG v(dout0_27) FROM=309.9n TO=310.1n

.meas tran Vdout0_28ck20 AVG v(dout0_28) FROM=309.9n TO=310.1n

.meas tran Vdout0_29ck20 AVG v(dout0_29) FROM=309.9n TO=310.1n

.meas tran Vdout0_30ck20 AVG v(dout0_30) FROM=309.9n TO=310.1n

.meas tran Vdout0_31ck20 AVG v(dout0_31) FROM=309.9n TO=310.1n

.meas tran Vdout0_32ck20 AVG v(dout0_32) FROM=309.9n TO=310.1n

.meas tran Vdout0_33ck20 AVG v(dout0_33) FROM=309.9n TO=310.1n

.meas tran Vdout0_34ck20 AVG v(dout0_34) FROM=309.9n TO=310.1n

.meas tran Vdout0_35ck20 AVG v(dout0_35) FROM=309.9n TO=310.1n

.meas tran Vdout0_36ck20 AVG v(dout0_36) FROM=309.9n TO=310.1n

.meas tran Vdout0_37ck20 AVG v(dout0_37) FROM=309.9n TO=310.1n

.meas tran Vdout0_38ck20 AVG v(dout0_38) FROM=309.9n TO=310.1n

.meas tran Vdout0_39ck20 AVG v(dout0_39) FROM=309.9n TO=310.1n

.meas tran Vdout0_40ck20 AVG v(dout0_40) FROM=309.9n TO=310.1n

.meas tran Vdout0_41ck20 AVG v(dout0_41) FROM=309.9n TO=310.1n

.meas tran Vdout0_42ck20 AVG v(dout0_42) FROM=309.9n TO=310.1n

.meas tran Vdout0_43ck20 AVG v(dout0_43) FROM=309.9n TO=310.1n

.meas tran Vdout0_44ck20 AVG v(dout0_44) FROM=309.9n TO=310.1n

.meas tran Vdout0_45ck20 AVG v(dout0_45) FROM=309.9n TO=310.1n

.meas tran Vdout0_46ck20 AVG v(dout0_46) FROM=309.9n TO=310.1n

.meas tran Vdout0_47ck20 AVG v(dout0_47) FROM=309.9n TO=310.1n

.meas tran Vdout0_48ck20 AVG v(dout0_48) FROM=309.9n TO=310.1n

.meas tran Vdout0_49ck20 AVG v(dout0_49) FROM=309.9n TO=310.1n

.meas tran Vdout0_50ck20 AVG v(dout0_50) FROM=309.9n TO=310.1n

.meas tran Vdout0_51ck20 AVG v(dout0_51) FROM=309.9n TO=310.1n

.meas tran Vdout0_52ck20 AVG v(dout0_52) FROM=309.9n TO=310.1n

.meas tran Vdout0_53ck20 AVG v(dout0_53) FROM=309.9n TO=310.1n

.meas tran Vdout0_54ck20 AVG v(dout0_54) FROM=309.9n TO=310.1n

.meas tran Vdout0_55ck20 AVG v(dout0_55) FROM=309.9n TO=310.1n

.meas tran Vdout0_56ck20 AVG v(dout0_56) FROM=309.9n TO=310.1n

.meas tran Vdout0_57ck20 AVG v(dout0_57) FROM=309.9n TO=310.1n

.meas tran Vdout0_58ck20 AVG v(dout0_58) FROM=309.9n TO=310.1n

.meas tran Vdout0_59ck20 AVG v(dout0_59) FROM=309.9n TO=310.1n

.meas tran Vdout0_60ck20 AVG v(dout0_60) FROM=309.9n TO=310.1n

.meas tran Vdout0_61ck20 AVG v(dout0_61) FROM=309.9n TO=310.1n

.meas tran Vdout0_62ck20 AVG v(dout0_62) FROM=309.9n TO=310.1n

.meas tran Vdout0_63ck20 AVG v(dout0_63) FROM=309.9n TO=310.1n

.meas tran Vdout0_64ck20 AVG v(dout0_64) FROM=309.9n TO=310.1n

.meas tran Vdout0_65ck20 AVG v(dout0_65) FROM=309.9n TO=310.1n

.meas tran Vdout0_66ck20 AVG v(dout0_66) FROM=309.9n TO=310.1n

.meas tran Vdout0_67ck20 AVG v(dout0_67) FROM=309.9n TO=310.1n

.meas tran Vdout0_68ck20 AVG v(dout0_68) FROM=309.9n TO=310.1n

.meas tran Vdout0_69ck20 AVG v(dout0_69) FROM=309.9n TO=310.1n

.meas tran Vdout0_70ck20 AVG v(dout0_70) FROM=309.9n TO=310.1n

.meas tran Vdout0_71ck20 AVG v(dout0_71) FROM=309.9n TO=310.1n

.meas tran Vdout0_72ck20 AVG v(dout0_72) FROM=309.9n TO=310.1n

.meas tran Vdout0_73ck20 AVG v(dout0_73) FROM=309.9n TO=310.1n

.meas tran Vdout0_74ck20 AVG v(dout0_74) FROM=309.9n TO=310.1n

.meas tran Vdout0_75ck20 AVG v(dout0_75) FROM=309.9n TO=310.1n

.meas tran Vdout0_76ck20 AVG v(dout0_76) FROM=309.9n TO=310.1n

.meas tran Vdout0_77ck20 AVG v(dout0_77) FROM=309.9n TO=310.1n

.meas tran Vdout0_78ck20 AVG v(dout0_78) FROM=309.9n TO=310.1n

.meas tran Vdout0_79ck20 AVG v(dout0_79) FROM=309.9n TO=310.1n

.meas tran Vdout1_0ck21 AVG v(dout1_0) FROM=329.9n TO=330.1n

.meas tran Vdout1_1ck21 AVG v(dout1_1) FROM=329.9n TO=330.1n

.meas tran Vdout1_2ck21 AVG v(dout1_2) FROM=329.9n TO=330.1n

.meas tran Vdout1_3ck21 AVG v(dout1_3) FROM=329.9n TO=330.1n

.meas tran Vdout1_4ck21 AVG v(dout1_4) FROM=329.9n TO=330.1n

.meas tran Vdout1_5ck21 AVG v(dout1_5) FROM=329.9n TO=330.1n

.meas tran Vdout1_6ck21 AVG v(dout1_6) FROM=329.9n TO=330.1n

.meas tran Vdout1_7ck21 AVG v(dout1_7) FROM=329.9n TO=330.1n

.meas tran Vdout1_8ck21 AVG v(dout1_8) FROM=329.9n TO=330.1n

.meas tran Vdout1_9ck21 AVG v(dout1_9) FROM=329.9n TO=330.1n

.meas tran Vdout1_10ck21 AVG v(dout1_10) FROM=329.9n TO=330.1n

.meas tran Vdout1_11ck21 AVG v(dout1_11) FROM=329.9n TO=330.1n

.meas tran Vdout1_12ck21 AVG v(dout1_12) FROM=329.9n TO=330.1n

.meas tran Vdout1_13ck21 AVG v(dout1_13) FROM=329.9n TO=330.1n

.meas tran Vdout1_14ck21 AVG v(dout1_14) FROM=329.9n TO=330.1n

.meas tran Vdout1_15ck21 AVG v(dout1_15) FROM=329.9n TO=330.1n

.meas tran Vdout1_16ck21 AVG v(dout1_16) FROM=329.9n TO=330.1n

.meas tran Vdout1_17ck21 AVG v(dout1_17) FROM=329.9n TO=330.1n

.meas tran Vdout1_18ck21 AVG v(dout1_18) FROM=329.9n TO=330.1n

.meas tran Vdout1_19ck21 AVG v(dout1_19) FROM=329.9n TO=330.1n

.meas tran Vdout1_20ck21 AVG v(dout1_20) FROM=329.9n TO=330.1n

.meas tran Vdout1_21ck21 AVG v(dout1_21) FROM=329.9n TO=330.1n

.meas tran Vdout1_22ck21 AVG v(dout1_22) FROM=329.9n TO=330.1n

.meas tran Vdout1_23ck21 AVG v(dout1_23) FROM=329.9n TO=330.1n

.meas tran Vdout1_24ck21 AVG v(dout1_24) FROM=329.9n TO=330.1n

.meas tran Vdout1_25ck21 AVG v(dout1_25) FROM=329.9n TO=330.1n

.meas tran Vdout1_26ck21 AVG v(dout1_26) FROM=329.9n TO=330.1n

.meas tran Vdout1_27ck21 AVG v(dout1_27) FROM=329.9n TO=330.1n

.meas tran Vdout1_28ck21 AVG v(dout1_28) FROM=329.9n TO=330.1n

.meas tran Vdout1_29ck21 AVG v(dout1_29) FROM=329.9n TO=330.1n

.meas tran Vdout1_30ck21 AVG v(dout1_30) FROM=329.9n TO=330.1n

.meas tran Vdout1_31ck21 AVG v(dout1_31) FROM=329.9n TO=330.1n

.meas tran Vdout1_32ck21 AVG v(dout1_32) FROM=329.9n TO=330.1n

.meas tran Vdout1_33ck21 AVG v(dout1_33) FROM=329.9n TO=330.1n

.meas tran Vdout1_34ck21 AVG v(dout1_34) FROM=329.9n TO=330.1n

.meas tran Vdout1_35ck21 AVG v(dout1_35) FROM=329.9n TO=330.1n

.meas tran Vdout1_36ck21 AVG v(dout1_36) FROM=329.9n TO=330.1n

.meas tran Vdout1_37ck21 AVG v(dout1_37) FROM=329.9n TO=330.1n

.meas tran Vdout1_38ck21 AVG v(dout1_38) FROM=329.9n TO=330.1n

.meas tran Vdout1_39ck21 AVG v(dout1_39) FROM=329.9n TO=330.1n

.meas tran Vdout1_40ck21 AVG v(dout1_40) FROM=329.9n TO=330.1n

.meas tran Vdout1_41ck21 AVG v(dout1_41) FROM=329.9n TO=330.1n

.meas tran Vdout1_42ck21 AVG v(dout1_42) FROM=329.9n TO=330.1n

.meas tran Vdout1_43ck21 AVG v(dout1_43) FROM=329.9n TO=330.1n

.meas tran Vdout1_44ck21 AVG v(dout1_44) FROM=329.9n TO=330.1n

.meas tran Vdout1_45ck21 AVG v(dout1_45) FROM=329.9n TO=330.1n

.meas tran Vdout1_46ck21 AVG v(dout1_46) FROM=329.9n TO=330.1n

.meas tran Vdout1_47ck21 AVG v(dout1_47) FROM=329.9n TO=330.1n

.meas tran Vdout1_48ck21 AVG v(dout1_48) FROM=329.9n TO=330.1n

.meas tran Vdout1_49ck21 AVG v(dout1_49) FROM=329.9n TO=330.1n

.meas tran Vdout1_50ck21 AVG v(dout1_50) FROM=329.9n TO=330.1n

.meas tran Vdout1_51ck21 AVG v(dout1_51) FROM=329.9n TO=330.1n

.meas tran Vdout1_52ck21 AVG v(dout1_52) FROM=329.9n TO=330.1n

.meas tran Vdout1_53ck21 AVG v(dout1_53) FROM=329.9n TO=330.1n

.meas tran Vdout1_54ck21 AVG v(dout1_54) FROM=329.9n TO=330.1n

.meas tran Vdout1_55ck21 AVG v(dout1_55) FROM=329.9n TO=330.1n

.meas tran Vdout1_56ck21 AVG v(dout1_56) FROM=329.9n TO=330.1n

.meas tran Vdout1_57ck21 AVG v(dout1_57) FROM=329.9n TO=330.1n

.meas tran Vdout1_58ck21 AVG v(dout1_58) FROM=329.9n TO=330.1n

.meas tran Vdout1_59ck21 AVG v(dout1_59) FROM=329.9n TO=330.1n

.meas tran Vdout1_60ck21 AVG v(dout1_60) FROM=329.9n TO=330.1n

.meas tran Vdout1_61ck21 AVG v(dout1_61) FROM=329.9n TO=330.1n

.meas tran Vdout1_62ck21 AVG v(dout1_62) FROM=329.9n TO=330.1n

.meas tran Vdout1_63ck21 AVG v(dout1_63) FROM=329.9n TO=330.1n

.meas tran Vdout1_64ck21 AVG v(dout1_64) FROM=329.9n TO=330.1n

.meas tran Vdout1_65ck21 AVG v(dout1_65) FROM=329.9n TO=330.1n

.meas tran Vdout1_66ck21 AVG v(dout1_66) FROM=329.9n TO=330.1n

.meas tran Vdout1_67ck21 AVG v(dout1_67) FROM=329.9n TO=330.1n

.meas tran Vdout1_68ck21 AVG v(dout1_68) FROM=329.9n TO=330.1n

.meas tran Vdout1_69ck21 AVG v(dout1_69) FROM=329.9n TO=330.1n

.meas tran Vdout1_70ck21 AVG v(dout1_70) FROM=329.9n TO=330.1n

.meas tran Vdout1_71ck21 AVG v(dout1_71) FROM=329.9n TO=330.1n

.meas tran Vdout1_72ck21 AVG v(dout1_72) FROM=329.9n TO=330.1n

.meas tran Vdout1_73ck21 AVG v(dout1_73) FROM=329.9n TO=330.1n

.meas tran Vdout1_74ck21 AVG v(dout1_74) FROM=329.9n TO=330.1n

.meas tran Vdout1_75ck21 AVG v(dout1_75) FROM=329.9n TO=330.1n

.meas tran Vdout1_76ck21 AVG v(dout1_76) FROM=329.9n TO=330.1n

.meas tran Vdout1_77ck21 AVG v(dout1_77) FROM=329.9n TO=330.1n

.meas tran Vdout1_78ck21 AVG v(dout1_78) FROM=329.9n TO=330.1n

.meas tran Vdout1_79ck21 AVG v(dout1_79) FROM=329.9n TO=330.1n

.meas tran Vdout0_0ck22 AVG v(dout0_0) FROM=339.9n TO=340.1n

.meas tran Vdout0_1ck22 AVG v(dout0_1) FROM=339.9n TO=340.1n

.meas tran Vdout0_2ck22 AVG v(dout0_2) FROM=339.9n TO=340.1n

.meas tran Vdout0_3ck22 AVG v(dout0_3) FROM=339.9n TO=340.1n

.meas tran Vdout0_4ck22 AVG v(dout0_4) FROM=339.9n TO=340.1n

.meas tran Vdout0_5ck22 AVG v(dout0_5) FROM=339.9n TO=340.1n

.meas tran Vdout0_6ck22 AVG v(dout0_6) FROM=339.9n TO=340.1n

.meas tran Vdout0_7ck22 AVG v(dout0_7) FROM=339.9n TO=340.1n

.meas tran Vdout0_8ck22 AVG v(dout0_8) FROM=339.9n TO=340.1n

.meas tran Vdout0_9ck22 AVG v(dout0_9) FROM=339.9n TO=340.1n

.meas tran Vdout0_10ck22 AVG v(dout0_10) FROM=339.9n TO=340.1n

.meas tran Vdout0_11ck22 AVG v(dout0_11) FROM=339.9n TO=340.1n

.meas tran Vdout0_12ck22 AVG v(dout0_12) FROM=339.9n TO=340.1n

.meas tran Vdout0_13ck22 AVG v(dout0_13) FROM=339.9n TO=340.1n

.meas tran Vdout0_14ck22 AVG v(dout0_14) FROM=339.9n TO=340.1n

.meas tran Vdout0_15ck22 AVG v(dout0_15) FROM=339.9n TO=340.1n

.meas tran Vdout0_16ck22 AVG v(dout0_16) FROM=339.9n TO=340.1n

.meas tran Vdout0_17ck22 AVG v(dout0_17) FROM=339.9n TO=340.1n

.meas tran Vdout0_18ck22 AVG v(dout0_18) FROM=339.9n TO=340.1n

.meas tran Vdout0_19ck22 AVG v(dout0_19) FROM=339.9n TO=340.1n

.meas tran Vdout0_20ck22 AVG v(dout0_20) FROM=339.9n TO=340.1n

.meas tran Vdout0_21ck22 AVG v(dout0_21) FROM=339.9n TO=340.1n

.meas tran Vdout0_22ck22 AVG v(dout0_22) FROM=339.9n TO=340.1n

.meas tran Vdout0_23ck22 AVG v(dout0_23) FROM=339.9n TO=340.1n

.meas tran Vdout0_24ck22 AVG v(dout0_24) FROM=339.9n TO=340.1n

.meas tran Vdout0_25ck22 AVG v(dout0_25) FROM=339.9n TO=340.1n

.meas tran Vdout0_26ck22 AVG v(dout0_26) FROM=339.9n TO=340.1n

.meas tran Vdout0_27ck22 AVG v(dout0_27) FROM=339.9n TO=340.1n

.meas tran Vdout0_28ck22 AVG v(dout0_28) FROM=339.9n TO=340.1n

.meas tran Vdout0_29ck22 AVG v(dout0_29) FROM=339.9n TO=340.1n

.meas tran Vdout0_30ck22 AVG v(dout0_30) FROM=339.9n TO=340.1n

.meas tran Vdout0_31ck22 AVG v(dout0_31) FROM=339.9n TO=340.1n

.meas tran Vdout0_32ck22 AVG v(dout0_32) FROM=339.9n TO=340.1n

.meas tran Vdout0_33ck22 AVG v(dout0_33) FROM=339.9n TO=340.1n

.meas tran Vdout0_34ck22 AVG v(dout0_34) FROM=339.9n TO=340.1n

.meas tran Vdout0_35ck22 AVG v(dout0_35) FROM=339.9n TO=340.1n

.meas tran Vdout0_36ck22 AVG v(dout0_36) FROM=339.9n TO=340.1n

.meas tran Vdout0_37ck22 AVG v(dout0_37) FROM=339.9n TO=340.1n

.meas tran Vdout0_38ck22 AVG v(dout0_38) FROM=339.9n TO=340.1n

.meas tran Vdout0_39ck22 AVG v(dout0_39) FROM=339.9n TO=340.1n

.meas tran Vdout0_40ck22 AVG v(dout0_40) FROM=339.9n TO=340.1n

.meas tran Vdout0_41ck22 AVG v(dout0_41) FROM=339.9n TO=340.1n

.meas tran Vdout0_42ck22 AVG v(dout0_42) FROM=339.9n TO=340.1n

.meas tran Vdout0_43ck22 AVG v(dout0_43) FROM=339.9n TO=340.1n

.meas tran Vdout0_44ck22 AVG v(dout0_44) FROM=339.9n TO=340.1n

.meas tran Vdout0_45ck22 AVG v(dout0_45) FROM=339.9n TO=340.1n

.meas tran Vdout0_46ck22 AVG v(dout0_46) FROM=339.9n TO=340.1n

.meas tran Vdout0_47ck22 AVG v(dout0_47) FROM=339.9n TO=340.1n

.meas tran Vdout0_48ck22 AVG v(dout0_48) FROM=339.9n TO=340.1n

.meas tran Vdout0_49ck22 AVG v(dout0_49) FROM=339.9n TO=340.1n

.meas tran Vdout0_50ck22 AVG v(dout0_50) FROM=339.9n TO=340.1n

.meas tran Vdout0_51ck22 AVG v(dout0_51) FROM=339.9n TO=340.1n

.meas tran Vdout0_52ck22 AVG v(dout0_52) FROM=339.9n TO=340.1n

.meas tran Vdout0_53ck22 AVG v(dout0_53) FROM=339.9n TO=340.1n

.meas tran Vdout0_54ck22 AVG v(dout0_54) FROM=339.9n TO=340.1n

.meas tran Vdout0_55ck22 AVG v(dout0_55) FROM=339.9n TO=340.1n

.meas tran Vdout0_56ck22 AVG v(dout0_56) FROM=339.9n TO=340.1n

.meas tran Vdout0_57ck22 AVG v(dout0_57) FROM=339.9n TO=340.1n

.meas tran Vdout0_58ck22 AVG v(dout0_58) FROM=339.9n TO=340.1n

.meas tran Vdout0_59ck22 AVG v(dout0_59) FROM=339.9n TO=340.1n

.meas tran Vdout0_60ck22 AVG v(dout0_60) FROM=339.9n TO=340.1n

.meas tran Vdout0_61ck22 AVG v(dout0_61) FROM=339.9n TO=340.1n

.meas tran Vdout0_62ck22 AVG v(dout0_62) FROM=339.9n TO=340.1n

.meas tran Vdout0_63ck22 AVG v(dout0_63) FROM=339.9n TO=340.1n

.meas tran Vdout0_64ck22 AVG v(dout0_64) FROM=339.9n TO=340.1n

.meas tran Vdout0_65ck22 AVG v(dout0_65) FROM=339.9n TO=340.1n

.meas tran Vdout0_66ck22 AVG v(dout0_66) FROM=339.9n TO=340.1n

.meas tran Vdout0_67ck22 AVG v(dout0_67) FROM=339.9n TO=340.1n

.meas tran Vdout0_68ck22 AVG v(dout0_68) FROM=339.9n TO=340.1n

.meas tran Vdout0_69ck22 AVG v(dout0_69) FROM=339.9n TO=340.1n

.meas tran Vdout0_70ck22 AVG v(dout0_70) FROM=339.9n TO=340.1n

.meas tran Vdout0_71ck22 AVG v(dout0_71) FROM=339.9n TO=340.1n

.meas tran Vdout0_72ck22 AVG v(dout0_72) FROM=339.9n TO=340.1n

.meas tran Vdout0_73ck22 AVG v(dout0_73) FROM=339.9n TO=340.1n

.meas tran Vdout0_74ck22 AVG v(dout0_74) FROM=339.9n TO=340.1n

.meas tran Vdout0_75ck22 AVG v(dout0_75) FROM=339.9n TO=340.1n

.meas tran Vdout0_76ck22 AVG v(dout0_76) FROM=339.9n TO=340.1n

.meas tran Vdout0_77ck22 AVG v(dout0_77) FROM=339.9n TO=340.1n

.meas tran Vdout0_78ck22 AVG v(dout0_78) FROM=339.9n TO=340.1n

.meas tran Vdout0_79ck22 AVG v(dout0_79) FROM=339.9n TO=340.1n

.meas tran Vdout1_0ck23 AVG v(dout1_0) FROM=339.9n TO=340.1n

.meas tran Vdout1_1ck23 AVG v(dout1_1) FROM=339.9n TO=340.1n

.meas tran Vdout1_2ck23 AVG v(dout1_2) FROM=339.9n TO=340.1n

.meas tran Vdout1_3ck23 AVG v(dout1_3) FROM=339.9n TO=340.1n

.meas tran Vdout1_4ck23 AVG v(dout1_4) FROM=339.9n TO=340.1n

.meas tran Vdout1_5ck23 AVG v(dout1_5) FROM=339.9n TO=340.1n

.meas tran Vdout1_6ck23 AVG v(dout1_6) FROM=339.9n TO=340.1n

.meas tran Vdout1_7ck23 AVG v(dout1_7) FROM=339.9n TO=340.1n

.meas tran Vdout1_8ck23 AVG v(dout1_8) FROM=339.9n TO=340.1n

.meas tran Vdout1_9ck23 AVG v(dout1_9) FROM=339.9n TO=340.1n

.meas tran Vdout1_10ck23 AVG v(dout1_10) FROM=339.9n TO=340.1n

.meas tran Vdout1_11ck23 AVG v(dout1_11) FROM=339.9n TO=340.1n

.meas tran Vdout1_12ck23 AVG v(dout1_12) FROM=339.9n TO=340.1n

.meas tran Vdout1_13ck23 AVG v(dout1_13) FROM=339.9n TO=340.1n

.meas tran Vdout1_14ck23 AVG v(dout1_14) FROM=339.9n TO=340.1n

.meas tran Vdout1_15ck23 AVG v(dout1_15) FROM=339.9n TO=340.1n

.meas tran Vdout1_16ck23 AVG v(dout1_16) FROM=339.9n TO=340.1n

.meas tran Vdout1_17ck23 AVG v(dout1_17) FROM=339.9n TO=340.1n

.meas tran Vdout1_18ck23 AVG v(dout1_18) FROM=339.9n TO=340.1n

.meas tran Vdout1_19ck23 AVG v(dout1_19) FROM=339.9n TO=340.1n

.meas tran Vdout1_20ck23 AVG v(dout1_20) FROM=339.9n TO=340.1n

.meas tran Vdout1_21ck23 AVG v(dout1_21) FROM=339.9n TO=340.1n

.meas tran Vdout1_22ck23 AVG v(dout1_22) FROM=339.9n TO=340.1n

.meas tran Vdout1_23ck23 AVG v(dout1_23) FROM=339.9n TO=340.1n

.meas tran Vdout1_24ck23 AVG v(dout1_24) FROM=339.9n TO=340.1n

.meas tran Vdout1_25ck23 AVG v(dout1_25) FROM=339.9n TO=340.1n

.meas tran Vdout1_26ck23 AVG v(dout1_26) FROM=339.9n TO=340.1n

.meas tran Vdout1_27ck23 AVG v(dout1_27) FROM=339.9n TO=340.1n

.meas tran Vdout1_28ck23 AVG v(dout1_28) FROM=339.9n TO=340.1n

.meas tran Vdout1_29ck23 AVG v(dout1_29) FROM=339.9n TO=340.1n

.meas tran Vdout1_30ck23 AVG v(dout1_30) FROM=339.9n TO=340.1n

.meas tran Vdout1_31ck23 AVG v(dout1_31) FROM=339.9n TO=340.1n

.meas tran Vdout1_32ck23 AVG v(dout1_32) FROM=339.9n TO=340.1n

.meas tran Vdout1_33ck23 AVG v(dout1_33) FROM=339.9n TO=340.1n

.meas tran Vdout1_34ck23 AVG v(dout1_34) FROM=339.9n TO=340.1n

.meas tran Vdout1_35ck23 AVG v(dout1_35) FROM=339.9n TO=340.1n

.meas tran Vdout1_36ck23 AVG v(dout1_36) FROM=339.9n TO=340.1n

.meas tran Vdout1_37ck23 AVG v(dout1_37) FROM=339.9n TO=340.1n

.meas tran Vdout1_38ck23 AVG v(dout1_38) FROM=339.9n TO=340.1n

.meas tran Vdout1_39ck23 AVG v(dout1_39) FROM=339.9n TO=340.1n

.meas tran Vdout1_40ck23 AVG v(dout1_40) FROM=339.9n TO=340.1n

.meas tran Vdout1_41ck23 AVG v(dout1_41) FROM=339.9n TO=340.1n

.meas tran Vdout1_42ck23 AVG v(dout1_42) FROM=339.9n TO=340.1n

.meas tran Vdout1_43ck23 AVG v(dout1_43) FROM=339.9n TO=340.1n

.meas tran Vdout1_44ck23 AVG v(dout1_44) FROM=339.9n TO=340.1n

.meas tran Vdout1_45ck23 AVG v(dout1_45) FROM=339.9n TO=340.1n

.meas tran Vdout1_46ck23 AVG v(dout1_46) FROM=339.9n TO=340.1n

.meas tran Vdout1_47ck23 AVG v(dout1_47) FROM=339.9n TO=340.1n

.meas tran Vdout1_48ck23 AVG v(dout1_48) FROM=339.9n TO=340.1n

.meas tran Vdout1_49ck23 AVG v(dout1_49) FROM=339.9n TO=340.1n

.meas tran Vdout1_50ck23 AVG v(dout1_50) FROM=339.9n TO=340.1n

.meas tran Vdout1_51ck23 AVG v(dout1_51) FROM=339.9n TO=340.1n

.meas tran Vdout1_52ck23 AVG v(dout1_52) FROM=339.9n TO=340.1n

.meas tran Vdout1_53ck23 AVG v(dout1_53) FROM=339.9n TO=340.1n

.meas tran Vdout1_54ck23 AVG v(dout1_54) FROM=339.9n TO=340.1n

.meas tran Vdout1_55ck23 AVG v(dout1_55) FROM=339.9n TO=340.1n

.meas tran Vdout1_56ck23 AVG v(dout1_56) FROM=339.9n TO=340.1n

.meas tran Vdout1_57ck23 AVG v(dout1_57) FROM=339.9n TO=340.1n

.meas tran Vdout1_58ck23 AVG v(dout1_58) FROM=339.9n TO=340.1n

.meas tran Vdout1_59ck23 AVG v(dout1_59) FROM=339.9n TO=340.1n

.meas tran Vdout1_60ck23 AVG v(dout1_60) FROM=339.9n TO=340.1n

.meas tran Vdout1_61ck23 AVG v(dout1_61) FROM=339.9n TO=340.1n

.meas tran Vdout1_62ck23 AVG v(dout1_62) FROM=339.9n TO=340.1n

.meas tran Vdout1_63ck23 AVG v(dout1_63) FROM=339.9n TO=340.1n

.meas tran Vdout1_64ck23 AVG v(dout1_64) FROM=339.9n TO=340.1n

.meas tran Vdout1_65ck23 AVG v(dout1_65) FROM=339.9n TO=340.1n

.meas tran Vdout1_66ck23 AVG v(dout1_66) FROM=339.9n TO=340.1n

.meas tran Vdout1_67ck23 AVG v(dout1_67) FROM=339.9n TO=340.1n

.meas tran Vdout1_68ck23 AVG v(dout1_68) FROM=339.9n TO=340.1n

.meas tran Vdout1_69ck23 AVG v(dout1_69) FROM=339.9n TO=340.1n

.meas tran Vdout1_70ck23 AVG v(dout1_70) FROM=339.9n TO=340.1n

.meas tran Vdout1_71ck23 AVG v(dout1_71) FROM=339.9n TO=340.1n

.meas tran Vdout1_72ck23 AVG v(dout1_72) FROM=339.9n TO=340.1n

.meas tran Vdout1_73ck23 AVG v(dout1_73) FROM=339.9n TO=340.1n

.meas tran Vdout1_74ck23 AVG v(dout1_74) FROM=339.9n TO=340.1n

.meas tran Vdout1_75ck23 AVG v(dout1_75) FROM=339.9n TO=340.1n

.meas tran Vdout1_76ck23 AVG v(dout1_76) FROM=339.9n TO=340.1n

.meas tran Vdout1_77ck23 AVG v(dout1_77) FROM=339.9n TO=340.1n

.meas tran Vdout1_78ck23 AVG v(dout1_78) FROM=339.9n TO=340.1n

.meas tran Vdout1_79ck23 AVG v(dout1_79) FROM=339.9n TO=340.1n

.meas tran Vdout0_0ck24 AVG v(dout0_0) FROM=349.9n TO=350.1n

.meas tran Vdout0_1ck24 AVG v(dout0_1) FROM=349.9n TO=350.1n

.meas tran Vdout0_2ck24 AVG v(dout0_2) FROM=349.9n TO=350.1n

.meas tran Vdout0_3ck24 AVG v(dout0_3) FROM=349.9n TO=350.1n

.meas tran Vdout0_4ck24 AVG v(dout0_4) FROM=349.9n TO=350.1n

.meas tran Vdout0_5ck24 AVG v(dout0_5) FROM=349.9n TO=350.1n

.meas tran Vdout0_6ck24 AVG v(dout0_6) FROM=349.9n TO=350.1n

.meas tran Vdout0_7ck24 AVG v(dout0_7) FROM=349.9n TO=350.1n

.meas tran Vdout0_8ck24 AVG v(dout0_8) FROM=349.9n TO=350.1n

.meas tran Vdout0_9ck24 AVG v(dout0_9) FROM=349.9n TO=350.1n

.meas tran Vdout0_10ck24 AVG v(dout0_10) FROM=349.9n TO=350.1n

.meas tran Vdout0_11ck24 AVG v(dout0_11) FROM=349.9n TO=350.1n

.meas tran Vdout0_12ck24 AVG v(dout0_12) FROM=349.9n TO=350.1n

.meas tran Vdout0_13ck24 AVG v(dout0_13) FROM=349.9n TO=350.1n

.meas tran Vdout0_14ck24 AVG v(dout0_14) FROM=349.9n TO=350.1n

.meas tran Vdout0_15ck24 AVG v(dout0_15) FROM=349.9n TO=350.1n

.meas tran Vdout0_16ck24 AVG v(dout0_16) FROM=349.9n TO=350.1n

.meas tran Vdout0_17ck24 AVG v(dout0_17) FROM=349.9n TO=350.1n

.meas tran Vdout0_18ck24 AVG v(dout0_18) FROM=349.9n TO=350.1n

.meas tran Vdout0_19ck24 AVG v(dout0_19) FROM=349.9n TO=350.1n

.meas tran Vdout0_20ck24 AVG v(dout0_20) FROM=349.9n TO=350.1n

.meas tran Vdout0_21ck24 AVG v(dout0_21) FROM=349.9n TO=350.1n

.meas tran Vdout0_22ck24 AVG v(dout0_22) FROM=349.9n TO=350.1n

.meas tran Vdout0_23ck24 AVG v(dout0_23) FROM=349.9n TO=350.1n

.meas tran Vdout0_24ck24 AVG v(dout0_24) FROM=349.9n TO=350.1n

.meas tran Vdout0_25ck24 AVG v(dout0_25) FROM=349.9n TO=350.1n

.meas tran Vdout0_26ck24 AVG v(dout0_26) FROM=349.9n TO=350.1n

.meas tran Vdout0_27ck24 AVG v(dout0_27) FROM=349.9n TO=350.1n

.meas tran Vdout0_28ck24 AVG v(dout0_28) FROM=349.9n TO=350.1n

.meas tran Vdout0_29ck24 AVG v(dout0_29) FROM=349.9n TO=350.1n

.meas tran Vdout0_30ck24 AVG v(dout0_30) FROM=349.9n TO=350.1n

.meas tran Vdout0_31ck24 AVG v(dout0_31) FROM=349.9n TO=350.1n

.meas tran Vdout0_32ck24 AVG v(dout0_32) FROM=349.9n TO=350.1n

.meas tran Vdout0_33ck24 AVG v(dout0_33) FROM=349.9n TO=350.1n

.meas tran Vdout0_34ck24 AVG v(dout0_34) FROM=349.9n TO=350.1n

.meas tran Vdout0_35ck24 AVG v(dout0_35) FROM=349.9n TO=350.1n

.meas tran Vdout0_36ck24 AVG v(dout0_36) FROM=349.9n TO=350.1n

.meas tran Vdout0_37ck24 AVG v(dout0_37) FROM=349.9n TO=350.1n

.meas tran Vdout0_38ck24 AVG v(dout0_38) FROM=349.9n TO=350.1n

.meas tran Vdout0_39ck24 AVG v(dout0_39) FROM=349.9n TO=350.1n

.meas tran Vdout0_40ck24 AVG v(dout0_40) FROM=349.9n TO=350.1n

.meas tran Vdout0_41ck24 AVG v(dout0_41) FROM=349.9n TO=350.1n

.meas tran Vdout0_42ck24 AVG v(dout0_42) FROM=349.9n TO=350.1n

.meas tran Vdout0_43ck24 AVG v(dout0_43) FROM=349.9n TO=350.1n

.meas tran Vdout0_44ck24 AVG v(dout0_44) FROM=349.9n TO=350.1n

.meas tran Vdout0_45ck24 AVG v(dout0_45) FROM=349.9n TO=350.1n

.meas tran Vdout0_46ck24 AVG v(dout0_46) FROM=349.9n TO=350.1n

.meas tran Vdout0_47ck24 AVG v(dout0_47) FROM=349.9n TO=350.1n

.meas tran Vdout0_48ck24 AVG v(dout0_48) FROM=349.9n TO=350.1n

.meas tran Vdout0_49ck24 AVG v(dout0_49) FROM=349.9n TO=350.1n

.meas tran Vdout0_50ck24 AVG v(dout0_50) FROM=349.9n TO=350.1n

.meas tran Vdout0_51ck24 AVG v(dout0_51) FROM=349.9n TO=350.1n

.meas tran Vdout0_52ck24 AVG v(dout0_52) FROM=349.9n TO=350.1n

.meas tran Vdout0_53ck24 AVG v(dout0_53) FROM=349.9n TO=350.1n

.meas tran Vdout0_54ck24 AVG v(dout0_54) FROM=349.9n TO=350.1n

.meas tran Vdout0_55ck24 AVG v(dout0_55) FROM=349.9n TO=350.1n

.meas tran Vdout0_56ck24 AVG v(dout0_56) FROM=349.9n TO=350.1n

.meas tran Vdout0_57ck24 AVG v(dout0_57) FROM=349.9n TO=350.1n

.meas tran Vdout0_58ck24 AVG v(dout0_58) FROM=349.9n TO=350.1n

.meas tran Vdout0_59ck24 AVG v(dout0_59) FROM=349.9n TO=350.1n

.meas tran Vdout0_60ck24 AVG v(dout0_60) FROM=349.9n TO=350.1n

.meas tran Vdout0_61ck24 AVG v(dout0_61) FROM=349.9n TO=350.1n

.meas tran Vdout0_62ck24 AVG v(dout0_62) FROM=349.9n TO=350.1n

.meas tran Vdout0_63ck24 AVG v(dout0_63) FROM=349.9n TO=350.1n

.meas tran Vdout0_64ck24 AVG v(dout0_64) FROM=349.9n TO=350.1n

.meas tran Vdout0_65ck24 AVG v(dout0_65) FROM=349.9n TO=350.1n

.meas tran Vdout0_66ck24 AVG v(dout0_66) FROM=349.9n TO=350.1n

.meas tran Vdout0_67ck24 AVG v(dout0_67) FROM=349.9n TO=350.1n

.meas tran Vdout0_68ck24 AVG v(dout0_68) FROM=349.9n TO=350.1n

.meas tran Vdout0_69ck24 AVG v(dout0_69) FROM=349.9n TO=350.1n

.meas tran Vdout0_70ck24 AVG v(dout0_70) FROM=349.9n TO=350.1n

.meas tran Vdout0_71ck24 AVG v(dout0_71) FROM=349.9n TO=350.1n

.meas tran Vdout0_72ck24 AVG v(dout0_72) FROM=349.9n TO=350.1n

.meas tran Vdout0_73ck24 AVG v(dout0_73) FROM=349.9n TO=350.1n

.meas tran Vdout0_74ck24 AVG v(dout0_74) FROM=349.9n TO=350.1n

.meas tran Vdout0_75ck24 AVG v(dout0_75) FROM=349.9n TO=350.1n

.meas tran Vdout0_76ck24 AVG v(dout0_76) FROM=349.9n TO=350.1n

.meas tran Vdout0_77ck24 AVG v(dout0_77) FROM=349.9n TO=350.1n

.meas tran Vdout0_78ck24 AVG v(dout0_78) FROM=349.9n TO=350.1n

.meas tran Vdout0_79ck24 AVG v(dout0_79) FROM=349.9n TO=350.1n

.meas tran Vdout1_0ck25 AVG v(dout1_0) FROM=349.9n TO=350.1n

.meas tran Vdout1_1ck25 AVG v(dout1_1) FROM=349.9n TO=350.1n

.meas tran Vdout1_2ck25 AVG v(dout1_2) FROM=349.9n TO=350.1n

.meas tran Vdout1_3ck25 AVG v(dout1_3) FROM=349.9n TO=350.1n

.meas tran Vdout1_4ck25 AVG v(dout1_4) FROM=349.9n TO=350.1n

.meas tran Vdout1_5ck25 AVG v(dout1_5) FROM=349.9n TO=350.1n

.meas tran Vdout1_6ck25 AVG v(dout1_6) FROM=349.9n TO=350.1n

.meas tran Vdout1_7ck25 AVG v(dout1_7) FROM=349.9n TO=350.1n

.meas tran Vdout1_8ck25 AVG v(dout1_8) FROM=349.9n TO=350.1n

.meas tran Vdout1_9ck25 AVG v(dout1_9) FROM=349.9n TO=350.1n

.meas tran Vdout1_10ck25 AVG v(dout1_10) FROM=349.9n TO=350.1n

.meas tran Vdout1_11ck25 AVG v(dout1_11) FROM=349.9n TO=350.1n

.meas tran Vdout1_12ck25 AVG v(dout1_12) FROM=349.9n TO=350.1n

.meas tran Vdout1_13ck25 AVG v(dout1_13) FROM=349.9n TO=350.1n

.meas tran Vdout1_14ck25 AVG v(dout1_14) FROM=349.9n TO=350.1n

.meas tran Vdout1_15ck25 AVG v(dout1_15) FROM=349.9n TO=350.1n

.meas tran Vdout1_16ck25 AVG v(dout1_16) FROM=349.9n TO=350.1n

.meas tran Vdout1_17ck25 AVG v(dout1_17) FROM=349.9n TO=350.1n

.meas tran Vdout1_18ck25 AVG v(dout1_18) FROM=349.9n TO=350.1n

.meas tran Vdout1_19ck25 AVG v(dout1_19) FROM=349.9n TO=350.1n

.meas tran Vdout1_20ck25 AVG v(dout1_20) FROM=349.9n TO=350.1n

.meas tran Vdout1_21ck25 AVG v(dout1_21) FROM=349.9n TO=350.1n

.meas tran Vdout1_22ck25 AVG v(dout1_22) FROM=349.9n TO=350.1n

.meas tran Vdout1_23ck25 AVG v(dout1_23) FROM=349.9n TO=350.1n

.meas tran Vdout1_24ck25 AVG v(dout1_24) FROM=349.9n TO=350.1n

.meas tran Vdout1_25ck25 AVG v(dout1_25) FROM=349.9n TO=350.1n

.meas tran Vdout1_26ck25 AVG v(dout1_26) FROM=349.9n TO=350.1n

.meas tran Vdout1_27ck25 AVG v(dout1_27) FROM=349.9n TO=350.1n

.meas tran Vdout1_28ck25 AVG v(dout1_28) FROM=349.9n TO=350.1n

.meas tran Vdout1_29ck25 AVG v(dout1_29) FROM=349.9n TO=350.1n

.meas tran Vdout1_30ck25 AVG v(dout1_30) FROM=349.9n TO=350.1n

.meas tran Vdout1_31ck25 AVG v(dout1_31) FROM=349.9n TO=350.1n

.meas tran Vdout1_32ck25 AVG v(dout1_32) FROM=349.9n TO=350.1n

.meas tran Vdout1_33ck25 AVG v(dout1_33) FROM=349.9n TO=350.1n

.meas tran Vdout1_34ck25 AVG v(dout1_34) FROM=349.9n TO=350.1n

.meas tran Vdout1_35ck25 AVG v(dout1_35) FROM=349.9n TO=350.1n

.meas tran Vdout1_36ck25 AVG v(dout1_36) FROM=349.9n TO=350.1n

.meas tran Vdout1_37ck25 AVG v(dout1_37) FROM=349.9n TO=350.1n

.meas tran Vdout1_38ck25 AVG v(dout1_38) FROM=349.9n TO=350.1n

.meas tran Vdout1_39ck25 AVG v(dout1_39) FROM=349.9n TO=350.1n

.meas tran Vdout1_40ck25 AVG v(dout1_40) FROM=349.9n TO=350.1n

.meas tran Vdout1_41ck25 AVG v(dout1_41) FROM=349.9n TO=350.1n

.meas tran Vdout1_42ck25 AVG v(dout1_42) FROM=349.9n TO=350.1n

.meas tran Vdout1_43ck25 AVG v(dout1_43) FROM=349.9n TO=350.1n

.meas tran Vdout1_44ck25 AVG v(dout1_44) FROM=349.9n TO=350.1n

.meas tran Vdout1_45ck25 AVG v(dout1_45) FROM=349.9n TO=350.1n

.meas tran Vdout1_46ck25 AVG v(dout1_46) FROM=349.9n TO=350.1n

.meas tran Vdout1_47ck25 AVG v(dout1_47) FROM=349.9n TO=350.1n

.meas tran Vdout1_48ck25 AVG v(dout1_48) FROM=349.9n TO=350.1n

.meas tran Vdout1_49ck25 AVG v(dout1_49) FROM=349.9n TO=350.1n

.meas tran Vdout1_50ck25 AVG v(dout1_50) FROM=349.9n TO=350.1n

.meas tran Vdout1_51ck25 AVG v(dout1_51) FROM=349.9n TO=350.1n

.meas tran Vdout1_52ck25 AVG v(dout1_52) FROM=349.9n TO=350.1n

.meas tran Vdout1_53ck25 AVG v(dout1_53) FROM=349.9n TO=350.1n

.meas tran Vdout1_54ck25 AVG v(dout1_54) FROM=349.9n TO=350.1n

.meas tran Vdout1_55ck25 AVG v(dout1_55) FROM=349.9n TO=350.1n

.meas tran Vdout1_56ck25 AVG v(dout1_56) FROM=349.9n TO=350.1n

.meas tran Vdout1_57ck25 AVG v(dout1_57) FROM=349.9n TO=350.1n

.meas tran Vdout1_58ck25 AVG v(dout1_58) FROM=349.9n TO=350.1n

.meas tran Vdout1_59ck25 AVG v(dout1_59) FROM=349.9n TO=350.1n

.meas tran Vdout1_60ck25 AVG v(dout1_60) FROM=349.9n TO=350.1n

.meas tran Vdout1_61ck25 AVG v(dout1_61) FROM=349.9n TO=350.1n

.meas tran Vdout1_62ck25 AVG v(dout1_62) FROM=349.9n TO=350.1n

.meas tran Vdout1_63ck25 AVG v(dout1_63) FROM=349.9n TO=350.1n

.meas tran Vdout1_64ck25 AVG v(dout1_64) FROM=349.9n TO=350.1n

.meas tran Vdout1_65ck25 AVG v(dout1_65) FROM=349.9n TO=350.1n

.meas tran Vdout1_66ck25 AVG v(dout1_66) FROM=349.9n TO=350.1n

.meas tran Vdout1_67ck25 AVG v(dout1_67) FROM=349.9n TO=350.1n

.meas tran Vdout1_68ck25 AVG v(dout1_68) FROM=349.9n TO=350.1n

.meas tran Vdout1_69ck25 AVG v(dout1_69) FROM=349.9n TO=350.1n

.meas tran Vdout1_70ck25 AVG v(dout1_70) FROM=349.9n TO=350.1n

.meas tran Vdout1_71ck25 AVG v(dout1_71) FROM=349.9n TO=350.1n

.meas tran Vdout1_72ck25 AVG v(dout1_72) FROM=349.9n TO=350.1n

.meas tran Vdout1_73ck25 AVG v(dout1_73) FROM=349.9n TO=350.1n

.meas tran Vdout1_74ck25 AVG v(dout1_74) FROM=349.9n TO=350.1n

.meas tran Vdout1_75ck25 AVG v(dout1_75) FROM=349.9n TO=350.1n

.meas tran Vdout1_76ck25 AVG v(dout1_76) FROM=349.9n TO=350.1n

.meas tran Vdout1_77ck25 AVG v(dout1_77) FROM=349.9n TO=350.1n

.meas tran Vdout1_78ck25 AVG v(dout1_78) FROM=349.9n TO=350.1n

.meas tran Vdout1_79ck25 AVG v(dout1_79) FROM=349.9n TO=350.1n

.meas tran Vdout0_0ck26 AVG v(dout0_0) FROM=369.9n TO=370.1n

.meas tran Vdout0_1ck26 AVG v(dout0_1) FROM=369.9n TO=370.1n

.meas tran Vdout0_2ck26 AVG v(dout0_2) FROM=369.9n TO=370.1n

.meas tran Vdout0_3ck26 AVG v(dout0_3) FROM=369.9n TO=370.1n

.meas tran Vdout0_4ck26 AVG v(dout0_4) FROM=369.9n TO=370.1n

.meas tran Vdout0_5ck26 AVG v(dout0_5) FROM=369.9n TO=370.1n

.meas tran Vdout0_6ck26 AVG v(dout0_6) FROM=369.9n TO=370.1n

.meas tran Vdout0_7ck26 AVG v(dout0_7) FROM=369.9n TO=370.1n

.meas tran Vdout0_8ck26 AVG v(dout0_8) FROM=369.9n TO=370.1n

.meas tran Vdout0_9ck26 AVG v(dout0_9) FROM=369.9n TO=370.1n

.meas tran Vdout0_10ck26 AVG v(dout0_10) FROM=369.9n TO=370.1n

.meas tran Vdout0_11ck26 AVG v(dout0_11) FROM=369.9n TO=370.1n

.meas tran Vdout0_12ck26 AVG v(dout0_12) FROM=369.9n TO=370.1n

.meas tran Vdout0_13ck26 AVG v(dout0_13) FROM=369.9n TO=370.1n

.meas tran Vdout0_14ck26 AVG v(dout0_14) FROM=369.9n TO=370.1n

.meas tran Vdout0_15ck26 AVG v(dout0_15) FROM=369.9n TO=370.1n

.meas tran Vdout0_16ck26 AVG v(dout0_16) FROM=369.9n TO=370.1n

.meas tran Vdout0_17ck26 AVG v(dout0_17) FROM=369.9n TO=370.1n

.meas tran Vdout0_18ck26 AVG v(dout0_18) FROM=369.9n TO=370.1n

.meas tran Vdout0_19ck26 AVG v(dout0_19) FROM=369.9n TO=370.1n

.meas tran Vdout0_20ck26 AVG v(dout0_20) FROM=369.9n TO=370.1n

.meas tran Vdout0_21ck26 AVG v(dout0_21) FROM=369.9n TO=370.1n

.meas tran Vdout0_22ck26 AVG v(dout0_22) FROM=369.9n TO=370.1n

.meas tran Vdout0_23ck26 AVG v(dout0_23) FROM=369.9n TO=370.1n

.meas tran Vdout0_24ck26 AVG v(dout0_24) FROM=369.9n TO=370.1n

.meas tran Vdout0_25ck26 AVG v(dout0_25) FROM=369.9n TO=370.1n

.meas tran Vdout0_26ck26 AVG v(dout0_26) FROM=369.9n TO=370.1n

.meas tran Vdout0_27ck26 AVG v(dout0_27) FROM=369.9n TO=370.1n

.meas tran Vdout0_28ck26 AVG v(dout0_28) FROM=369.9n TO=370.1n

.meas tran Vdout0_29ck26 AVG v(dout0_29) FROM=369.9n TO=370.1n

.meas tran Vdout0_30ck26 AVG v(dout0_30) FROM=369.9n TO=370.1n

.meas tran Vdout0_31ck26 AVG v(dout0_31) FROM=369.9n TO=370.1n

.meas tran Vdout0_32ck26 AVG v(dout0_32) FROM=369.9n TO=370.1n

.meas tran Vdout0_33ck26 AVG v(dout0_33) FROM=369.9n TO=370.1n

.meas tran Vdout0_34ck26 AVG v(dout0_34) FROM=369.9n TO=370.1n

.meas tran Vdout0_35ck26 AVG v(dout0_35) FROM=369.9n TO=370.1n

.meas tran Vdout0_36ck26 AVG v(dout0_36) FROM=369.9n TO=370.1n

.meas tran Vdout0_37ck26 AVG v(dout0_37) FROM=369.9n TO=370.1n

.meas tran Vdout0_38ck26 AVG v(dout0_38) FROM=369.9n TO=370.1n

.meas tran Vdout0_39ck26 AVG v(dout0_39) FROM=369.9n TO=370.1n

.meas tran Vdout0_40ck26 AVG v(dout0_40) FROM=369.9n TO=370.1n

.meas tran Vdout0_41ck26 AVG v(dout0_41) FROM=369.9n TO=370.1n

.meas tran Vdout0_42ck26 AVG v(dout0_42) FROM=369.9n TO=370.1n

.meas tran Vdout0_43ck26 AVG v(dout0_43) FROM=369.9n TO=370.1n

.meas tran Vdout0_44ck26 AVG v(dout0_44) FROM=369.9n TO=370.1n

.meas tran Vdout0_45ck26 AVG v(dout0_45) FROM=369.9n TO=370.1n

.meas tran Vdout0_46ck26 AVG v(dout0_46) FROM=369.9n TO=370.1n

.meas tran Vdout0_47ck26 AVG v(dout0_47) FROM=369.9n TO=370.1n

.meas tran Vdout0_48ck26 AVG v(dout0_48) FROM=369.9n TO=370.1n

.meas tran Vdout0_49ck26 AVG v(dout0_49) FROM=369.9n TO=370.1n

.meas tran Vdout0_50ck26 AVG v(dout0_50) FROM=369.9n TO=370.1n

.meas tran Vdout0_51ck26 AVG v(dout0_51) FROM=369.9n TO=370.1n

.meas tran Vdout0_52ck26 AVG v(dout0_52) FROM=369.9n TO=370.1n

.meas tran Vdout0_53ck26 AVG v(dout0_53) FROM=369.9n TO=370.1n

.meas tran Vdout0_54ck26 AVG v(dout0_54) FROM=369.9n TO=370.1n

.meas tran Vdout0_55ck26 AVG v(dout0_55) FROM=369.9n TO=370.1n

.meas tran Vdout0_56ck26 AVG v(dout0_56) FROM=369.9n TO=370.1n

.meas tran Vdout0_57ck26 AVG v(dout0_57) FROM=369.9n TO=370.1n

.meas tran Vdout0_58ck26 AVG v(dout0_58) FROM=369.9n TO=370.1n

.meas tran Vdout0_59ck26 AVG v(dout0_59) FROM=369.9n TO=370.1n

.meas tran Vdout0_60ck26 AVG v(dout0_60) FROM=369.9n TO=370.1n

.meas tran Vdout0_61ck26 AVG v(dout0_61) FROM=369.9n TO=370.1n

.meas tran Vdout0_62ck26 AVG v(dout0_62) FROM=369.9n TO=370.1n

.meas tran Vdout0_63ck26 AVG v(dout0_63) FROM=369.9n TO=370.1n

.meas tran Vdout0_64ck26 AVG v(dout0_64) FROM=369.9n TO=370.1n

.meas tran Vdout0_65ck26 AVG v(dout0_65) FROM=369.9n TO=370.1n

.meas tran Vdout0_66ck26 AVG v(dout0_66) FROM=369.9n TO=370.1n

.meas tran Vdout0_67ck26 AVG v(dout0_67) FROM=369.9n TO=370.1n

.meas tran Vdout0_68ck26 AVG v(dout0_68) FROM=369.9n TO=370.1n

.meas tran Vdout0_69ck26 AVG v(dout0_69) FROM=369.9n TO=370.1n

.meas tran Vdout0_70ck26 AVG v(dout0_70) FROM=369.9n TO=370.1n

.meas tran Vdout0_71ck26 AVG v(dout0_71) FROM=369.9n TO=370.1n

.meas tran Vdout0_72ck26 AVG v(dout0_72) FROM=369.9n TO=370.1n

.meas tran Vdout0_73ck26 AVG v(dout0_73) FROM=369.9n TO=370.1n

.meas tran Vdout0_74ck26 AVG v(dout0_74) FROM=369.9n TO=370.1n

.meas tran Vdout0_75ck26 AVG v(dout0_75) FROM=369.9n TO=370.1n

.meas tran Vdout0_76ck26 AVG v(dout0_76) FROM=369.9n TO=370.1n

.meas tran Vdout0_77ck26 AVG v(dout0_77) FROM=369.9n TO=370.1n

.meas tran Vdout0_78ck26 AVG v(dout0_78) FROM=369.9n TO=370.1n

.meas tran Vdout0_79ck26 AVG v(dout0_79) FROM=369.9n TO=370.1n

.meas tran Vdout1_0ck27 AVG v(dout1_0) FROM=379.9n TO=380.1n

.meas tran Vdout1_1ck27 AVG v(dout1_1) FROM=379.9n TO=380.1n

.meas tran Vdout1_2ck27 AVG v(dout1_2) FROM=379.9n TO=380.1n

.meas tran Vdout1_3ck27 AVG v(dout1_3) FROM=379.9n TO=380.1n

.meas tran Vdout1_4ck27 AVG v(dout1_4) FROM=379.9n TO=380.1n

.meas tran Vdout1_5ck27 AVG v(dout1_5) FROM=379.9n TO=380.1n

.meas tran Vdout1_6ck27 AVG v(dout1_6) FROM=379.9n TO=380.1n

.meas tran Vdout1_7ck27 AVG v(dout1_7) FROM=379.9n TO=380.1n

.meas tran Vdout1_8ck27 AVG v(dout1_8) FROM=379.9n TO=380.1n

.meas tran Vdout1_9ck27 AVG v(dout1_9) FROM=379.9n TO=380.1n

.meas tran Vdout1_10ck27 AVG v(dout1_10) FROM=379.9n TO=380.1n

.meas tran Vdout1_11ck27 AVG v(dout1_11) FROM=379.9n TO=380.1n

.meas tran Vdout1_12ck27 AVG v(dout1_12) FROM=379.9n TO=380.1n

.meas tran Vdout1_13ck27 AVG v(dout1_13) FROM=379.9n TO=380.1n

.meas tran Vdout1_14ck27 AVG v(dout1_14) FROM=379.9n TO=380.1n

.meas tran Vdout1_15ck27 AVG v(dout1_15) FROM=379.9n TO=380.1n

.meas tran Vdout1_16ck27 AVG v(dout1_16) FROM=379.9n TO=380.1n

.meas tran Vdout1_17ck27 AVG v(dout1_17) FROM=379.9n TO=380.1n

.meas tran Vdout1_18ck27 AVG v(dout1_18) FROM=379.9n TO=380.1n

.meas tran Vdout1_19ck27 AVG v(dout1_19) FROM=379.9n TO=380.1n

.meas tran Vdout1_20ck27 AVG v(dout1_20) FROM=379.9n TO=380.1n

.meas tran Vdout1_21ck27 AVG v(dout1_21) FROM=379.9n TO=380.1n

.meas tran Vdout1_22ck27 AVG v(dout1_22) FROM=379.9n TO=380.1n

.meas tran Vdout1_23ck27 AVG v(dout1_23) FROM=379.9n TO=380.1n

.meas tran Vdout1_24ck27 AVG v(dout1_24) FROM=379.9n TO=380.1n

.meas tran Vdout1_25ck27 AVG v(dout1_25) FROM=379.9n TO=380.1n

.meas tran Vdout1_26ck27 AVG v(dout1_26) FROM=379.9n TO=380.1n

.meas tran Vdout1_27ck27 AVG v(dout1_27) FROM=379.9n TO=380.1n

.meas tran Vdout1_28ck27 AVG v(dout1_28) FROM=379.9n TO=380.1n

.meas tran Vdout1_29ck27 AVG v(dout1_29) FROM=379.9n TO=380.1n

.meas tran Vdout1_30ck27 AVG v(dout1_30) FROM=379.9n TO=380.1n

.meas tran Vdout1_31ck27 AVG v(dout1_31) FROM=379.9n TO=380.1n

.meas tran Vdout1_32ck27 AVG v(dout1_32) FROM=379.9n TO=380.1n

.meas tran Vdout1_33ck27 AVG v(dout1_33) FROM=379.9n TO=380.1n

.meas tran Vdout1_34ck27 AVG v(dout1_34) FROM=379.9n TO=380.1n

.meas tran Vdout1_35ck27 AVG v(dout1_35) FROM=379.9n TO=380.1n

.meas tran Vdout1_36ck27 AVG v(dout1_36) FROM=379.9n TO=380.1n

.meas tran Vdout1_37ck27 AVG v(dout1_37) FROM=379.9n TO=380.1n

.meas tran Vdout1_38ck27 AVG v(dout1_38) FROM=379.9n TO=380.1n

.meas tran Vdout1_39ck27 AVG v(dout1_39) FROM=379.9n TO=380.1n

.meas tran Vdout1_40ck27 AVG v(dout1_40) FROM=379.9n TO=380.1n

.meas tran Vdout1_41ck27 AVG v(dout1_41) FROM=379.9n TO=380.1n

.meas tran Vdout1_42ck27 AVG v(dout1_42) FROM=379.9n TO=380.1n

.meas tran Vdout1_43ck27 AVG v(dout1_43) FROM=379.9n TO=380.1n

.meas tran Vdout1_44ck27 AVG v(dout1_44) FROM=379.9n TO=380.1n

.meas tran Vdout1_45ck27 AVG v(dout1_45) FROM=379.9n TO=380.1n

.meas tran Vdout1_46ck27 AVG v(dout1_46) FROM=379.9n TO=380.1n

.meas tran Vdout1_47ck27 AVG v(dout1_47) FROM=379.9n TO=380.1n

.meas tran Vdout1_48ck27 AVG v(dout1_48) FROM=379.9n TO=380.1n

.meas tran Vdout1_49ck27 AVG v(dout1_49) FROM=379.9n TO=380.1n

.meas tran Vdout1_50ck27 AVG v(dout1_50) FROM=379.9n TO=380.1n

.meas tran Vdout1_51ck27 AVG v(dout1_51) FROM=379.9n TO=380.1n

.meas tran Vdout1_52ck27 AVG v(dout1_52) FROM=379.9n TO=380.1n

.meas tran Vdout1_53ck27 AVG v(dout1_53) FROM=379.9n TO=380.1n

.meas tran Vdout1_54ck27 AVG v(dout1_54) FROM=379.9n TO=380.1n

.meas tran Vdout1_55ck27 AVG v(dout1_55) FROM=379.9n TO=380.1n

.meas tran Vdout1_56ck27 AVG v(dout1_56) FROM=379.9n TO=380.1n

.meas tran Vdout1_57ck27 AVG v(dout1_57) FROM=379.9n TO=380.1n

.meas tran Vdout1_58ck27 AVG v(dout1_58) FROM=379.9n TO=380.1n

.meas tran Vdout1_59ck27 AVG v(dout1_59) FROM=379.9n TO=380.1n

.meas tran Vdout1_60ck27 AVG v(dout1_60) FROM=379.9n TO=380.1n

.meas tran Vdout1_61ck27 AVG v(dout1_61) FROM=379.9n TO=380.1n

.meas tran Vdout1_62ck27 AVG v(dout1_62) FROM=379.9n TO=380.1n

.meas tran Vdout1_63ck27 AVG v(dout1_63) FROM=379.9n TO=380.1n

.meas tran Vdout1_64ck27 AVG v(dout1_64) FROM=379.9n TO=380.1n

.meas tran Vdout1_65ck27 AVG v(dout1_65) FROM=379.9n TO=380.1n

.meas tran Vdout1_66ck27 AVG v(dout1_66) FROM=379.9n TO=380.1n

.meas tran Vdout1_67ck27 AVG v(dout1_67) FROM=379.9n TO=380.1n

.meas tran Vdout1_68ck27 AVG v(dout1_68) FROM=379.9n TO=380.1n

.meas tran Vdout1_69ck27 AVG v(dout1_69) FROM=379.9n TO=380.1n

.meas tran Vdout1_70ck27 AVG v(dout1_70) FROM=379.9n TO=380.1n

.meas tran Vdout1_71ck27 AVG v(dout1_71) FROM=379.9n TO=380.1n

.meas tran Vdout1_72ck27 AVG v(dout1_72) FROM=379.9n TO=380.1n

.meas tran Vdout1_73ck27 AVG v(dout1_73) FROM=379.9n TO=380.1n

.meas tran Vdout1_74ck27 AVG v(dout1_74) FROM=379.9n TO=380.1n

.meas tran Vdout1_75ck27 AVG v(dout1_75) FROM=379.9n TO=380.1n

.meas tran Vdout1_76ck27 AVG v(dout1_76) FROM=379.9n TO=380.1n

.meas tran Vdout1_77ck27 AVG v(dout1_77) FROM=379.9n TO=380.1n

.meas tran Vdout1_78ck27 AVG v(dout1_78) FROM=379.9n TO=380.1n

.meas tran Vdout1_79ck27 AVG v(dout1_79) FROM=379.9n TO=380.1n

.meas tran Vdout1_0ck28 AVG v(dout1_0) FROM=389.9n TO=390.1n

.meas tran Vdout1_1ck28 AVG v(dout1_1) FROM=389.9n TO=390.1n

.meas tran Vdout1_2ck28 AVG v(dout1_2) FROM=389.9n TO=390.1n

.meas tran Vdout1_3ck28 AVG v(dout1_3) FROM=389.9n TO=390.1n

.meas tran Vdout1_4ck28 AVG v(dout1_4) FROM=389.9n TO=390.1n

.meas tran Vdout1_5ck28 AVG v(dout1_5) FROM=389.9n TO=390.1n

.meas tran Vdout1_6ck28 AVG v(dout1_6) FROM=389.9n TO=390.1n

.meas tran Vdout1_7ck28 AVG v(dout1_7) FROM=389.9n TO=390.1n

.meas tran Vdout1_8ck28 AVG v(dout1_8) FROM=389.9n TO=390.1n

.meas tran Vdout1_9ck28 AVG v(dout1_9) FROM=389.9n TO=390.1n

.meas tran Vdout1_10ck28 AVG v(dout1_10) FROM=389.9n TO=390.1n

.meas tran Vdout1_11ck28 AVG v(dout1_11) FROM=389.9n TO=390.1n

.meas tran Vdout1_12ck28 AVG v(dout1_12) FROM=389.9n TO=390.1n

.meas tran Vdout1_13ck28 AVG v(dout1_13) FROM=389.9n TO=390.1n

.meas tran Vdout1_14ck28 AVG v(dout1_14) FROM=389.9n TO=390.1n

.meas tran Vdout1_15ck28 AVG v(dout1_15) FROM=389.9n TO=390.1n

.meas tran Vdout1_16ck28 AVG v(dout1_16) FROM=389.9n TO=390.1n

.meas tran Vdout1_17ck28 AVG v(dout1_17) FROM=389.9n TO=390.1n

.meas tran Vdout1_18ck28 AVG v(dout1_18) FROM=389.9n TO=390.1n

.meas tran Vdout1_19ck28 AVG v(dout1_19) FROM=389.9n TO=390.1n

.meas tran Vdout1_20ck28 AVG v(dout1_20) FROM=389.9n TO=390.1n

.meas tran Vdout1_21ck28 AVG v(dout1_21) FROM=389.9n TO=390.1n

.meas tran Vdout1_22ck28 AVG v(dout1_22) FROM=389.9n TO=390.1n

.meas tran Vdout1_23ck28 AVG v(dout1_23) FROM=389.9n TO=390.1n

.meas tran Vdout1_24ck28 AVG v(dout1_24) FROM=389.9n TO=390.1n

.meas tran Vdout1_25ck28 AVG v(dout1_25) FROM=389.9n TO=390.1n

.meas tran Vdout1_26ck28 AVG v(dout1_26) FROM=389.9n TO=390.1n

.meas tran Vdout1_27ck28 AVG v(dout1_27) FROM=389.9n TO=390.1n

.meas tran Vdout1_28ck28 AVG v(dout1_28) FROM=389.9n TO=390.1n

.meas tran Vdout1_29ck28 AVG v(dout1_29) FROM=389.9n TO=390.1n

.meas tran Vdout1_30ck28 AVG v(dout1_30) FROM=389.9n TO=390.1n

.meas tran Vdout1_31ck28 AVG v(dout1_31) FROM=389.9n TO=390.1n

.meas tran Vdout1_32ck28 AVG v(dout1_32) FROM=389.9n TO=390.1n

.meas tran Vdout1_33ck28 AVG v(dout1_33) FROM=389.9n TO=390.1n

.meas tran Vdout1_34ck28 AVG v(dout1_34) FROM=389.9n TO=390.1n

.meas tran Vdout1_35ck28 AVG v(dout1_35) FROM=389.9n TO=390.1n

.meas tran Vdout1_36ck28 AVG v(dout1_36) FROM=389.9n TO=390.1n

.meas tran Vdout1_37ck28 AVG v(dout1_37) FROM=389.9n TO=390.1n

.meas tran Vdout1_38ck28 AVG v(dout1_38) FROM=389.9n TO=390.1n

.meas tran Vdout1_39ck28 AVG v(dout1_39) FROM=389.9n TO=390.1n

.meas tran Vdout1_40ck28 AVG v(dout1_40) FROM=389.9n TO=390.1n

.meas tran Vdout1_41ck28 AVG v(dout1_41) FROM=389.9n TO=390.1n

.meas tran Vdout1_42ck28 AVG v(dout1_42) FROM=389.9n TO=390.1n

.meas tran Vdout1_43ck28 AVG v(dout1_43) FROM=389.9n TO=390.1n

.meas tran Vdout1_44ck28 AVG v(dout1_44) FROM=389.9n TO=390.1n

.meas tran Vdout1_45ck28 AVG v(dout1_45) FROM=389.9n TO=390.1n

.meas tran Vdout1_46ck28 AVG v(dout1_46) FROM=389.9n TO=390.1n

.meas tran Vdout1_47ck28 AVG v(dout1_47) FROM=389.9n TO=390.1n

.meas tran Vdout1_48ck28 AVG v(dout1_48) FROM=389.9n TO=390.1n

.meas tran Vdout1_49ck28 AVG v(dout1_49) FROM=389.9n TO=390.1n

.meas tran Vdout1_50ck28 AVG v(dout1_50) FROM=389.9n TO=390.1n

.meas tran Vdout1_51ck28 AVG v(dout1_51) FROM=389.9n TO=390.1n

.meas tran Vdout1_52ck28 AVG v(dout1_52) FROM=389.9n TO=390.1n

.meas tran Vdout1_53ck28 AVG v(dout1_53) FROM=389.9n TO=390.1n

.meas tran Vdout1_54ck28 AVG v(dout1_54) FROM=389.9n TO=390.1n

.meas tran Vdout1_55ck28 AVG v(dout1_55) FROM=389.9n TO=390.1n

.meas tran Vdout1_56ck28 AVG v(dout1_56) FROM=389.9n TO=390.1n

.meas tran Vdout1_57ck28 AVG v(dout1_57) FROM=389.9n TO=390.1n

.meas tran Vdout1_58ck28 AVG v(dout1_58) FROM=389.9n TO=390.1n

.meas tran Vdout1_59ck28 AVG v(dout1_59) FROM=389.9n TO=390.1n

.meas tran Vdout1_60ck28 AVG v(dout1_60) FROM=389.9n TO=390.1n

.meas tran Vdout1_61ck28 AVG v(dout1_61) FROM=389.9n TO=390.1n

.meas tran Vdout1_62ck28 AVG v(dout1_62) FROM=389.9n TO=390.1n

.meas tran Vdout1_63ck28 AVG v(dout1_63) FROM=389.9n TO=390.1n

.meas tran Vdout1_64ck28 AVG v(dout1_64) FROM=389.9n TO=390.1n

.meas tran Vdout1_65ck28 AVG v(dout1_65) FROM=389.9n TO=390.1n

.meas tran Vdout1_66ck28 AVG v(dout1_66) FROM=389.9n TO=390.1n

.meas tran Vdout1_67ck28 AVG v(dout1_67) FROM=389.9n TO=390.1n

.meas tran Vdout1_68ck28 AVG v(dout1_68) FROM=389.9n TO=390.1n

.meas tran Vdout1_69ck28 AVG v(dout1_69) FROM=389.9n TO=390.1n

.meas tran Vdout1_70ck28 AVG v(dout1_70) FROM=389.9n TO=390.1n

.meas tran Vdout1_71ck28 AVG v(dout1_71) FROM=389.9n TO=390.1n

.meas tran Vdout1_72ck28 AVG v(dout1_72) FROM=389.9n TO=390.1n

.meas tran Vdout1_73ck28 AVG v(dout1_73) FROM=389.9n TO=390.1n

.meas tran Vdout1_74ck28 AVG v(dout1_74) FROM=389.9n TO=390.1n

.meas tran Vdout1_75ck28 AVG v(dout1_75) FROM=389.9n TO=390.1n

.meas tran Vdout1_76ck28 AVG v(dout1_76) FROM=389.9n TO=390.1n

.meas tran Vdout1_77ck28 AVG v(dout1_77) FROM=389.9n TO=390.1n

.meas tran Vdout1_78ck28 AVG v(dout1_78) FROM=389.9n TO=390.1n

.meas tran Vdout1_79ck28 AVG v(dout1_79) FROM=389.9n TO=390.1n

.meas tran Vdout1_0ck29 AVG v(dout1_0) FROM=399.9n TO=400.1n

.meas tran Vdout1_1ck29 AVG v(dout1_1) FROM=399.9n TO=400.1n

.meas tran Vdout1_2ck29 AVG v(dout1_2) FROM=399.9n TO=400.1n

.meas tran Vdout1_3ck29 AVG v(dout1_3) FROM=399.9n TO=400.1n

.meas tran Vdout1_4ck29 AVG v(dout1_4) FROM=399.9n TO=400.1n

.meas tran Vdout1_5ck29 AVG v(dout1_5) FROM=399.9n TO=400.1n

.meas tran Vdout1_6ck29 AVG v(dout1_6) FROM=399.9n TO=400.1n

.meas tran Vdout1_7ck29 AVG v(dout1_7) FROM=399.9n TO=400.1n

.meas tran Vdout1_8ck29 AVG v(dout1_8) FROM=399.9n TO=400.1n

.meas tran Vdout1_9ck29 AVG v(dout1_9) FROM=399.9n TO=400.1n

.meas tran Vdout1_10ck29 AVG v(dout1_10) FROM=399.9n TO=400.1n

.meas tran Vdout1_11ck29 AVG v(dout1_11) FROM=399.9n TO=400.1n

.meas tran Vdout1_12ck29 AVG v(dout1_12) FROM=399.9n TO=400.1n

.meas tran Vdout1_13ck29 AVG v(dout1_13) FROM=399.9n TO=400.1n

.meas tran Vdout1_14ck29 AVG v(dout1_14) FROM=399.9n TO=400.1n

.meas tran Vdout1_15ck29 AVG v(dout1_15) FROM=399.9n TO=400.1n

.meas tran Vdout1_16ck29 AVG v(dout1_16) FROM=399.9n TO=400.1n

.meas tran Vdout1_17ck29 AVG v(dout1_17) FROM=399.9n TO=400.1n

.meas tran Vdout1_18ck29 AVG v(dout1_18) FROM=399.9n TO=400.1n

.meas tran Vdout1_19ck29 AVG v(dout1_19) FROM=399.9n TO=400.1n

.meas tran Vdout1_20ck29 AVG v(dout1_20) FROM=399.9n TO=400.1n

.meas tran Vdout1_21ck29 AVG v(dout1_21) FROM=399.9n TO=400.1n

.meas tran Vdout1_22ck29 AVG v(dout1_22) FROM=399.9n TO=400.1n

.meas tran Vdout1_23ck29 AVG v(dout1_23) FROM=399.9n TO=400.1n

.meas tran Vdout1_24ck29 AVG v(dout1_24) FROM=399.9n TO=400.1n

.meas tran Vdout1_25ck29 AVG v(dout1_25) FROM=399.9n TO=400.1n

.meas tran Vdout1_26ck29 AVG v(dout1_26) FROM=399.9n TO=400.1n

.meas tran Vdout1_27ck29 AVG v(dout1_27) FROM=399.9n TO=400.1n

.meas tran Vdout1_28ck29 AVG v(dout1_28) FROM=399.9n TO=400.1n

.meas tran Vdout1_29ck29 AVG v(dout1_29) FROM=399.9n TO=400.1n

.meas tran Vdout1_30ck29 AVG v(dout1_30) FROM=399.9n TO=400.1n

.meas tran Vdout1_31ck29 AVG v(dout1_31) FROM=399.9n TO=400.1n

.meas tran Vdout1_32ck29 AVG v(dout1_32) FROM=399.9n TO=400.1n

.meas tran Vdout1_33ck29 AVG v(dout1_33) FROM=399.9n TO=400.1n

.meas tran Vdout1_34ck29 AVG v(dout1_34) FROM=399.9n TO=400.1n

.meas tran Vdout1_35ck29 AVG v(dout1_35) FROM=399.9n TO=400.1n

.meas tran Vdout1_36ck29 AVG v(dout1_36) FROM=399.9n TO=400.1n

.meas tran Vdout1_37ck29 AVG v(dout1_37) FROM=399.9n TO=400.1n

.meas tran Vdout1_38ck29 AVG v(dout1_38) FROM=399.9n TO=400.1n

.meas tran Vdout1_39ck29 AVG v(dout1_39) FROM=399.9n TO=400.1n

.meas tran Vdout1_40ck29 AVG v(dout1_40) FROM=399.9n TO=400.1n

.meas tran Vdout1_41ck29 AVG v(dout1_41) FROM=399.9n TO=400.1n

.meas tran Vdout1_42ck29 AVG v(dout1_42) FROM=399.9n TO=400.1n

.meas tran Vdout1_43ck29 AVG v(dout1_43) FROM=399.9n TO=400.1n

.meas tran Vdout1_44ck29 AVG v(dout1_44) FROM=399.9n TO=400.1n

.meas tran Vdout1_45ck29 AVG v(dout1_45) FROM=399.9n TO=400.1n

.meas tran Vdout1_46ck29 AVG v(dout1_46) FROM=399.9n TO=400.1n

.meas tran Vdout1_47ck29 AVG v(dout1_47) FROM=399.9n TO=400.1n

.meas tran Vdout1_48ck29 AVG v(dout1_48) FROM=399.9n TO=400.1n

.meas tran Vdout1_49ck29 AVG v(dout1_49) FROM=399.9n TO=400.1n

.meas tran Vdout1_50ck29 AVG v(dout1_50) FROM=399.9n TO=400.1n

.meas tran Vdout1_51ck29 AVG v(dout1_51) FROM=399.9n TO=400.1n

.meas tran Vdout1_52ck29 AVG v(dout1_52) FROM=399.9n TO=400.1n

.meas tran Vdout1_53ck29 AVG v(dout1_53) FROM=399.9n TO=400.1n

.meas tran Vdout1_54ck29 AVG v(dout1_54) FROM=399.9n TO=400.1n

.meas tran Vdout1_55ck29 AVG v(dout1_55) FROM=399.9n TO=400.1n

.meas tran Vdout1_56ck29 AVG v(dout1_56) FROM=399.9n TO=400.1n

.meas tran Vdout1_57ck29 AVG v(dout1_57) FROM=399.9n TO=400.1n

.meas tran Vdout1_58ck29 AVG v(dout1_58) FROM=399.9n TO=400.1n

.meas tran Vdout1_59ck29 AVG v(dout1_59) FROM=399.9n TO=400.1n

.meas tran Vdout1_60ck29 AVG v(dout1_60) FROM=399.9n TO=400.1n

.meas tran Vdout1_61ck29 AVG v(dout1_61) FROM=399.9n TO=400.1n

.meas tran Vdout1_62ck29 AVG v(dout1_62) FROM=399.9n TO=400.1n

.meas tran Vdout1_63ck29 AVG v(dout1_63) FROM=399.9n TO=400.1n

.meas tran Vdout1_64ck29 AVG v(dout1_64) FROM=399.9n TO=400.1n

.meas tran Vdout1_65ck29 AVG v(dout1_65) FROM=399.9n TO=400.1n

.meas tran Vdout1_66ck29 AVG v(dout1_66) FROM=399.9n TO=400.1n

.meas tran Vdout1_67ck29 AVG v(dout1_67) FROM=399.9n TO=400.1n

.meas tran Vdout1_68ck29 AVG v(dout1_68) FROM=399.9n TO=400.1n

.meas tran Vdout1_69ck29 AVG v(dout1_69) FROM=399.9n TO=400.1n

.meas tran Vdout1_70ck29 AVG v(dout1_70) FROM=399.9n TO=400.1n

.meas tran Vdout1_71ck29 AVG v(dout1_71) FROM=399.9n TO=400.1n

.meas tran Vdout1_72ck29 AVG v(dout1_72) FROM=399.9n TO=400.1n

.meas tran Vdout1_73ck29 AVG v(dout1_73) FROM=399.9n TO=400.1n

.meas tran Vdout1_74ck29 AVG v(dout1_74) FROM=399.9n TO=400.1n

.meas tran Vdout1_75ck29 AVG v(dout1_75) FROM=399.9n TO=400.1n

.meas tran Vdout1_76ck29 AVG v(dout1_76) FROM=399.9n TO=400.1n

.meas tran Vdout1_77ck29 AVG v(dout1_77) FROM=399.9n TO=400.1n

.meas tran Vdout1_78ck29 AVG v(dout1_78) FROM=399.9n TO=400.1n

.meas tran Vdout1_79ck29 AVG v(dout1_79) FROM=399.9n TO=400.1n

.meas tran Vdout0_0ck30 AVG v(dout0_0) FROM=409.9n TO=410.1n

.meas tran Vdout0_1ck30 AVG v(dout0_1) FROM=409.9n TO=410.1n

.meas tran Vdout0_2ck30 AVG v(dout0_2) FROM=409.9n TO=410.1n

.meas tran Vdout0_3ck30 AVG v(dout0_3) FROM=409.9n TO=410.1n

.meas tran Vdout0_4ck30 AVG v(dout0_4) FROM=409.9n TO=410.1n

.meas tran Vdout0_5ck30 AVG v(dout0_5) FROM=409.9n TO=410.1n

.meas tran Vdout0_6ck30 AVG v(dout0_6) FROM=409.9n TO=410.1n

.meas tran Vdout0_7ck30 AVG v(dout0_7) FROM=409.9n TO=410.1n

.meas tran Vdout0_8ck30 AVG v(dout0_8) FROM=409.9n TO=410.1n

.meas tran Vdout0_9ck30 AVG v(dout0_9) FROM=409.9n TO=410.1n

.meas tran Vdout0_10ck30 AVG v(dout0_10) FROM=409.9n TO=410.1n

.meas tran Vdout0_11ck30 AVG v(dout0_11) FROM=409.9n TO=410.1n

.meas tran Vdout0_12ck30 AVG v(dout0_12) FROM=409.9n TO=410.1n

.meas tran Vdout0_13ck30 AVG v(dout0_13) FROM=409.9n TO=410.1n

.meas tran Vdout0_14ck30 AVG v(dout0_14) FROM=409.9n TO=410.1n

.meas tran Vdout0_15ck30 AVG v(dout0_15) FROM=409.9n TO=410.1n

.meas tran Vdout0_16ck30 AVG v(dout0_16) FROM=409.9n TO=410.1n

.meas tran Vdout0_17ck30 AVG v(dout0_17) FROM=409.9n TO=410.1n

.meas tran Vdout0_18ck30 AVG v(dout0_18) FROM=409.9n TO=410.1n

.meas tran Vdout0_19ck30 AVG v(dout0_19) FROM=409.9n TO=410.1n

.meas tran Vdout0_20ck30 AVG v(dout0_20) FROM=409.9n TO=410.1n

.meas tran Vdout0_21ck30 AVG v(dout0_21) FROM=409.9n TO=410.1n

.meas tran Vdout0_22ck30 AVG v(dout0_22) FROM=409.9n TO=410.1n

.meas tran Vdout0_23ck30 AVG v(dout0_23) FROM=409.9n TO=410.1n

.meas tran Vdout0_24ck30 AVG v(dout0_24) FROM=409.9n TO=410.1n

.meas tran Vdout0_25ck30 AVG v(dout0_25) FROM=409.9n TO=410.1n

.meas tran Vdout0_26ck30 AVG v(dout0_26) FROM=409.9n TO=410.1n

.meas tran Vdout0_27ck30 AVG v(dout0_27) FROM=409.9n TO=410.1n

.meas tran Vdout0_28ck30 AVG v(dout0_28) FROM=409.9n TO=410.1n

.meas tran Vdout0_29ck30 AVG v(dout0_29) FROM=409.9n TO=410.1n

.meas tran Vdout0_30ck30 AVG v(dout0_30) FROM=409.9n TO=410.1n

.meas tran Vdout0_31ck30 AVG v(dout0_31) FROM=409.9n TO=410.1n

.meas tran Vdout0_32ck30 AVG v(dout0_32) FROM=409.9n TO=410.1n

.meas tran Vdout0_33ck30 AVG v(dout0_33) FROM=409.9n TO=410.1n

.meas tran Vdout0_34ck30 AVG v(dout0_34) FROM=409.9n TO=410.1n

.meas tran Vdout0_35ck30 AVG v(dout0_35) FROM=409.9n TO=410.1n

.meas tran Vdout0_36ck30 AVG v(dout0_36) FROM=409.9n TO=410.1n

.meas tran Vdout0_37ck30 AVG v(dout0_37) FROM=409.9n TO=410.1n

.meas tran Vdout0_38ck30 AVG v(dout0_38) FROM=409.9n TO=410.1n

.meas tran Vdout0_39ck30 AVG v(dout0_39) FROM=409.9n TO=410.1n

.meas tran Vdout0_40ck30 AVG v(dout0_40) FROM=409.9n TO=410.1n

.meas tran Vdout0_41ck30 AVG v(dout0_41) FROM=409.9n TO=410.1n

.meas tran Vdout0_42ck30 AVG v(dout0_42) FROM=409.9n TO=410.1n

.meas tran Vdout0_43ck30 AVG v(dout0_43) FROM=409.9n TO=410.1n

.meas tran Vdout0_44ck30 AVG v(dout0_44) FROM=409.9n TO=410.1n

.meas tran Vdout0_45ck30 AVG v(dout0_45) FROM=409.9n TO=410.1n

.meas tran Vdout0_46ck30 AVG v(dout0_46) FROM=409.9n TO=410.1n

.meas tran Vdout0_47ck30 AVG v(dout0_47) FROM=409.9n TO=410.1n

.meas tran Vdout0_48ck30 AVG v(dout0_48) FROM=409.9n TO=410.1n

.meas tran Vdout0_49ck30 AVG v(dout0_49) FROM=409.9n TO=410.1n

.meas tran Vdout0_50ck30 AVG v(dout0_50) FROM=409.9n TO=410.1n

.meas tran Vdout0_51ck30 AVG v(dout0_51) FROM=409.9n TO=410.1n

.meas tran Vdout0_52ck30 AVG v(dout0_52) FROM=409.9n TO=410.1n

.meas tran Vdout0_53ck30 AVG v(dout0_53) FROM=409.9n TO=410.1n

.meas tran Vdout0_54ck30 AVG v(dout0_54) FROM=409.9n TO=410.1n

.meas tran Vdout0_55ck30 AVG v(dout0_55) FROM=409.9n TO=410.1n

.meas tran Vdout0_56ck30 AVG v(dout0_56) FROM=409.9n TO=410.1n

.meas tran Vdout0_57ck30 AVG v(dout0_57) FROM=409.9n TO=410.1n

.meas tran Vdout0_58ck30 AVG v(dout0_58) FROM=409.9n TO=410.1n

.meas tran Vdout0_59ck30 AVG v(dout0_59) FROM=409.9n TO=410.1n

.meas tran Vdout0_60ck30 AVG v(dout0_60) FROM=409.9n TO=410.1n

.meas tran Vdout0_61ck30 AVG v(dout0_61) FROM=409.9n TO=410.1n

.meas tran Vdout0_62ck30 AVG v(dout0_62) FROM=409.9n TO=410.1n

.meas tran Vdout0_63ck30 AVG v(dout0_63) FROM=409.9n TO=410.1n

.meas tran Vdout0_64ck30 AVG v(dout0_64) FROM=409.9n TO=410.1n

.meas tran Vdout0_65ck30 AVG v(dout0_65) FROM=409.9n TO=410.1n

.meas tran Vdout0_66ck30 AVG v(dout0_66) FROM=409.9n TO=410.1n

.meas tran Vdout0_67ck30 AVG v(dout0_67) FROM=409.9n TO=410.1n

.meas tran Vdout0_68ck30 AVG v(dout0_68) FROM=409.9n TO=410.1n

.meas tran Vdout0_69ck30 AVG v(dout0_69) FROM=409.9n TO=410.1n

.meas tran Vdout0_70ck30 AVG v(dout0_70) FROM=409.9n TO=410.1n

.meas tran Vdout0_71ck30 AVG v(dout0_71) FROM=409.9n TO=410.1n

.meas tran Vdout0_72ck30 AVG v(dout0_72) FROM=409.9n TO=410.1n

.meas tran Vdout0_73ck30 AVG v(dout0_73) FROM=409.9n TO=410.1n

.meas tran Vdout0_74ck30 AVG v(dout0_74) FROM=409.9n TO=410.1n

.meas tran Vdout0_75ck30 AVG v(dout0_75) FROM=409.9n TO=410.1n

.meas tran Vdout0_76ck30 AVG v(dout0_76) FROM=409.9n TO=410.1n

.meas tran Vdout0_77ck30 AVG v(dout0_77) FROM=409.9n TO=410.1n

.meas tran Vdout0_78ck30 AVG v(dout0_78) FROM=409.9n TO=410.1n

.meas tran Vdout0_79ck30 AVG v(dout0_79) FROM=409.9n TO=410.1n

.meas tran Vdout1_0ck31 AVG v(dout1_0) FROM=409.9n TO=410.1n

.meas tran Vdout1_1ck31 AVG v(dout1_1) FROM=409.9n TO=410.1n

.meas tran Vdout1_2ck31 AVG v(dout1_2) FROM=409.9n TO=410.1n

.meas tran Vdout1_3ck31 AVG v(dout1_3) FROM=409.9n TO=410.1n

.meas tran Vdout1_4ck31 AVG v(dout1_4) FROM=409.9n TO=410.1n

.meas tran Vdout1_5ck31 AVG v(dout1_5) FROM=409.9n TO=410.1n

.meas tran Vdout1_6ck31 AVG v(dout1_6) FROM=409.9n TO=410.1n

.meas tran Vdout1_7ck31 AVG v(dout1_7) FROM=409.9n TO=410.1n

.meas tran Vdout1_8ck31 AVG v(dout1_8) FROM=409.9n TO=410.1n

.meas tran Vdout1_9ck31 AVG v(dout1_9) FROM=409.9n TO=410.1n

.meas tran Vdout1_10ck31 AVG v(dout1_10) FROM=409.9n TO=410.1n

.meas tran Vdout1_11ck31 AVG v(dout1_11) FROM=409.9n TO=410.1n

.meas tran Vdout1_12ck31 AVG v(dout1_12) FROM=409.9n TO=410.1n

.meas tran Vdout1_13ck31 AVG v(dout1_13) FROM=409.9n TO=410.1n

.meas tran Vdout1_14ck31 AVG v(dout1_14) FROM=409.9n TO=410.1n

.meas tran Vdout1_15ck31 AVG v(dout1_15) FROM=409.9n TO=410.1n

.meas tran Vdout1_16ck31 AVG v(dout1_16) FROM=409.9n TO=410.1n

.meas tran Vdout1_17ck31 AVG v(dout1_17) FROM=409.9n TO=410.1n

.meas tran Vdout1_18ck31 AVG v(dout1_18) FROM=409.9n TO=410.1n

.meas tran Vdout1_19ck31 AVG v(dout1_19) FROM=409.9n TO=410.1n

.meas tran Vdout1_20ck31 AVG v(dout1_20) FROM=409.9n TO=410.1n

.meas tran Vdout1_21ck31 AVG v(dout1_21) FROM=409.9n TO=410.1n

.meas tran Vdout1_22ck31 AVG v(dout1_22) FROM=409.9n TO=410.1n

.meas tran Vdout1_23ck31 AVG v(dout1_23) FROM=409.9n TO=410.1n

.meas tran Vdout1_24ck31 AVG v(dout1_24) FROM=409.9n TO=410.1n

.meas tran Vdout1_25ck31 AVG v(dout1_25) FROM=409.9n TO=410.1n

.meas tran Vdout1_26ck31 AVG v(dout1_26) FROM=409.9n TO=410.1n

.meas tran Vdout1_27ck31 AVG v(dout1_27) FROM=409.9n TO=410.1n

.meas tran Vdout1_28ck31 AVG v(dout1_28) FROM=409.9n TO=410.1n

.meas tran Vdout1_29ck31 AVG v(dout1_29) FROM=409.9n TO=410.1n

.meas tran Vdout1_30ck31 AVG v(dout1_30) FROM=409.9n TO=410.1n

.meas tran Vdout1_31ck31 AVG v(dout1_31) FROM=409.9n TO=410.1n

.meas tran Vdout1_32ck31 AVG v(dout1_32) FROM=409.9n TO=410.1n

.meas tran Vdout1_33ck31 AVG v(dout1_33) FROM=409.9n TO=410.1n

.meas tran Vdout1_34ck31 AVG v(dout1_34) FROM=409.9n TO=410.1n

.meas tran Vdout1_35ck31 AVG v(dout1_35) FROM=409.9n TO=410.1n

.meas tran Vdout1_36ck31 AVG v(dout1_36) FROM=409.9n TO=410.1n

.meas tran Vdout1_37ck31 AVG v(dout1_37) FROM=409.9n TO=410.1n

.meas tran Vdout1_38ck31 AVG v(dout1_38) FROM=409.9n TO=410.1n

.meas tran Vdout1_39ck31 AVG v(dout1_39) FROM=409.9n TO=410.1n

.meas tran Vdout1_40ck31 AVG v(dout1_40) FROM=409.9n TO=410.1n

.meas tran Vdout1_41ck31 AVG v(dout1_41) FROM=409.9n TO=410.1n

.meas tran Vdout1_42ck31 AVG v(dout1_42) FROM=409.9n TO=410.1n

.meas tran Vdout1_43ck31 AVG v(dout1_43) FROM=409.9n TO=410.1n

.meas tran Vdout1_44ck31 AVG v(dout1_44) FROM=409.9n TO=410.1n

.meas tran Vdout1_45ck31 AVG v(dout1_45) FROM=409.9n TO=410.1n

.meas tran Vdout1_46ck31 AVG v(dout1_46) FROM=409.9n TO=410.1n

.meas tran Vdout1_47ck31 AVG v(dout1_47) FROM=409.9n TO=410.1n

.meas tran Vdout1_48ck31 AVG v(dout1_48) FROM=409.9n TO=410.1n

.meas tran Vdout1_49ck31 AVG v(dout1_49) FROM=409.9n TO=410.1n

.meas tran Vdout1_50ck31 AVG v(dout1_50) FROM=409.9n TO=410.1n

.meas tran Vdout1_51ck31 AVG v(dout1_51) FROM=409.9n TO=410.1n

.meas tran Vdout1_52ck31 AVG v(dout1_52) FROM=409.9n TO=410.1n

.meas tran Vdout1_53ck31 AVG v(dout1_53) FROM=409.9n TO=410.1n

.meas tran Vdout1_54ck31 AVG v(dout1_54) FROM=409.9n TO=410.1n

.meas tran Vdout1_55ck31 AVG v(dout1_55) FROM=409.9n TO=410.1n

.meas tran Vdout1_56ck31 AVG v(dout1_56) FROM=409.9n TO=410.1n

.meas tran Vdout1_57ck31 AVG v(dout1_57) FROM=409.9n TO=410.1n

.meas tran Vdout1_58ck31 AVG v(dout1_58) FROM=409.9n TO=410.1n

.meas tran Vdout1_59ck31 AVG v(dout1_59) FROM=409.9n TO=410.1n

.meas tran Vdout1_60ck31 AVG v(dout1_60) FROM=409.9n TO=410.1n

.meas tran Vdout1_61ck31 AVG v(dout1_61) FROM=409.9n TO=410.1n

.meas tran Vdout1_62ck31 AVG v(dout1_62) FROM=409.9n TO=410.1n

.meas tran Vdout1_63ck31 AVG v(dout1_63) FROM=409.9n TO=410.1n

.meas tran Vdout1_64ck31 AVG v(dout1_64) FROM=409.9n TO=410.1n

.meas tran Vdout1_65ck31 AVG v(dout1_65) FROM=409.9n TO=410.1n

.meas tran Vdout1_66ck31 AVG v(dout1_66) FROM=409.9n TO=410.1n

.meas tran Vdout1_67ck31 AVG v(dout1_67) FROM=409.9n TO=410.1n

.meas tran Vdout1_68ck31 AVG v(dout1_68) FROM=409.9n TO=410.1n

.meas tran Vdout1_69ck31 AVG v(dout1_69) FROM=409.9n TO=410.1n

.meas tran Vdout1_70ck31 AVG v(dout1_70) FROM=409.9n TO=410.1n

.meas tran Vdout1_71ck31 AVG v(dout1_71) FROM=409.9n TO=410.1n

.meas tran Vdout1_72ck31 AVG v(dout1_72) FROM=409.9n TO=410.1n

.meas tran Vdout1_73ck31 AVG v(dout1_73) FROM=409.9n TO=410.1n

.meas tran Vdout1_74ck31 AVG v(dout1_74) FROM=409.9n TO=410.1n

.meas tran Vdout1_75ck31 AVG v(dout1_75) FROM=409.9n TO=410.1n

.meas tran Vdout1_76ck31 AVG v(dout1_76) FROM=409.9n TO=410.1n

.meas tran Vdout1_77ck31 AVG v(dout1_77) FROM=409.9n TO=410.1n

.meas tran Vdout1_78ck31 AVG v(dout1_78) FROM=409.9n TO=410.1n

.meas tran Vdout1_79ck31 AVG v(dout1_79) FROM=409.9n TO=410.1n

.meas tran Vdout1_0ck32 AVG v(dout1_0) FROM=419.9n TO=420.1n

.meas tran Vdout1_1ck32 AVG v(dout1_1) FROM=419.9n TO=420.1n

.meas tran Vdout1_2ck32 AVG v(dout1_2) FROM=419.9n TO=420.1n

.meas tran Vdout1_3ck32 AVG v(dout1_3) FROM=419.9n TO=420.1n

.meas tran Vdout1_4ck32 AVG v(dout1_4) FROM=419.9n TO=420.1n

.meas tran Vdout1_5ck32 AVG v(dout1_5) FROM=419.9n TO=420.1n

.meas tran Vdout1_6ck32 AVG v(dout1_6) FROM=419.9n TO=420.1n

.meas tran Vdout1_7ck32 AVG v(dout1_7) FROM=419.9n TO=420.1n

.meas tran Vdout1_8ck32 AVG v(dout1_8) FROM=419.9n TO=420.1n

.meas tran Vdout1_9ck32 AVG v(dout1_9) FROM=419.9n TO=420.1n

.meas tran Vdout1_10ck32 AVG v(dout1_10) FROM=419.9n TO=420.1n

.meas tran Vdout1_11ck32 AVG v(dout1_11) FROM=419.9n TO=420.1n

.meas tran Vdout1_12ck32 AVG v(dout1_12) FROM=419.9n TO=420.1n

.meas tran Vdout1_13ck32 AVG v(dout1_13) FROM=419.9n TO=420.1n

.meas tran Vdout1_14ck32 AVG v(dout1_14) FROM=419.9n TO=420.1n

.meas tran Vdout1_15ck32 AVG v(dout1_15) FROM=419.9n TO=420.1n

.meas tran Vdout1_16ck32 AVG v(dout1_16) FROM=419.9n TO=420.1n

.meas tran Vdout1_17ck32 AVG v(dout1_17) FROM=419.9n TO=420.1n

.meas tran Vdout1_18ck32 AVG v(dout1_18) FROM=419.9n TO=420.1n

.meas tran Vdout1_19ck32 AVG v(dout1_19) FROM=419.9n TO=420.1n

.meas tran Vdout1_20ck32 AVG v(dout1_20) FROM=419.9n TO=420.1n

.meas tran Vdout1_21ck32 AVG v(dout1_21) FROM=419.9n TO=420.1n

.meas tran Vdout1_22ck32 AVG v(dout1_22) FROM=419.9n TO=420.1n

.meas tran Vdout1_23ck32 AVG v(dout1_23) FROM=419.9n TO=420.1n

.meas tran Vdout1_24ck32 AVG v(dout1_24) FROM=419.9n TO=420.1n

.meas tran Vdout1_25ck32 AVG v(dout1_25) FROM=419.9n TO=420.1n

.meas tran Vdout1_26ck32 AVG v(dout1_26) FROM=419.9n TO=420.1n

.meas tran Vdout1_27ck32 AVG v(dout1_27) FROM=419.9n TO=420.1n

.meas tran Vdout1_28ck32 AVG v(dout1_28) FROM=419.9n TO=420.1n

.meas tran Vdout1_29ck32 AVG v(dout1_29) FROM=419.9n TO=420.1n

.meas tran Vdout1_30ck32 AVG v(dout1_30) FROM=419.9n TO=420.1n

.meas tran Vdout1_31ck32 AVG v(dout1_31) FROM=419.9n TO=420.1n

.meas tran Vdout1_32ck32 AVG v(dout1_32) FROM=419.9n TO=420.1n

.meas tran Vdout1_33ck32 AVG v(dout1_33) FROM=419.9n TO=420.1n

.meas tran Vdout1_34ck32 AVG v(dout1_34) FROM=419.9n TO=420.1n

.meas tran Vdout1_35ck32 AVG v(dout1_35) FROM=419.9n TO=420.1n

.meas tran Vdout1_36ck32 AVG v(dout1_36) FROM=419.9n TO=420.1n

.meas tran Vdout1_37ck32 AVG v(dout1_37) FROM=419.9n TO=420.1n

.meas tran Vdout1_38ck32 AVG v(dout1_38) FROM=419.9n TO=420.1n

.meas tran Vdout1_39ck32 AVG v(dout1_39) FROM=419.9n TO=420.1n

.meas tran Vdout1_40ck32 AVG v(dout1_40) FROM=419.9n TO=420.1n

.meas tran Vdout1_41ck32 AVG v(dout1_41) FROM=419.9n TO=420.1n

.meas tran Vdout1_42ck32 AVG v(dout1_42) FROM=419.9n TO=420.1n

.meas tran Vdout1_43ck32 AVG v(dout1_43) FROM=419.9n TO=420.1n

.meas tran Vdout1_44ck32 AVG v(dout1_44) FROM=419.9n TO=420.1n

.meas tran Vdout1_45ck32 AVG v(dout1_45) FROM=419.9n TO=420.1n

.meas tran Vdout1_46ck32 AVG v(dout1_46) FROM=419.9n TO=420.1n

.meas tran Vdout1_47ck32 AVG v(dout1_47) FROM=419.9n TO=420.1n

.meas tran Vdout1_48ck32 AVG v(dout1_48) FROM=419.9n TO=420.1n

.meas tran Vdout1_49ck32 AVG v(dout1_49) FROM=419.9n TO=420.1n

.meas tran Vdout1_50ck32 AVG v(dout1_50) FROM=419.9n TO=420.1n

.meas tran Vdout1_51ck32 AVG v(dout1_51) FROM=419.9n TO=420.1n

.meas tran Vdout1_52ck32 AVG v(dout1_52) FROM=419.9n TO=420.1n

.meas tran Vdout1_53ck32 AVG v(dout1_53) FROM=419.9n TO=420.1n

.meas tran Vdout1_54ck32 AVG v(dout1_54) FROM=419.9n TO=420.1n

.meas tran Vdout1_55ck32 AVG v(dout1_55) FROM=419.9n TO=420.1n

.meas tran Vdout1_56ck32 AVG v(dout1_56) FROM=419.9n TO=420.1n

.meas tran Vdout1_57ck32 AVG v(dout1_57) FROM=419.9n TO=420.1n

.meas tran Vdout1_58ck32 AVG v(dout1_58) FROM=419.9n TO=420.1n

.meas tran Vdout1_59ck32 AVG v(dout1_59) FROM=419.9n TO=420.1n

.meas tran Vdout1_60ck32 AVG v(dout1_60) FROM=419.9n TO=420.1n

.meas tran Vdout1_61ck32 AVG v(dout1_61) FROM=419.9n TO=420.1n

.meas tran Vdout1_62ck32 AVG v(dout1_62) FROM=419.9n TO=420.1n

.meas tran Vdout1_63ck32 AVG v(dout1_63) FROM=419.9n TO=420.1n

.meas tran Vdout1_64ck32 AVG v(dout1_64) FROM=419.9n TO=420.1n

.meas tran Vdout1_65ck32 AVG v(dout1_65) FROM=419.9n TO=420.1n

.meas tran Vdout1_66ck32 AVG v(dout1_66) FROM=419.9n TO=420.1n

.meas tran Vdout1_67ck32 AVG v(dout1_67) FROM=419.9n TO=420.1n

.meas tran Vdout1_68ck32 AVG v(dout1_68) FROM=419.9n TO=420.1n

.meas tran Vdout1_69ck32 AVG v(dout1_69) FROM=419.9n TO=420.1n

.meas tran Vdout1_70ck32 AVG v(dout1_70) FROM=419.9n TO=420.1n

.meas tran Vdout1_71ck32 AVG v(dout1_71) FROM=419.9n TO=420.1n

.meas tran Vdout1_72ck32 AVG v(dout1_72) FROM=419.9n TO=420.1n

.meas tran Vdout1_73ck32 AVG v(dout1_73) FROM=419.9n TO=420.1n

.meas tran Vdout1_74ck32 AVG v(dout1_74) FROM=419.9n TO=420.1n

.meas tran Vdout1_75ck32 AVG v(dout1_75) FROM=419.9n TO=420.1n

.meas tran Vdout1_76ck32 AVG v(dout1_76) FROM=419.9n TO=420.1n

.meas tran Vdout1_77ck32 AVG v(dout1_77) FROM=419.9n TO=420.1n

.meas tran Vdout1_78ck32 AVG v(dout1_78) FROM=419.9n TO=420.1n

.meas tran Vdout1_79ck32 AVG v(dout1_79) FROM=419.9n TO=420.1n

.meas tran Vdout0_0ck33 AVG v(dout0_0) FROM=429.9n TO=430.1n

.meas tran Vdout0_1ck33 AVG v(dout0_1) FROM=429.9n TO=430.1n

.meas tran Vdout0_2ck33 AVG v(dout0_2) FROM=429.9n TO=430.1n

.meas tran Vdout0_3ck33 AVG v(dout0_3) FROM=429.9n TO=430.1n

.meas tran Vdout0_4ck33 AVG v(dout0_4) FROM=429.9n TO=430.1n

.meas tran Vdout0_5ck33 AVG v(dout0_5) FROM=429.9n TO=430.1n

.meas tran Vdout0_6ck33 AVG v(dout0_6) FROM=429.9n TO=430.1n

.meas tran Vdout0_7ck33 AVG v(dout0_7) FROM=429.9n TO=430.1n

.meas tran Vdout0_8ck33 AVG v(dout0_8) FROM=429.9n TO=430.1n

.meas tran Vdout0_9ck33 AVG v(dout0_9) FROM=429.9n TO=430.1n

.meas tran Vdout0_10ck33 AVG v(dout0_10) FROM=429.9n TO=430.1n

.meas tran Vdout0_11ck33 AVG v(dout0_11) FROM=429.9n TO=430.1n

.meas tran Vdout0_12ck33 AVG v(dout0_12) FROM=429.9n TO=430.1n

.meas tran Vdout0_13ck33 AVG v(dout0_13) FROM=429.9n TO=430.1n

.meas tran Vdout0_14ck33 AVG v(dout0_14) FROM=429.9n TO=430.1n

.meas tran Vdout0_15ck33 AVG v(dout0_15) FROM=429.9n TO=430.1n

.meas tran Vdout0_16ck33 AVG v(dout0_16) FROM=429.9n TO=430.1n

.meas tran Vdout0_17ck33 AVG v(dout0_17) FROM=429.9n TO=430.1n

.meas tran Vdout0_18ck33 AVG v(dout0_18) FROM=429.9n TO=430.1n

.meas tran Vdout0_19ck33 AVG v(dout0_19) FROM=429.9n TO=430.1n

.meas tran Vdout0_20ck33 AVG v(dout0_20) FROM=429.9n TO=430.1n

.meas tran Vdout0_21ck33 AVG v(dout0_21) FROM=429.9n TO=430.1n

.meas tran Vdout0_22ck33 AVG v(dout0_22) FROM=429.9n TO=430.1n

.meas tran Vdout0_23ck33 AVG v(dout0_23) FROM=429.9n TO=430.1n

.meas tran Vdout0_24ck33 AVG v(dout0_24) FROM=429.9n TO=430.1n

.meas tran Vdout0_25ck33 AVG v(dout0_25) FROM=429.9n TO=430.1n

.meas tran Vdout0_26ck33 AVG v(dout0_26) FROM=429.9n TO=430.1n

.meas tran Vdout0_27ck33 AVG v(dout0_27) FROM=429.9n TO=430.1n

.meas tran Vdout0_28ck33 AVG v(dout0_28) FROM=429.9n TO=430.1n

.meas tran Vdout0_29ck33 AVG v(dout0_29) FROM=429.9n TO=430.1n

.meas tran Vdout0_30ck33 AVG v(dout0_30) FROM=429.9n TO=430.1n

.meas tran Vdout0_31ck33 AVG v(dout0_31) FROM=429.9n TO=430.1n

.meas tran Vdout0_32ck33 AVG v(dout0_32) FROM=429.9n TO=430.1n

.meas tran Vdout0_33ck33 AVG v(dout0_33) FROM=429.9n TO=430.1n

.meas tran Vdout0_34ck33 AVG v(dout0_34) FROM=429.9n TO=430.1n

.meas tran Vdout0_35ck33 AVG v(dout0_35) FROM=429.9n TO=430.1n

.meas tran Vdout0_36ck33 AVG v(dout0_36) FROM=429.9n TO=430.1n

.meas tran Vdout0_37ck33 AVG v(dout0_37) FROM=429.9n TO=430.1n

.meas tran Vdout0_38ck33 AVG v(dout0_38) FROM=429.9n TO=430.1n

.meas tran Vdout0_39ck33 AVG v(dout0_39) FROM=429.9n TO=430.1n

.meas tran Vdout0_40ck33 AVG v(dout0_40) FROM=429.9n TO=430.1n

.meas tran Vdout0_41ck33 AVG v(dout0_41) FROM=429.9n TO=430.1n

.meas tran Vdout0_42ck33 AVG v(dout0_42) FROM=429.9n TO=430.1n

.meas tran Vdout0_43ck33 AVG v(dout0_43) FROM=429.9n TO=430.1n

.meas tran Vdout0_44ck33 AVG v(dout0_44) FROM=429.9n TO=430.1n

.meas tran Vdout0_45ck33 AVG v(dout0_45) FROM=429.9n TO=430.1n

.meas tran Vdout0_46ck33 AVG v(dout0_46) FROM=429.9n TO=430.1n

.meas tran Vdout0_47ck33 AVG v(dout0_47) FROM=429.9n TO=430.1n

.meas tran Vdout0_48ck33 AVG v(dout0_48) FROM=429.9n TO=430.1n

.meas tran Vdout0_49ck33 AVG v(dout0_49) FROM=429.9n TO=430.1n

.meas tran Vdout0_50ck33 AVG v(dout0_50) FROM=429.9n TO=430.1n

.meas tran Vdout0_51ck33 AVG v(dout0_51) FROM=429.9n TO=430.1n

.meas tran Vdout0_52ck33 AVG v(dout0_52) FROM=429.9n TO=430.1n

.meas tran Vdout0_53ck33 AVG v(dout0_53) FROM=429.9n TO=430.1n

.meas tran Vdout0_54ck33 AVG v(dout0_54) FROM=429.9n TO=430.1n

.meas tran Vdout0_55ck33 AVG v(dout0_55) FROM=429.9n TO=430.1n

.meas tran Vdout0_56ck33 AVG v(dout0_56) FROM=429.9n TO=430.1n

.meas tran Vdout0_57ck33 AVG v(dout0_57) FROM=429.9n TO=430.1n

.meas tran Vdout0_58ck33 AVG v(dout0_58) FROM=429.9n TO=430.1n

.meas tran Vdout0_59ck33 AVG v(dout0_59) FROM=429.9n TO=430.1n

.meas tran Vdout0_60ck33 AVG v(dout0_60) FROM=429.9n TO=430.1n

.meas tran Vdout0_61ck33 AVG v(dout0_61) FROM=429.9n TO=430.1n

.meas tran Vdout0_62ck33 AVG v(dout0_62) FROM=429.9n TO=430.1n

.meas tran Vdout0_63ck33 AVG v(dout0_63) FROM=429.9n TO=430.1n

.meas tran Vdout0_64ck33 AVG v(dout0_64) FROM=429.9n TO=430.1n

.meas tran Vdout0_65ck33 AVG v(dout0_65) FROM=429.9n TO=430.1n

.meas tran Vdout0_66ck33 AVG v(dout0_66) FROM=429.9n TO=430.1n

.meas tran Vdout0_67ck33 AVG v(dout0_67) FROM=429.9n TO=430.1n

.meas tran Vdout0_68ck33 AVG v(dout0_68) FROM=429.9n TO=430.1n

.meas tran Vdout0_69ck33 AVG v(dout0_69) FROM=429.9n TO=430.1n

.meas tran Vdout0_70ck33 AVG v(dout0_70) FROM=429.9n TO=430.1n

.meas tran Vdout0_71ck33 AVG v(dout0_71) FROM=429.9n TO=430.1n

.meas tran Vdout0_72ck33 AVG v(dout0_72) FROM=429.9n TO=430.1n

.meas tran Vdout0_73ck33 AVG v(dout0_73) FROM=429.9n TO=430.1n

.meas tran Vdout0_74ck33 AVG v(dout0_74) FROM=429.9n TO=430.1n

.meas tran Vdout0_75ck33 AVG v(dout0_75) FROM=429.9n TO=430.1n

.meas tran Vdout0_76ck33 AVG v(dout0_76) FROM=429.9n TO=430.1n

.meas tran Vdout0_77ck33 AVG v(dout0_77) FROM=429.9n TO=430.1n

.meas tran Vdout0_78ck33 AVG v(dout0_78) FROM=429.9n TO=430.1n

.meas tran Vdout0_79ck33 AVG v(dout0_79) FROM=429.9n TO=430.1n

.meas tran Vdout1_0ck34 AVG v(dout1_0) FROM=429.9n TO=430.1n

.meas tran Vdout1_1ck34 AVG v(dout1_1) FROM=429.9n TO=430.1n

.meas tran Vdout1_2ck34 AVG v(dout1_2) FROM=429.9n TO=430.1n

.meas tran Vdout1_3ck34 AVG v(dout1_3) FROM=429.9n TO=430.1n

.meas tran Vdout1_4ck34 AVG v(dout1_4) FROM=429.9n TO=430.1n

.meas tran Vdout1_5ck34 AVG v(dout1_5) FROM=429.9n TO=430.1n

.meas tran Vdout1_6ck34 AVG v(dout1_6) FROM=429.9n TO=430.1n

.meas tran Vdout1_7ck34 AVG v(dout1_7) FROM=429.9n TO=430.1n

.meas tran Vdout1_8ck34 AVG v(dout1_8) FROM=429.9n TO=430.1n

.meas tran Vdout1_9ck34 AVG v(dout1_9) FROM=429.9n TO=430.1n

.meas tran Vdout1_10ck34 AVG v(dout1_10) FROM=429.9n TO=430.1n

.meas tran Vdout1_11ck34 AVG v(dout1_11) FROM=429.9n TO=430.1n

.meas tran Vdout1_12ck34 AVG v(dout1_12) FROM=429.9n TO=430.1n

.meas tran Vdout1_13ck34 AVG v(dout1_13) FROM=429.9n TO=430.1n

.meas tran Vdout1_14ck34 AVG v(dout1_14) FROM=429.9n TO=430.1n

.meas tran Vdout1_15ck34 AVG v(dout1_15) FROM=429.9n TO=430.1n

.meas tran Vdout1_16ck34 AVG v(dout1_16) FROM=429.9n TO=430.1n

.meas tran Vdout1_17ck34 AVG v(dout1_17) FROM=429.9n TO=430.1n

.meas tran Vdout1_18ck34 AVG v(dout1_18) FROM=429.9n TO=430.1n

.meas tran Vdout1_19ck34 AVG v(dout1_19) FROM=429.9n TO=430.1n

.meas tran Vdout1_20ck34 AVG v(dout1_20) FROM=429.9n TO=430.1n

.meas tran Vdout1_21ck34 AVG v(dout1_21) FROM=429.9n TO=430.1n

.meas tran Vdout1_22ck34 AVG v(dout1_22) FROM=429.9n TO=430.1n

.meas tran Vdout1_23ck34 AVG v(dout1_23) FROM=429.9n TO=430.1n

.meas tran Vdout1_24ck34 AVG v(dout1_24) FROM=429.9n TO=430.1n

.meas tran Vdout1_25ck34 AVG v(dout1_25) FROM=429.9n TO=430.1n

.meas tran Vdout1_26ck34 AVG v(dout1_26) FROM=429.9n TO=430.1n

.meas tran Vdout1_27ck34 AVG v(dout1_27) FROM=429.9n TO=430.1n

.meas tran Vdout1_28ck34 AVG v(dout1_28) FROM=429.9n TO=430.1n

.meas tran Vdout1_29ck34 AVG v(dout1_29) FROM=429.9n TO=430.1n

.meas tran Vdout1_30ck34 AVG v(dout1_30) FROM=429.9n TO=430.1n

.meas tran Vdout1_31ck34 AVG v(dout1_31) FROM=429.9n TO=430.1n

.meas tran Vdout1_32ck34 AVG v(dout1_32) FROM=429.9n TO=430.1n

.meas tran Vdout1_33ck34 AVG v(dout1_33) FROM=429.9n TO=430.1n

.meas tran Vdout1_34ck34 AVG v(dout1_34) FROM=429.9n TO=430.1n

.meas tran Vdout1_35ck34 AVG v(dout1_35) FROM=429.9n TO=430.1n

.meas tran Vdout1_36ck34 AVG v(dout1_36) FROM=429.9n TO=430.1n

.meas tran Vdout1_37ck34 AVG v(dout1_37) FROM=429.9n TO=430.1n

.meas tran Vdout1_38ck34 AVG v(dout1_38) FROM=429.9n TO=430.1n

.meas tran Vdout1_39ck34 AVG v(dout1_39) FROM=429.9n TO=430.1n

.meas tran Vdout1_40ck34 AVG v(dout1_40) FROM=429.9n TO=430.1n

.meas tran Vdout1_41ck34 AVG v(dout1_41) FROM=429.9n TO=430.1n

.meas tran Vdout1_42ck34 AVG v(dout1_42) FROM=429.9n TO=430.1n

.meas tran Vdout1_43ck34 AVG v(dout1_43) FROM=429.9n TO=430.1n

.meas tran Vdout1_44ck34 AVG v(dout1_44) FROM=429.9n TO=430.1n

.meas tran Vdout1_45ck34 AVG v(dout1_45) FROM=429.9n TO=430.1n

.meas tran Vdout1_46ck34 AVG v(dout1_46) FROM=429.9n TO=430.1n

.meas tran Vdout1_47ck34 AVG v(dout1_47) FROM=429.9n TO=430.1n

.meas tran Vdout1_48ck34 AVG v(dout1_48) FROM=429.9n TO=430.1n

.meas tran Vdout1_49ck34 AVG v(dout1_49) FROM=429.9n TO=430.1n

.meas tran Vdout1_50ck34 AVG v(dout1_50) FROM=429.9n TO=430.1n

.meas tran Vdout1_51ck34 AVG v(dout1_51) FROM=429.9n TO=430.1n

.meas tran Vdout1_52ck34 AVG v(dout1_52) FROM=429.9n TO=430.1n

.meas tran Vdout1_53ck34 AVG v(dout1_53) FROM=429.9n TO=430.1n

.meas tran Vdout1_54ck34 AVG v(dout1_54) FROM=429.9n TO=430.1n

.meas tran Vdout1_55ck34 AVG v(dout1_55) FROM=429.9n TO=430.1n

.meas tran Vdout1_56ck34 AVG v(dout1_56) FROM=429.9n TO=430.1n

.meas tran Vdout1_57ck34 AVG v(dout1_57) FROM=429.9n TO=430.1n

.meas tran Vdout1_58ck34 AVG v(dout1_58) FROM=429.9n TO=430.1n

.meas tran Vdout1_59ck34 AVG v(dout1_59) FROM=429.9n TO=430.1n

.meas tran Vdout1_60ck34 AVG v(dout1_60) FROM=429.9n TO=430.1n

.meas tran Vdout1_61ck34 AVG v(dout1_61) FROM=429.9n TO=430.1n

.meas tran Vdout1_62ck34 AVG v(dout1_62) FROM=429.9n TO=430.1n

.meas tran Vdout1_63ck34 AVG v(dout1_63) FROM=429.9n TO=430.1n

.meas tran Vdout1_64ck34 AVG v(dout1_64) FROM=429.9n TO=430.1n

.meas tran Vdout1_65ck34 AVG v(dout1_65) FROM=429.9n TO=430.1n

.meas tran Vdout1_66ck34 AVG v(dout1_66) FROM=429.9n TO=430.1n

.meas tran Vdout1_67ck34 AVG v(dout1_67) FROM=429.9n TO=430.1n

.meas tran Vdout1_68ck34 AVG v(dout1_68) FROM=429.9n TO=430.1n

.meas tran Vdout1_69ck34 AVG v(dout1_69) FROM=429.9n TO=430.1n

.meas tran Vdout1_70ck34 AVG v(dout1_70) FROM=429.9n TO=430.1n

.meas tran Vdout1_71ck34 AVG v(dout1_71) FROM=429.9n TO=430.1n

.meas tran Vdout1_72ck34 AVG v(dout1_72) FROM=429.9n TO=430.1n

.meas tran Vdout1_73ck34 AVG v(dout1_73) FROM=429.9n TO=430.1n

.meas tran Vdout1_74ck34 AVG v(dout1_74) FROM=429.9n TO=430.1n

.meas tran Vdout1_75ck34 AVG v(dout1_75) FROM=429.9n TO=430.1n

.meas tran Vdout1_76ck34 AVG v(dout1_76) FROM=429.9n TO=430.1n

.meas tran Vdout1_77ck34 AVG v(dout1_77) FROM=429.9n TO=430.1n

.meas tran Vdout1_78ck34 AVG v(dout1_78) FROM=429.9n TO=430.1n

.meas tran Vdout1_79ck34 AVG v(dout1_79) FROM=429.9n TO=430.1n

.meas tran Vdout0_0ck35 AVG v(dout0_0) FROM=459.9n TO=460.1n

.meas tran Vdout0_1ck35 AVG v(dout0_1) FROM=459.9n TO=460.1n

.meas tran Vdout0_2ck35 AVG v(dout0_2) FROM=459.9n TO=460.1n

.meas tran Vdout0_3ck35 AVG v(dout0_3) FROM=459.9n TO=460.1n

.meas tran Vdout0_4ck35 AVG v(dout0_4) FROM=459.9n TO=460.1n

.meas tran Vdout0_5ck35 AVG v(dout0_5) FROM=459.9n TO=460.1n

.meas tran Vdout0_6ck35 AVG v(dout0_6) FROM=459.9n TO=460.1n

.meas tran Vdout0_7ck35 AVG v(dout0_7) FROM=459.9n TO=460.1n

.meas tran Vdout0_8ck35 AVG v(dout0_8) FROM=459.9n TO=460.1n

.meas tran Vdout0_9ck35 AVG v(dout0_9) FROM=459.9n TO=460.1n

.meas tran Vdout0_10ck35 AVG v(dout0_10) FROM=459.9n TO=460.1n

.meas tran Vdout0_11ck35 AVG v(dout0_11) FROM=459.9n TO=460.1n

.meas tran Vdout0_12ck35 AVG v(dout0_12) FROM=459.9n TO=460.1n

.meas tran Vdout0_13ck35 AVG v(dout0_13) FROM=459.9n TO=460.1n

.meas tran Vdout0_14ck35 AVG v(dout0_14) FROM=459.9n TO=460.1n

.meas tran Vdout0_15ck35 AVG v(dout0_15) FROM=459.9n TO=460.1n

.meas tran Vdout0_16ck35 AVG v(dout0_16) FROM=459.9n TO=460.1n

.meas tran Vdout0_17ck35 AVG v(dout0_17) FROM=459.9n TO=460.1n

.meas tran Vdout0_18ck35 AVG v(dout0_18) FROM=459.9n TO=460.1n

.meas tran Vdout0_19ck35 AVG v(dout0_19) FROM=459.9n TO=460.1n

.meas tran Vdout0_20ck35 AVG v(dout0_20) FROM=459.9n TO=460.1n

.meas tran Vdout0_21ck35 AVG v(dout0_21) FROM=459.9n TO=460.1n

.meas tran Vdout0_22ck35 AVG v(dout0_22) FROM=459.9n TO=460.1n

.meas tran Vdout0_23ck35 AVG v(dout0_23) FROM=459.9n TO=460.1n

.meas tran Vdout0_24ck35 AVG v(dout0_24) FROM=459.9n TO=460.1n

.meas tran Vdout0_25ck35 AVG v(dout0_25) FROM=459.9n TO=460.1n

.meas tran Vdout0_26ck35 AVG v(dout0_26) FROM=459.9n TO=460.1n

.meas tran Vdout0_27ck35 AVG v(dout0_27) FROM=459.9n TO=460.1n

.meas tran Vdout0_28ck35 AVG v(dout0_28) FROM=459.9n TO=460.1n

.meas tran Vdout0_29ck35 AVG v(dout0_29) FROM=459.9n TO=460.1n

.meas tran Vdout0_30ck35 AVG v(dout0_30) FROM=459.9n TO=460.1n

.meas tran Vdout0_31ck35 AVG v(dout0_31) FROM=459.9n TO=460.1n

.meas tran Vdout0_32ck35 AVG v(dout0_32) FROM=459.9n TO=460.1n

.meas tran Vdout0_33ck35 AVG v(dout0_33) FROM=459.9n TO=460.1n

.meas tran Vdout0_34ck35 AVG v(dout0_34) FROM=459.9n TO=460.1n

.meas tran Vdout0_35ck35 AVG v(dout0_35) FROM=459.9n TO=460.1n

.meas tran Vdout0_36ck35 AVG v(dout0_36) FROM=459.9n TO=460.1n

.meas tran Vdout0_37ck35 AVG v(dout0_37) FROM=459.9n TO=460.1n

.meas tran Vdout0_38ck35 AVG v(dout0_38) FROM=459.9n TO=460.1n

.meas tran Vdout0_39ck35 AVG v(dout0_39) FROM=459.9n TO=460.1n

.meas tran Vdout0_40ck35 AVG v(dout0_40) FROM=459.9n TO=460.1n

.meas tran Vdout0_41ck35 AVG v(dout0_41) FROM=459.9n TO=460.1n

.meas tran Vdout0_42ck35 AVG v(dout0_42) FROM=459.9n TO=460.1n

.meas tran Vdout0_43ck35 AVG v(dout0_43) FROM=459.9n TO=460.1n

.meas tran Vdout0_44ck35 AVG v(dout0_44) FROM=459.9n TO=460.1n

.meas tran Vdout0_45ck35 AVG v(dout0_45) FROM=459.9n TO=460.1n

.meas tran Vdout0_46ck35 AVG v(dout0_46) FROM=459.9n TO=460.1n

.meas tran Vdout0_47ck35 AVG v(dout0_47) FROM=459.9n TO=460.1n

.meas tran Vdout0_48ck35 AVG v(dout0_48) FROM=459.9n TO=460.1n

.meas tran Vdout0_49ck35 AVG v(dout0_49) FROM=459.9n TO=460.1n

.meas tran Vdout0_50ck35 AVG v(dout0_50) FROM=459.9n TO=460.1n

.meas tran Vdout0_51ck35 AVG v(dout0_51) FROM=459.9n TO=460.1n

.meas tran Vdout0_52ck35 AVG v(dout0_52) FROM=459.9n TO=460.1n

.meas tran Vdout0_53ck35 AVG v(dout0_53) FROM=459.9n TO=460.1n

.meas tran Vdout0_54ck35 AVG v(dout0_54) FROM=459.9n TO=460.1n

.meas tran Vdout0_55ck35 AVG v(dout0_55) FROM=459.9n TO=460.1n

.meas tran Vdout0_56ck35 AVG v(dout0_56) FROM=459.9n TO=460.1n

.meas tran Vdout0_57ck35 AVG v(dout0_57) FROM=459.9n TO=460.1n

.meas tran Vdout0_58ck35 AVG v(dout0_58) FROM=459.9n TO=460.1n

.meas tran Vdout0_59ck35 AVG v(dout0_59) FROM=459.9n TO=460.1n

.meas tran Vdout0_60ck35 AVG v(dout0_60) FROM=459.9n TO=460.1n

.meas tran Vdout0_61ck35 AVG v(dout0_61) FROM=459.9n TO=460.1n

.meas tran Vdout0_62ck35 AVG v(dout0_62) FROM=459.9n TO=460.1n

.meas tran Vdout0_63ck35 AVG v(dout0_63) FROM=459.9n TO=460.1n

.meas tran Vdout0_64ck35 AVG v(dout0_64) FROM=459.9n TO=460.1n

.meas tran Vdout0_65ck35 AVG v(dout0_65) FROM=459.9n TO=460.1n

.meas tran Vdout0_66ck35 AVG v(dout0_66) FROM=459.9n TO=460.1n

.meas tran Vdout0_67ck35 AVG v(dout0_67) FROM=459.9n TO=460.1n

.meas tran Vdout0_68ck35 AVG v(dout0_68) FROM=459.9n TO=460.1n

.meas tran Vdout0_69ck35 AVG v(dout0_69) FROM=459.9n TO=460.1n

.meas tran Vdout0_70ck35 AVG v(dout0_70) FROM=459.9n TO=460.1n

.meas tran Vdout0_71ck35 AVG v(dout0_71) FROM=459.9n TO=460.1n

.meas tran Vdout0_72ck35 AVG v(dout0_72) FROM=459.9n TO=460.1n

.meas tran Vdout0_73ck35 AVG v(dout0_73) FROM=459.9n TO=460.1n

.meas tran Vdout0_74ck35 AVG v(dout0_74) FROM=459.9n TO=460.1n

.meas tran Vdout0_75ck35 AVG v(dout0_75) FROM=459.9n TO=460.1n

.meas tran Vdout0_76ck35 AVG v(dout0_76) FROM=459.9n TO=460.1n

.meas tran Vdout0_77ck35 AVG v(dout0_77) FROM=459.9n TO=460.1n

.meas tran Vdout0_78ck35 AVG v(dout0_78) FROM=459.9n TO=460.1n

.meas tran Vdout0_79ck35 AVG v(dout0_79) FROM=459.9n TO=460.1n

.meas tran Vdout1_0ck36 AVG v(dout1_0) FROM=489.9n TO=490.1n

.meas tran Vdout1_1ck36 AVG v(dout1_1) FROM=489.9n TO=490.1n

.meas tran Vdout1_2ck36 AVG v(dout1_2) FROM=489.9n TO=490.1n

.meas tran Vdout1_3ck36 AVG v(dout1_3) FROM=489.9n TO=490.1n

.meas tran Vdout1_4ck36 AVG v(dout1_4) FROM=489.9n TO=490.1n

.meas tran Vdout1_5ck36 AVG v(dout1_5) FROM=489.9n TO=490.1n

.meas tran Vdout1_6ck36 AVG v(dout1_6) FROM=489.9n TO=490.1n

.meas tran Vdout1_7ck36 AVG v(dout1_7) FROM=489.9n TO=490.1n

.meas tran Vdout1_8ck36 AVG v(dout1_8) FROM=489.9n TO=490.1n

.meas tran Vdout1_9ck36 AVG v(dout1_9) FROM=489.9n TO=490.1n

.meas tran Vdout1_10ck36 AVG v(dout1_10) FROM=489.9n TO=490.1n

.meas tran Vdout1_11ck36 AVG v(dout1_11) FROM=489.9n TO=490.1n

.meas tran Vdout1_12ck36 AVG v(dout1_12) FROM=489.9n TO=490.1n

.meas tran Vdout1_13ck36 AVG v(dout1_13) FROM=489.9n TO=490.1n

.meas tran Vdout1_14ck36 AVG v(dout1_14) FROM=489.9n TO=490.1n

.meas tran Vdout1_15ck36 AVG v(dout1_15) FROM=489.9n TO=490.1n

.meas tran Vdout1_16ck36 AVG v(dout1_16) FROM=489.9n TO=490.1n

.meas tran Vdout1_17ck36 AVG v(dout1_17) FROM=489.9n TO=490.1n

.meas tran Vdout1_18ck36 AVG v(dout1_18) FROM=489.9n TO=490.1n

.meas tran Vdout1_19ck36 AVG v(dout1_19) FROM=489.9n TO=490.1n

.meas tran Vdout1_20ck36 AVG v(dout1_20) FROM=489.9n TO=490.1n

.meas tran Vdout1_21ck36 AVG v(dout1_21) FROM=489.9n TO=490.1n

.meas tran Vdout1_22ck36 AVG v(dout1_22) FROM=489.9n TO=490.1n

.meas tran Vdout1_23ck36 AVG v(dout1_23) FROM=489.9n TO=490.1n

.meas tran Vdout1_24ck36 AVG v(dout1_24) FROM=489.9n TO=490.1n

.meas tran Vdout1_25ck36 AVG v(dout1_25) FROM=489.9n TO=490.1n

.meas tran Vdout1_26ck36 AVG v(dout1_26) FROM=489.9n TO=490.1n

.meas tran Vdout1_27ck36 AVG v(dout1_27) FROM=489.9n TO=490.1n

.meas tran Vdout1_28ck36 AVG v(dout1_28) FROM=489.9n TO=490.1n

.meas tran Vdout1_29ck36 AVG v(dout1_29) FROM=489.9n TO=490.1n

.meas tran Vdout1_30ck36 AVG v(dout1_30) FROM=489.9n TO=490.1n

.meas tran Vdout1_31ck36 AVG v(dout1_31) FROM=489.9n TO=490.1n

.meas tran Vdout1_32ck36 AVG v(dout1_32) FROM=489.9n TO=490.1n

.meas tran Vdout1_33ck36 AVG v(dout1_33) FROM=489.9n TO=490.1n

.meas tran Vdout1_34ck36 AVG v(dout1_34) FROM=489.9n TO=490.1n

.meas tran Vdout1_35ck36 AVG v(dout1_35) FROM=489.9n TO=490.1n

.meas tran Vdout1_36ck36 AVG v(dout1_36) FROM=489.9n TO=490.1n

.meas tran Vdout1_37ck36 AVG v(dout1_37) FROM=489.9n TO=490.1n

.meas tran Vdout1_38ck36 AVG v(dout1_38) FROM=489.9n TO=490.1n

.meas tran Vdout1_39ck36 AVG v(dout1_39) FROM=489.9n TO=490.1n

.meas tran Vdout1_40ck36 AVG v(dout1_40) FROM=489.9n TO=490.1n

.meas tran Vdout1_41ck36 AVG v(dout1_41) FROM=489.9n TO=490.1n

.meas tran Vdout1_42ck36 AVG v(dout1_42) FROM=489.9n TO=490.1n

.meas tran Vdout1_43ck36 AVG v(dout1_43) FROM=489.9n TO=490.1n

.meas tran Vdout1_44ck36 AVG v(dout1_44) FROM=489.9n TO=490.1n

.meas tran Vdout1_45ck36 AVG v(dout1_45) FROM=489.9n TO=490.1n

.meas tran Vdout1_46ck36 AVG v(dout1_46) FROM=489.9n TO=490.1n

.meas tran Vdout1_47ck36 AVG v(dout1_47) FROM=489.9n TO=490.1n

.meas tran Vdout1_48ck36 AVG v(dout1_48) FROM=489.9n TO=490.1n

.meas tran Vdout1_49ck36 AVG v(dout1_49) FROM=489.9n TO=490.1n

.meas tran Vdout1_50ck36 AVG v(dout1_50) FROM=489.9n TO=490.1n

.meas tran Vdout1_51ck36 AVG v(dout1_51) FROM=489.9n TO=490.1n

.meas tran Vdout1_52ck36 AVG v(dout1_52) FROM=489.9n TO=490.1n

.meas tran Vdout1_53ck36 AVG v(dout1_53) FROM=489.9n TO=490.1n

.meas tran Vdout1_54ck36 AVG v(dout1_54) FROM=489.9n TO=490.1n

.meas tran Vdout1_55ck36 AVG v(dout1_55) FROM=489.9n TO=490.1n

.meas tran Vdout1_56ck36 AVG v(dout1_56) FROM=489.9n TO=490.1n

.meas tran Vdout1_57ck36 AVG v(dout1_57) FROM=489.9n TO=490.1n

.meas tran Vdout1_58ck36 AVG v(dout1_58) FROM=489.9n TO=490.1n

.meas tran Vdout1_59ck36 AVG v(dout1_59) FROM=489.9n TO=490.1n

.meas tran Vdout1_60ck36 AVG v(dout1_60) FROM=489.9n TO=490.1n

.meas tran Vdout1_61ck36 AVG v(dout1_61) FROM=489.9n TO=490.1n

.meas tran Vdout1_62ck36 AVG v(dout1_62) FROM=489.9n TO=490.1n

.meas tran Vdout1_63ck36 AVG v(dout1_63) FROM=489.9n TO=490.1n

.meas tran Vdout1_64ck36 AVG v(dout1_64) FROM=489.9n TO=490.1n

.meas tran Vdout1_65ck36 AVG v(dout1_65) FROM=489.9n TO=490.1n

.meas tran Vdout1_66ck36 AVG v(dout1_66) FROM=489.9n TO=490.1n

.meas tran Vdout1_67ck36 AVG v(dout1_67) FROM=489.9n TO=490.1n

.meas tran Vdout1_68ck36 AVG v(dout1_68) FROM=489.9n TO=490.1n

.meas tran Vdout1_69ck36 AVG v(dout1_69) FROM=489.9n TO=490.1n

.meas tran Vdout1_70ck36 AVG v(dout1_70) FROM=489.9n TO=490.1n

.meas tran Vdout1_71ck36 AVG v(dout1_71) FROM=489.9n TO=490.1n

.meas tran Vdout1_72ck36 AVG v(dout1_72) FROM=489.9n TO=490.1n

.meas tran Vdout1_73ck36 AVG v(dout1_73) FROM=489.9n TO=490.1n

.meas tran Vdout1_74ck36 AVG v(dout1_74) FROM=489.9n TO=490.1n

.meas tran Vdout1_75ck36 AVG v(dout1_75) FROM=489.9n TO=490.1n

.meas tran Vdout1_76ck36 AVG v(dout1_76) FROM=489.9n TO=490.1n

.meas tran Vdout1_77ck36 AVG v(dout1_77) FROM=489.9n TO=490.1n

.meas tran Vdout1_78ck36 AVG v(dout1_78) FROM=489.9n TO=490.1n

.meas tran Vdout1_79ck36 AVG v(dout1_79) FROM=489.9n TO=490.1n

.meas tran Vdout1_0ck37 AVG v(dout1_0) FROM=509.9n TO=510.1n

.meas tran Vdout1_1ck37 AVG v(dout1_1) FROM=509.9n TO=510.1n

.meas tran Vdout1_2ck37 AVG v(dout1_2) FROM=509.9n TO=510.1n

.meas tran Vdout1_3ck37 AVG v(dout1_3) FROM=509.9n TO=510.1n

.meas tran Vdout1_4ck37 AVG v(dout1_4) FROM=509.9n TO=510.1n

.meas tran Vdout1_5ck37 AVG v(dout1_5) FROM=509.9n TO=510.1n

.meas tran Vdout1_6ck37 AVG v(dout1_6) FROM=509.9n TO=510.1n

.meas tran Vdout1_7ck37 AVG v(dout1_7) FROM=509.9n TO=510.1n

.meas tran Vdout1_8ck37 AVG v(dout1_8) FROM=509.9n TO=510.1n

.meas tran Vdout1_9ck37 AVG v(dout1_9) FROM=509.9n TO=510.1n

.meas tran Vdout1_10ck37 AVG v(dout1_10) FROM=509.9n TO=510.1n

.meas tran Vdout1_11ck37 AVG v(dout1_11) FROM=509.9n TO=510.1n

.meas tran Vdout1_12ck37 AVG v(dout1_12) FROM=509.9n TO=510.1n

.meas tran Vdout1_13ck37 AVG v(dout1_13) FROM=509.9n TO=510.1n

.meas tran Vdout1_14ck37 AVG v(dout1_14) FROM=509.9n TO=510.1n

.meas tran Vdout1_15ck37 AVG v(dout1_15) FROM=509.9n TO=510.1n

.meas tran Vdout1_16ck37 AVG v(dout1_16) FROM=509.9n TO=510.1n

.meas tran Vdout1_17ck37 AVG v(dout1_17) FROM=509.9n TO=510.1n

.meas tran Vdout1_18ck37 AVG v(dout1_18) FROM=509.9n TO=510.1n

.meas tran Vdout1_19ck37 AVG v(dout1_19) FROM=509.9n TO=510.1n

.meas tran Vdout1_20ck37 AVG v(dout1_20) FROM=509.9n TO=510.1n

.meas tran Vdout1_21ck37 AVG v(dout1_21) FROM=509.9n TO=510.1n

.meas tran Vdout1_22ck37 AVG v(dout1_22) FROM=509.9n TO=510.1n

.meas tran Vdout1_23ck37 AVG v(dout1_23) FROM=509.9n TO=510.1n

.meas tran Vdout1_24ck37 AVG v(dout1_24) FROM=509.9n TO=510.1n

.meas tran Vdout1_25ck37 AVG v(dout1_25) FROM=509.9n TO=510.1n

.meas tran Vdout1_26ck37 AVG v(dout1_26) FROM=509.9n TO=510.1n

.meas tran Vdout1_27ck37 AVG v(dout1_27) FROM=509.9n TO=510.1n

.meas tran Vdout1_28ck37 AVG v(dout1_28) FROM=509.9n TO=510.1n

.meas tran Vdout1_29ck37 AVG v(dout1_29) FROM=509.9n TO=510.1n

.meas tran Vdout1_30ck37 AVG v(dout1_30) FROM=509.9n TO=510.1n

.meas tran Vdout1_31ck37 AVG v(dout1_31) FROM=509.9n TO=510.1n

.meas tran Vdout1_32ck37 AVG v(dout1_32) FROM=509.9n TO=510.1n

.meas tran Vdout1_33ck37 AVG v(dout1_33) FROM=509.9n TO=510.1n

.meas tran Vdout1_34ck37 AVG v(dout1_34) FROM=509.9n TO=510.1n

.meas tran Vdout1_35ck37 AVG v(dout1_35) FROM=509.9n TO=510.1n

.meas tran Vdout1_36ck37 AVG v(dout1_36) FROM=509.9n TO=510.1n

.meas tran Vdout1_37ck37 AVG v(dout1_37) FROM=509.9n TO=510.1n

.meas tran Vdout1_38ck37 AVG v(dout1_38) FROM=509.9n TO=510.1n

.meas tran Vdout1_39ck37 AVG v(dout1_39) FROM=509.9n TO=510.1n

.meas tran Vdout1_40ck37 AVG v(dout1_40) FROM=509.9n TO=510.1n

.meas tran Vdout1_41ck37 AVG v(dout1_41) FROM=509.9n TO=510.1n

.meas tran Vdout1_42ck37 AVG v(dout1_42) FROM=509.9n TO=510.1n

.meas tran Vdout1_43ck37 AVG v(dout1_43) FROM=509.9n TO=510.1n

.meas tran Vdout1_44ck37 AVG v(dout1_44) FROM=509.9n TO=510.1n

.meas tran Vdout1_45ck37 AVG v(dout1_45) FROM=509.9n TO=510.1n

.meas tran Vdout1_46ck37 AVG v(dout1_46) FROM=509.9n TO=510.1n

.meas tran Vdout1_47ck37 AVG v(dout1_47) FROM=509.9n TO=510.1n

.meas tran Vdout1_48ck37 AVG v(dout1_48) FROM=509.9n TO=510.1n

.meas tran Vdout1_49ck37 AVG v(dout1_49) FROM=509.9n TO=510.1n

.meas tran Vdout1_50ck37 AVG v(dout1_50) FROM=509.9n TO=510.1n

.meas tran Vdout1_51ck37 AVG v(dout1_51) FROM=509.9n TO=510.1n

.meas tran Vdout1_52ck37 AVG v(dout1_52) FROM=509.9n TO=510.1n

.meas tran Vdout1_53ck37 AVG v(dout1_53) FROM=509.9n TO=510.1n

.meas tran Vdout1_54ck37 AVG v(dout1_54) FROM=509.9n TO=510.1n

.meas tran Vdout1_55ck37 AVG v(dout1_55) FROM=509.9n TO=510.1n

.meas tran Vdout1_56ck37 AVG v(dout1_56) FROM=509.9n TO=510.1n

.meas tran Vdout1_57ck37 AVG v(dout1_57) FROM=509.9n TO=510.1n

.meas tran Vdout1_58ck37 AVG v(dout1_58) FROM=509.9n TO=510.1n

.meas tran Vdout1_59ck37 AVG v(dout1_59) FROM=509.9n TO=510.1n

.meas tran Vdout1_60ck37 AVG v(dout1_60) FROM=509.9n TO=510.1n

.meas tran Vdout1_61ck37 AVG v(dout1_61) FROM=509.9n TO=510.1n

.meas tran Vdout1_62ck37 AVG v(dout1_62) FROM=509.9n TO=510.1n

.meas tran Vdout1_63ck37 AVG v(dout1_63) FROM=509.9n TO=510.1n

.meas tran Vdout1_64ck37 AVG v(dout1_64) FROM=509.9n TO=510.1n

.meas tran Vdout1_65ck37 AVG v(dout1_65) FROM=509.9n TO=510.1n

.meas tran Vdout1_66ck37 AVG v(dout1_66) FROM=509.9n TO=510.1n

.meas tran Vdout1_67ck37 AVG v(dout1_67) FROM=509.9n TO=510.1n

.meas tran Vdout1_68ck37 AVG v(dout1_68) FROM=509.9n TO=510.1n

.meas tran Vdout1_69ck37 AVG v(dout1_69) FROM=509.9n TO=510.1n

.meas tran Vdout1_70ck37 AVG v(dout1_70) FROM=509.9n TO=510.1n

.meas tran Vdout1_71ck37 AVG v(dout1_71) FROM=509.9n TO=510.1n

.meas tran Vdout1_72ck37 AVG v(dout1_72) FROM=509.9n TO=510.1n

.meas tran Vdout1_73ck37 AVG v(dout1_73) FROM=509.9n TO=510.1n

.meas tran Vdout1_74ck37 AVG v(dout1_74) FROM=509.9n TO=510.1n

.meas tran Vdout1_75ck37 AVG v(dout1_75) FROM=509.9n TO=510.1n

.meas tran Vdout1_76ck37 AVG v(dout1_76) FROM=509.9n TO=510.1n

.meas tran Vdout1_77ck37 AVG v(dout1_77) FROM=509.9n TO=510.1n

.meas tran Vdout1_78ck37 AVG v(dout1_78) FROM=509.9n TO=510.1n

.meas tran Vdout1_79ck37 AVG v(dout1_79) FROM=509.9n TO=510.1n

.meas tran Vdout0_0ck38 AVG v(dout0_0) FROM=559.9n TO=560.1n

.meas tran Vdout0_1ck38 AVG v(dout0_1) FROM=559.9n TO=560.1n

.meas tran Vdout0_2ck38 AVG v(dout0_2) FROM=559.9n TO=560.1n

.meas tran Vdout0_3ck38 AVG v(dout0_3) FROM=559.9n TO=560.1n

.meas tran Vdout0_4ck38 AVG v(dout0_4) FROM=559.9n TO=560.1n

.meas tran Vdout0_5ck38 AVG v(dout0_5) FROM=559.9n TO=560.1n

.meas tran Vdout0_6ck38 AVG v(dout0_6) FROM=559.9n TO=560.1n

.meas tran Vdout0_7ck38 AVG v(dout0_7) FROM=559.9n TO=560.1n

.meas tran Vdout0_8ck38 AVG v(dout0_8) FROM=559.9n TO=560.1n

.meas tran Vdout0_9ck38 AVG v(dout0_9) FROM=559.9n TO=560.1n

.meas tran Vdout0_10ck38 AVG v(dout0_10) FROM=559.9n TO=560.1n

.meas tran Vdout0_11ck38 AVG v(dout0_11) FROM=559.9n TO=560.1n

.meas tran Vdout0_12ck38 AVG v(dout0_12) FROM=559.9n TO=560.1n

.meas tran Vdout0_13ck38 AVG v(dout0_13) FROM=559.9n TO=560.1n

.meas tran Vdout0_14ck38 AVG v(dout0_14) FROM=559.9n TO=560.1n

.meas tran Vdout0_15ck38 AVG v(dout0_15) FROM=559.9n TO=560.1n

.meas tran Vdout0_16ck38 AVG v(dout0_16) FROM=559.9n TO=560.1n

.meas tran Vdout0_17ck38 AVG v(dout0_17) FROM=559.9n TO=560.1n

.meas tran Vdout0_18ck38 AVG v(dout0_18) FROM=559.9n TO=560.1n

.meas tran Vdout0_19ck38 AVG v(dout0_19) FROM=559.9n TO=560.1n

.meas tran Vdout0_20ck38 AVG v(dout0_20) FROM=559.9n TO=560.1n

.meas tran Vdout0_21ck38 AVG v(dout0_21) FROM=559.9n TO=560.1n

.meas tran Vdout0_22ck38 AVG v(dout0_22) FROM=559.9n TO=560.1n

.meas tran Vdout0_23ck38 AVG v(dout0_23) FROM=559.9n TO=560.1n

.meas tran Vdout0_24ck38 AVG v(dout0_24) FROM=559.9n TO=560.1n

.meas tran Vdout0_25ck38 AVG v(dout0_25) FROM=559.9n TO=560.1n

.meas tran Vdout0_26ck38 AVG v(dout0_26) FROM=559.9n TO=560.1n

.meas tran Vdout0_27ck38 AVG v(dout0_27) FROM=559.9n TO=560.1n

.meas tran Vdout0_28ck38 AVG v(dout0_28) FROM=559.9n TO=560.1n

.meas tran Vdout0_29ck38 AVG v(dout0_29) FROM=559.9n TO=560.1n

.meas tran Vdout0_30ck38 AVG v(dout0_30) FROM=559.9n TO=560.1n

.meas tran Vdout0_31ck38 AVG v(dout0_31) FROM=559.9n TO=560.1n

.meas tran Vdout0_32ck38 AVG v(dout0_32) FROM=559.9n TO=560.1n

.meas tran Vdout0_33ck38 AVG v(dout0_33) FROM=559.9n TO=560.1n

.meas tran Vdout0_34ck38 AVG v(dout0_34) FROM=559.9n TO=560.1n

.meas tran Vdout0_35ck38 AVG v(dout0_35) FROM=559.9n TO=560.1n

.meas tran Vdout0_36ck38 AVG v(dout0_36) FROM=559.9n TO=560.1n

.meas tran Vdout0_37ck38 AVG v(dout0_37) FROM=559.9n TO=560.1n

.meas tran Vdout0_38ck38 AVG v(dout0_38) FROM=559.9n TO=560.1n

.meas tran Vdout0_39ck38 AVG v(dout0_39) FROM=559.9n TO=560.1n

.meas tran Vdout0_40ck38 AVG v(dout0_40) FROM=559.9n TO=560.1n

.meas tran Vdout0_41ck38 AVG v(dout0_41) FROM=559.9n TO=560.1n

.meas tran Vdout0_42ck38 AVG v(dout0_42) FROM=559.9n TO=560.1n

.meas tran Vdout0_43ck38 AVG v(dout0_43) FROM=559.9n TO=560.1n

.meas tran Vdout0_44ck38 AVG v(dout0_44) FROM=559.9n TO=560.1n

.meas tran Vdout0_45ck38 AVG v(dout0_45) FROM=559.9n TO=560.1n

.meas tran Vdout0_46ck38 AVG v(dout0_46) FROM=559.9n TO=560.1n

.meas tran Vdout0_47ck38 AVG v(dout0_47) FROM=559.9n TO=560.1n

.meas tran Vdout0_48ck38 AVG v(dout0_48) FROM=559.9n TO=560.1n

.meas tran Vdout0_49ck38 AVG v(dout0_49) FROM=559.9n TO=560.1n

.meas tran Vdout0_50ck38 AVG v(dout0_50) FROM=559.9n TO=560.1n

.meas tran Vdout0_51ck38 AVG v(dout0_51) FROM=559.9n TO=560.1n

.meas tran Vdout0_52ck38 AVG v(dout0_52) FROM=559.9n TO=560.1n

.meas tran Vdout0_53ck38 AVG v(dout0_53) FROM=559.9n TO=560.1n

.meas tran Vdout0_54ck38 AVG v(dout0_54) FROM=559.9n TO=560.1n

.meas tran Vdout0_55ck38 AVG v(dout0_55) FROM=559.9n TO=560.1n

.meas tran Vdout0_56ck38 AVG v(dout0_56) FROM=559.9n TO=560.1n

.meas tran Vdout0_57ck38 AVG v(dout0_57) FROM=559.9n TO=560.1n

.meas tran Vdout0_58ck38 AVG v(dout0_58) FROM=559.9n TO=560.1n

.meas tran Vdout0_59ck38 AVG v(dout0_59) FROM=559.9n TO=560.1n

.meas tran Vdout0_60ck38 AVG v(dout0_60) FROM=559.9n TO=560.1n

.meas tran Vdout0_61ck38 AVG v(dout0_61) FROM=559.9n TO=560.1n

.meas tran Vdout0_62ck38 AVG v(dout0_62) FROM=559.9n TO=560.1n

.meas tran Vdout0_63ck38 AVG v(dout0_63) FROM=559.9n TO=560.1n

.meas tran Vdout0_64ck38 AVG v(dout0_64) FROM=559.9n TO=560.1n

.meas tran Vdout0_65ck38 AVG v(dout0_65) FROM=559.9n TO=560.1n

.meas tran Vdout0_66ck38 AVG v(dout0_66) FROM=559.9n TO=560.1n

.meas tran Vdout0_67ck38 AVG v(dout0_67) FROM=559.9n TO=560.1n

.meas tran Vdout0_68ck38 AVG v(dout0_68) FROM=559.9n TO=560.1n

.meas tran Vdout0_69ck38 AVG v(dout0_69) FROM=559.9n TO=560.1n

.meas tran Vdout0_70ck38 AVG v(dout0_70) FROM=559.9n TO=560.1n

.meas tran Vdout0_71ck38 AVG v(dout0_71) FROM=559.9n TO=560.1n

.meas tran Vdout0_72ck38 AVG v(dout0_72) FROM=559.9n TO=560.1n

.meas tran Vdout0_73ck38 AVG v(dout0_73) FROM=559.9n TO=560.1n

.meas tran Vdout0_74ck38 AVG v(dout0_74) FROM=559.9n TO=560.1n

.meas tran Vdout0_75ck38 AVG v(dout0_75) FROM=559.9n TO=560.1n

.meas tran Vdout0_76ck38 AVG v(dout0_76) FROM=559.9n TO=560.1n

.meas tran Vdout0_77ck38 AVG v(dout0_77) FROM=559.9n TO=560.1n

.meas tran Vdout0_78ck38 AVG v(dout0_78) FROM=559.9n TO=560.1n

.meas tran Vdout0_79ck38 AVG v(dout0_79) FROM=559.9n TO=560.1n

.meas tran Vdout1_0ck39 AVG v(dout1_0) FROM=559.9n TO=560.1n

.meas tran Vdout1_1ck39 AVG v(dout1_1) FROM=559.9n TO=560.1n

.meas tran Vdout1_2ck39 AVG v(dout1_2) FROM=559.9n TO=560.1n

.meas tran Vdout1_3ck39 AVG v(dout1_3) FROM=559.9n TO=560.1n

.meas tran Vdout1_4ck39 AVG v(dout1_4) FROM=559.9n TO=560.1n

.meas tran Vdout1_5ck39 AVG v(dout1_5) FROM=559.9n TO=560.1n

.meas tran Vdout1_6ck39 AVG v(dout1_6) FROM=559.9n TO=560.1n

.meas tran Vdout1_7ck39 AVG v(dout1_7) FROM=559.9n TO=560.1n

.meas tran Vdout1_8ck39 AVG v(dout1_8) FROM=559.9n TO=560.1n

.meas tran Vdout1_9ck39 AVG v(dout1_9) FROM=559.9n TO=560.1n

.meas tran Vdout1_10ck39 AVG v(dout1_10) FROM=559.9n TO=560.1n

.meas tran Vdout1_11ck39 AVG v(dout1_11) FROM=559.9n TO=560.1n

.meas tran Vdout1_12ck39 AVG v(dout1_12) FROM=559.9n TO=560.1n

.meas tran Vdout1_13ck39 AVG v(dout1_13) FROM=559.9n TO=560.1n

.meas tran Vdout1_14ck39 AVG v(dout1_14) FROM=559.9n TO=560.1n

.meas tran Vdout1_15ck39 AVG v(dout1_15) FROM=559.9n TO=560.1n

.meas tran Vdout1_16ck39 AVG v(dout1_16) FROM=559.9n TO=560.1n

.meas tran Vdout1_17ck39 AVG v(dout1_17) FROM=559.9n TO=560.1n

.meas tran Vdout1_18ck39 AVG v(dout1_18) FROM=559.9n TO=560.1n

.meas tran Vdout1_19ck39 AVG v(dout1_19) FROM=559.9n TO=560.1n

.meas tran Vdout1_20ck39 AVG v(dout1_20) FROM=559.9n TO=560.1n

.meas tran Vdout1_21ck39 AVG v(dout1_21) FROM=559.9n TO=560.1n

.meas tran Vdout1_22ck39 AVG v(dout1_22) FROM=559.9n TO=560.1n

.meas tran Vdout1_23ck39 AVG v(dout1_23) FROM=559.9n TO=560.1n

.meas tran Vdout1_24ck39 AVG v(dout1_24) FROM=559.9n TO=560.1n

.meas tran Vdout1_25ck39 AVG v(dout1_25) FROM=559.9n TO=560.1n

.meas tran Vdout1_26ck39 AVG v(dout1_26) FROM=559.9n TO=560.1n

.meas tran Vdout1_27ck39 AVG v(dout1_27) FROM=559.9n TO=560.1n

.meas tran Vdout1_28ck39 AVG v(dout1_28) FROM=559.9n TO=560.1n

.meas tran Vdout1_29ck39 AVG v(dout1_29) FROM=559.9n TO=560.1n

.meas tran Vdout1_30ck39 AVG v(dout1_30) FROM=559.9n TO=560.1n

.meas tran Vdout1_31ck39 AVG v(dout1_31) FROM=559.9n TO=560.1n

.meas tran Vdout1_32ck39 AVG v(dout1_32) FROM=559.9n TO=560.1n

.meas tran Vdout1_33ck39 AVG v(dout1_33) FROM=559.9n TO=560.1n

.meas tran Vdout1_34ck39 AVG v(dout1_34) FROM=559.9n TO=560.1n

.meas tran Vdout1_35ck39 AVG v(dout1_35) FROM=559.9n TO=560.1n

.meas tran Vdout1_36ck39 AVG v(dout1_36) FROM=559.9n TO=560.1n

.meas tran Vdout1_37ck39 AVG v(dout1_37) FROM=559.9n TO=560.1n

.meas tran Vdout1_38ck39 AVG v(dout1_38) FROM=559.9n TO=560.1n

.meas tran Vdout1_39ck39 AVG v(dout1_39) FROM=559.9n TO=560.1n

.meas tran Vdout1_40ck39 AVG v(dout1_40) FROM=559.9n TO=560.1n

.meas tran Vdout1_41ck39 AVG v(dout1_41) FROM=559.9n TO=560.1n

.meas tran Vdout1_42ck39 AVG v(dout1_42) FROM=559.9n TO=560.1n

.meas tran Vdout1_43ck39 AVG v(dout1_43) FROM=559.9n TO=560.1n

.meas tran Vdout1_44ck39 AVG v(dout1_44) FROM=559.9n TO=560.1n

.meas tran Vdout1_45ck39 AVG v(dout1_45) FROM=559.9n TO=560.1n

.meas tran Vdout1_46ck39 AVG v(dout1_46) FROM=559.9n TO=560.1n

.meas tran Vdout1_47ck39 AVG v(dout1_47) FROM=559.9n TO=560.1n

.meas tran Vdout1_48ck39 AVG v(dout1_48) FROM=559.9n TO=560.1n

.meas tran Vdout1_49ck39 AVG v(dout1_49) FROM=559.9n TO=560.1n

.meas tran Vdout1_50ck39 AVG v(dout1_50) FROM=559.9n TO=560.1n

.meas tran Vdout1_51ck39 AVG v(dout1_51) FROM=559.9n TO=560.1n

.meas tran Vdout1_52ck39 AVG v(dout1_52) FROM=559.9n TO=560.1n

.meas tran Vdout1_53ck39 AVG v(dout1_53) FROM=559.9n TO=560.1n

.meas tran Vdout1_54ck39 AVG v(dout1_54) FROM=559.9n TO=560.1n

.meas tran Vdout1_55ck39 AVG v(dout1_55) FROM=559.9n TO=560.1n

.meas tran Vdout1_56ck39 AVG v(dout1_56) FROM=559.9n TO=560.1n

.meas tran Vdout1_57ck39 AVG v(dout1_57) FROM=559.9n TO=560.1n

.meas tran Vdout1_58ck39 AVG v(dout1_58) FROM=559.9n TO=560.1n

.meas tran Vdout1_59ck39 AVG v(dout1_59) FROM=559.9n TO=560.1n

.meas tran Vdout1_60ck39 AVG v(dout1_60) FROM=559.9n TO=560.1n

.meas tran Vdout1_61ck39 AVG v(dout1_61) FROM=559.9n TO=560.1n

.meas tran Vdout1_62ck39 AVG v(dout1_62) FROM=559.9n TO=560.1n

.meas tran Vdout1_63ck39 AVG v(dout1_63) FROM=559.9n TO=560.1n

.meas tran Vdout1_64ck39 AVG v(dout1_64) FROM=559.9n TO=560.1n

.meas tran Vdout1_65ck39 AVG v(dout1_65) FROM=559.9n TO=560.1n

.meas tran Vdout1_66ck39 AVG v(dout1_66) FROM=559.9n TO=560.1n

.meas tran Vdout1_67ck39 AVG v(dout1_67) FROM=559.9n TO=560.1n

.meas tran Vdout1_68ck39 AVG v(dout1_68) FROM=559.9n TO=560.1n

.meas tran Vdout1_69ck39 AVG v(dout1_69) FROM=559.9n TO=560.1n

.meas tran Vdout1_70ck39 AVG v(dout1_70) FROM=559.9n TO=560.1n

.meas tran Vdout1_71ck39 AVG v(dout1_71) FROM=559.9n TO=560.1n

.meas tran Vdout1_72ck39 AVG v(dout1_72) FROM=559.9n TO=560.1n

.meas tran Vdout1_73ck39 AVG v(dout1_73) FROM=559.9n TO=560.1n

.meas tran Vdout1_74ck39 AVG v(dout1_74) FROM=559.9n TO=560.1n

.meas tran Vdout1_75ck39 AVG v(dout1_75) FROM=559.9n TO=560.1n

.meas tran Vdout1_76ck39 AVG v(dout1_76) FROM=559.9n TO=560.1n

.meas tran Vdout1_77ck39 AVG v(dout1_77) FROM=559.9n TO=560.1n

.meas tran Vdout1_78ck39 AVG v(dout1_78) FROM=559.9n TO=560.1n

.meas tran Vdout1_79ck39 AVG v(dout1_79) FROM=559.9n TO=560.1n

.meas tran Vdout1_0ck40 AVG v(dout1_0) FROM=589.9n TO=590.1n

.meas tran Vdout1_1ck40 AVG v(dout1_1) FROM=589.9n TO=590.1n

.meas tran Vdout1_2ck40 AVG v(dout1_2) FROM=589.9n TO=590.1n

.meas tran Vdout1_3ck40 AVG v(dout1_3) FROM=589.9n TO=590.1n

.meas tran Vdout1_4ck40 AVG v(dout1_4) FROM=589.9n TO=590.1n

.meas tran Vdout1_5ck40 AVG v(dout1_5) FROM=589.9n TO=590.1n

.meas tran Vdout1_6ck40 AVG v(dout1_6) FROM=589.9n TO=590.1n

.meas tran Vdout1_7ck40 AVG v(dout1_7) FROM=589.9n TO=590.1n

.meas tran Vdout1_8ck40 AVG v(dout1_8) FROM=589.9n TO=590.1n

.meas tran Vdout1_9ck40 AVG v(dout1_9) FROM=589.9n TO=590.1n

.meas tran Vdout1_10ck40 AVG v(dout1_10) FROM=589.9n TO=590.1n

.meas tran Vdout1_11ck40 AVG v(dout1_11) FROM=589.9n TO=590.1n

.meas tran Vdout1_12ck40 AVG v(dout1_12) FROM=589.9n TO=590.1n

.meas tran Vdout1_13ck40 AVG v(dout1_13) FROM=589.9n TO=590.1n

.meas tran Vdout1_14ck40 AVG v(dout1_14) FROM=589.9n TO=590.1n

.meas tran Vdout1_15ck40 AVG v(dout1_15) FROM=589.9n TO=590.1n

.meas tran Vdout1_16ck40 AVG v(dout1_16) FROM=589.9n TO=590.1n

.meas tran Vdout1_17ck40 AVG v(dout1_17) FROM=589.9n TO=590.1n

.meas tran Vdout1_18ck40 AVG v(dout1_18) FROM=589.9n TO=590.1n

.meas tran Vdout1_19ck40 AVG v(dout1_19) FROM=589.9n TO=590.1n

.meas tran Vdout1_20ck40 AVG v(dout1_20) FROM=589.9n TO=590.1n

.meas tran Vdout1_21ck40 AVG v(dout1_21) FROM=589.9n TO=590.1n

.meas tran Vdout1_22ck40 AVG v(dout1_22) FROM=589.9n TO=590.1n

.meas tran Vdout1_23ck40 AVG v(dout1_23) FROM=589.9n TO=590.1n

.meas tran Vdout1_24ck40 AVG v(dout1_24) FROM=589.9n TO=590.1n

.meas tran Vdout1_25ck40 AVG v(dout1_25) FROM=589.9n TO=590.1n

.meas tran Vdout1_26ck40 AVG v(dout1_26) FROM=589.9n TO=590.1n

.meas tran Vdout1_27ck40 AVG v(dout1_27) FROM=589.9n TO=590.1n

.meas tran Vdout1_28ck40 AVG v(dout1_28) FROM=589.9n TO=590.1n

.meas tran Vdout1_29ck40 AVG v(dout1_29) FROM=589.9n TO=590.1n

.meas tran Vdout1_30ck40 AVG v(dout1_30) FROM=589.9n TO=590.1n

.meas tran Vdout1_31ck40 AVG v(dout1_31) FROM=589.9n TO=590.1n

.meas tran Vdout1_32ck40 AVG v(dout1_32) FROM=589.9n TO=590.1n

.meas tran Vdout1_33ck40 AVG v(dout1_33) FROM=589.9n TO=590.1n

.meas tran Vdout1_34ck40 AVG v(dout1_34) FROM=589.9n TO=590.1n

.meas tran Vdout1_35ck40 AVG v(dout1_35) FROM=589.9n TO=590.1n

.meas tran Vdout1_36ck40 AVG v(dout1_36) FROM=589.9n TO=590.1n

.meas tran Vdout1_37ck40 AVG v(dout1_37) FROM=589.9n TO=590.1n

.meas tran Vdout1_38ck40 AVG v(dout1_38) FROM=589.9n TO=590.1n

.meas tran Vdout1_39ck40 AVG v(dout1_39) FROM=589.9n TO=590.1n

.meas tran Vdout1_40ck40 AVG v(dout1_40) FROM=589.9n TO=590.1n

.meas tran Vdout1_41ck40 AVG v(dout1_41) FROM=589.9n TO=590.1n

.meas tran Vdout1_42ck40 AVG v(dout1_42) FROM=589.9n TO=590.1n

.meas tran Vdout1_43ck40 AVG v(dout1_43) FROM=589.9n TO=590.1n

.meas tran Vdout1_44ck40 AVG v(dout1_44) FROM=589.9n TO=590.1n

.meas tran Vdout1_45ck40 AVG v(dout1_45) FROM=589.9n TO=590.1n

.meas tran Vdout1_46ck40 AVG v(dout1_46) FROM=589.9n TO=590.1n

.meas tran Vdout1_47ck40 AVG v(dout1_47) FROM=589.9n TO=590.1n

.meas tran Vdout1_48ck40 AVG v(dout1_48) FROM=589.9n TO=590.1n

.meas tran Vdout1_49ck40 AVG v(dout1_49) FROM=589.9n TO=590.1n

.meas tran Vdout1_50ck40 AVG v(dout1_50) FROM=589.9n TO=590.1n

.meas tran Vdout1_51ck40 AVG v(dout1_51) FROM=589.9n TO=590.1n

.meas tran Vdout1_52ck40 AVG v(dout1_52) FROM=589.9n TO=590.1n

.meas tran Vdout1_53ck40 AVG v(dout1_53) FROM=589.9n TO=590.1n

.meas tran Vdout1_54ck40 AVG v(dout1_54) FROM=589.9n TO=590.1n

.meas tran Vdout1_55ck40 AVG v(dout1_55) FROM=589.9n TO=590.1n

.meas tran Vdout1_56ck40 AVG v(dout1_56) FROM=589.9n TO=590.1n

.meas tran Vdout1_57ck40 AVG v(dout1_57) FROM=589.9n TO=590.1n

.meas tran Vdout1_58ck40 AVG v(dout1_58) FROM=589.9n TO=590.1n

.meas tran Vdout1_59ck40 AVG v(dout1_59) FROM=589.9n TO=590.1n

.meas tran Vdout1_60ck40 AVG v(dout1_60) FROM=589.9n TO=590.1n

.meas tran Vdout1_61ck40 AVG v(dout1_61) FROM=589.9n TO=590.1n

.meas tran Vdout1_62ck40 AVG v(dout1_62) FROM=589.9n TO=590.1n

.meas tran Vdout1_63ck40 AVG v(dout1_63) FROM=589.9n TO=590.1n

.meas tran Vdout1_64ck40 AVG v(dout1_64) FROM=589.9n TO=590.1n

.meas tran Vdout1_65ck40 AVG v(dout1_65) FROM=589.9n TO=590.1n

.meas tran Vdout1_66ck40 AVG v(dout1_66) FROM=589.9n TO=590.1n

.meas tran Vdout1_67ck40 AVG v(dout1_67) FROM=589.9n TO=590.1n

.meas tran Vdout1_68ck40 AVG v(dout1_68) FROM=589.9n TO=590.1n

.meas tran Vdout1_69ck40 AVG v(dout1_69) FROM=589.9n TO=590.1n

.meas tran Vdout1_70ck40 AVG v(dout1_70) FROM=589.9n TO=590.1n

.meas tran Vdout1_71ck40 AVG v(dout1_71) FROM=589.9n TO=590.1n

.meas tran Vdout1_72ck40 AVG v(dout1_72) FROM=589.9n TO=590.1n

.meas tran Vdout1_73ck40 AVG v(dout1_73) FROM=589.9n TO=590.1n

.meas tran Vdout1_74ck40 AVG v(dout1_74) FROM=589.9n TO=590.1n

.meas tran Vdout1_75ck40 AVG v(dout1_75) FROM=589.9n TO=590.1n

.meas tran Vdout1_76ck40 AVG v(dout1_76) FROM=589.9n TO=590.1n

.meas tran Vdout1_77ck40 AVG v(dout1_77) FROM=589.9n TO=590.1n

.meas tran Vdout1_78ck40 AVG v(dout1_78) FROM=589.9n TO=590.1n

.meas tran Vdout1_79ck40 AVG v(dout1_79) FROM=589.9n TO=590.1n

.meas tran Vdout1_0ck41 AVG v(dout1_0) FROM=619.9n TO=620.1n

.meas tran Vdout1_1ck41 AVG v(dout1_1) FROM=619.9n TO=620.1n

.meas tran Vdout1_2ck41 AVG v(dout1_2) FROM=619.9n TO=620.1n

.meas tran Vdout1_3ck41 AVG v(dout1_3) FROM=619.9n TO=620.1n

.meas tran Vdout1_4ck41 AVG v(dout1_4) FROM=619.9n TO=620.1n

.meas tran Vdout1_5ck41 AVG v(dout1_5) FROM=619.9n TO=620.1n

.meas tran Vdout1_6ck41 AVG v(dout1_6) FROM=619.9n TO=620.1n

.meas tran Vdout1_7ck41 AVG v(dout1_7) FROM=619.9n TO=620.1n

.meas tran Vdout1_8ck41 AVG v(dout1_8) FROM=619.9n TO=620.1n

.meas tran Vdout1_9ck41 AVG v(dout1_9) FROM=619.9n TO=620.1n

.meas tran Vdout1_10ck41 AVG v(dout1_10) FROM=619.9n TO=620.1n

.meas tran Vdout1_11ck41 AVG v(dout1_11) FROM=619.9n TO=620.1n

.meas tran Vdout1_12ck41 AVG v(dout1_12) FROM=619.9n TO=620.1n

.meas tran Vdout1_13ck41 AVG v(dout1_13) FROM=619.9n TO=620.1n

.meas tran Vdout1_14ck41 AVG v(dout1_14) FROM=619.9n TO=620.1n

.meas tran Vdout1_15ck41 AVG v(dout1_15) FROM=619.9n TO=620.1n

.meas tran Vdout1_16ck41 AVG v(dout1_16) FROM=619.9n TO=620.1n

.meas tran Vdout1_17ck41 AVG v(dout1_17) FROM=619.9n TO=620.1n

.meas tran Vdout1_18ck41 AVG v(dout1_18) FROM=619.9n TO=620.1n

.meas tran Vdout1_19ck41 AVG v(dout1_19) FROM=619.9n TO=620.1n

.meas tran Vdout1_20ck41 AVG v(dout1_20) FROM=619.9n TO=620.1n

.meas tran Vdout1_21ck41 AVG v(dout1_21) FROM=619.9n TO=620.1n

.meas tran Vdout1_22ck41 AVG v(dout1_22) FROM=619.9n TO=620.1n

.meas tran Vdout1_23ck41 AVG v(dout1_23) FROM=619.9n TO=620.1n

.meas tran Vdout1_24ck41 AVG v(dout1_24) FROM=619.9n TO=620.1n

.meas tran Vdout1_25ck41 AVG v(dout1_25) FROM=619.9n TO=620.1n

.meas tran Vdout1_26ck41 AVG v(dout1_26) FROM=619.9n TO=620.1n

.meas tran Vdout1_27ck41 AVG v(dout1_27) FROM=619.9n TO=620.1n

.meas tran Vdout1_28ck41 AVG v(dout1_28) FROM=619.9n TO=620.1n

.meas tran Vdout1_29ck41 AVG v(dout1_29) FROM=619.9n TO=620.1n

.meas tran Vdout1_30ck41 AVG v(dout1_30) FROM=619.9n TO=620.1n

.meas tran Vdout1_31ck41 AVG v(dout1_31) FROM=619.9n TO=620.1n

.meas tran Vdout1_32ck41 AVG v(dout1_32) FROM=619.9n TO=620.1n

.meas tran Vdout1_33ck41 AVG v(dout1_33) FROM=619.9n TO=620.1n

.meas tran Vdout1_34ck41 AVG v(dout1_34) FROM=619.9n TO=620.1n

.meas tran Vdout1_35ck41 AVG v(dout1_35) FROM=619.9n TO=620.1n

.meas tran Vdout1_36ck41 AVG v(dout1_36) FROM=619.9n TO=620.1n

.meas tran Vdout1_37ck41 AVG v(dout1_37) FROM=619.9n TO=620.1n

.meas tran Vdout1_38ck41 AVG v(dout1_38) FROM=619.9n TO=620.1n

.meas tran Vdout1_39ck41 AVG v(dout1_39) FROM=619.9n TO=620.1n

.meas tran Vdout1_40ck41 AVG v(dout1_40) FROM=619.9n TO=620.1n

.meas tran Vdout1_41ck41 AVG v(dout1_41) FROM=619.9n TO=620.1n

.meas tran Vdout1_42ck41 AVG v(dout1_42) FROM=619.9n TO=620.1n

.meas tran Vdout1_43ck41 AVG v(dout1_43) FROM=619.9n TO=620.1n

.meas tran Vdout1_44ck41 AVG v(dout1_44) FROM=619.9n TO=620.1n

.meas tran Vdout1_45ck41 AVG v(dout1_45) FROM=619.9n TO=620.1n

.meas tran Vdout1_46ck41 AVG v(dout1_46) FROM=619.9n TO=620.1n

.meas tran Vdout1_47ck41 AVG v(dout1_47) FROM=619.9n TO=620.1n

.meas tran Vdout1_48ck41 AVG v(dout1_48) FROM=619.9n TO=620.1n

.meas tran Vdout1_49ck41 AVG v(dout1_49) FROM=619.9n TO=620.1n

.meas tran Vdout1_50ck41 AVG v(dout1_50) FROM=619.9n TO=620.1n

.meas tran Vdout1_51ck41 AVG v(dout1_51) FROM=619.9n TO=620.1n

.meas tran Vdout1_52ck41 AVG v(dout1_52) FROM=619.9n TO=620.1n

.meas tran Vdout1_53ck41 AVG v(dout1_53) FROM=619.9n TO=620.1n

.meas tran Vdout1_54ck41 AVG v(dout1_54) FROM=619.9n TO=620.1n

.meas tran Vdout1_55ck41 AVG v(dout1_55) FROM=619.9n TO=620.1n

.meas tran Vdout1_56ck41 AVG v(dout1_56) FROM=619.9n TO=620.1n

.meas tran Vdout1_57ck41 AVG v(dout1_57) FROM=619.9n TO=620.1n

.meas tran Vdout1_58ck41 AVG v(dout1_58) FROM=619.9n TO=620.1n

.meas tran Vdout1_59ck41 AVG v(dout1_59) FROM=619.9n TO=620.1n

.meas tran Vdout1_60ck41 AVG v(dout1_60) FROM=619.9n TO=620.1n

.meas tran Vdout1_61ck41 AVG v(dout1_61) FROM=619.9n TO=620.1n

.meas tran Vdout1_62ck41 AVG v(dout1_62) FROM=619.9n TO=620.1n

.meas tran Vdout1_63ck41 AVG v(dout1_63) FROM=619.9n TO=620.1n

.meas tran Vdout1_64ck41 AVG v(dout1_64) FROM=619.9n TO=620.1n

.meas tran Vdout1_65ck41 AVG v(dout1_65) FROM=619.9n TO=620.1n

.meas tran Vdout1_66ck41 AVG v(dout1_66) FROM=619.9n TO=620.1n

.meas tran Vdout1_67ck41 AVG v(dout1_67) FROM=619.9n TO=620.1n

.meas tran Vdout1_68ck41 AVG v(dout1_68) FROM=619.9n TO=620.1n

.meas tran Vdout1_69ck41 AVG v(dout1_69) FROM=619.9n TO=620.1n

.meas tran Vdout1_70ck41 AVG v(dout1_70) FROM=619.9n TO=620.1n

.meas tran Vdout1_71ck41 AVG v(dout1_71) FROM=619.9n TO=620.1n

.meas tran Vdout1_72ck41 AVG v(dout1_72) FROM=619.9n TO=620.1n

.meas tran Vdout1_73ck41 AVG v(dout1_73) FROM=619.9n TO=620.1n

.meas tran Vdout1_74ck41 AVG v(dout1_74) FROM=619.9n TO=620.1n

.meas tran Vdout1_75ck41 AVG v(dout1_75) FROM=619.9n TO=620.1n

.meas tran Vdout1_76ck41 AVG v(dout1_76) FROM=619.9n TO=620.1n

.meas tran Vdout1_77ck41 AVG v(dout1_77) FROM=619.9n TO=620.1n

.meas tran Vdout1_78ck41 AVG v(dout1_78) FROM=619.9n TO=620.1n

.meas tran Vdout1_79ck41 AVG v(dout1_79) FROM=619.9n TO=620.1n

.meas tran Vdout0_0ck42 AVG v(dout0_0) FROM=629.9n TO=630.1n

.meas tran Vdout0_1ck42 AVG v(dout0_1) FROM=629.9n TO=630.1n

.meas tran Vdout0_2ck42 AVG v(dout0_2) FROM=629.9n TO=630.1n

.meas tran Vdout0_3ck42 AVG v(dout0_3) FROM=629.9n TO=630.1n

.meas tran Vdout0_4ck42 AVG v(dout0_4) FROM=629.9n TO=630.1n

.meas tran Vdout0_5ck42 AVG v(dout0_5) FROM=629.9n TO=630.1n

.meas tran Vdout0_6ck42 AVG v(dout0_6) FROM=629.9n TO=630.1n

.meas tran Vdout0_7ck42 AVG v(dout0_7) FROM=629.9n TO=630.1n

.meas tran Vdout0_8ck42 AVG v(dout0_8) FROM=629.9n TO=630.1n

.meas tran Vdout0_9ck42 AVG v(dout0_9) FROM=629.9n TO=630.1n

.meas tran Vdout0_10ck42 AVG v(dout0_10) FROM=629.9n TO=630.1n

.meas tran Vdout0_11ck42 AVG v(dout0_11) FROM=629.9n TO=630.1n

.meas tran Vdout0_12ck42 AVG v(dout0_12) FROM=629.9n TO=630.1n

.meas tran Vdout0_13ck42 AVG v(dout0_13) FROM=629.9n TO=630.1n

.meas tran Vdout0_14ck42 AVG v(dout0_14) FROM=629.9n TO=630.1n

.meas tran Vdout0_15ck42 AVG v(dout0_15) FROM=629.9n TO=630.1n

.meas tran Vdout0_16ck42 AVG v(dout0_16) FROM=629.9n TO=630.1n

.meas tran Vdout0_17ck42 AVG v(dout0_17) FROM=629.9n TO=630.1n

.meas tran Vdout0_18ck42 AVG v(dout0_18) FROM=629.9n TO=630.1n

.meas tran Vdout0_19ck42 AVG v(dout0_19) FROM=629.9n TO=630.1n

.meas tran Vdout0_20ck42 AVG v(dout0_20) FROM=629.9n TO=630.1n

.meas tran Vdout0_21ck42 AVG v(dout0_21) FROM=629.9n TO=630.1n

.meas tran Vdout0_22ck42 AVG v(dout0_22) FROM=629.9n TO=630.1n

.meas tran Vdout0_23ck42 AVG v(dout0_23) FROM=629.9n TO=630.1n

.meas tran Vdout0_24ck42 AVG v(dout0_24) FROM=629.9n TO=630.1n

.meas tran Vdout0_25ck42 AVG v(dout0_25) FROM=629.9n TO=630.1n

.meas tran Vdout0_26ck42 AVG v(dout0_26) FROM=629.9n TO=630.1n

.meas tran Vdout0_27ck42 AVG v(dout0_27) FROM=629.9n TO=630.1n

.meas tran Vdout0_28ck42 AVG v(dout0_28) FROM=629.9n TO=630.1n

.meas tran Vdout0_29ck42 AVG v(dout0_29) FROM=629.9n TO=630.1n

.meas tran Vdout0_30ck42 AVG v(dout0_30) FROM=629.9n TO=630.1n

.meas tran Vdout0_31ck42 AVG v(dout0_31) FROM=629.9n TO=630.1n

.meas tran Vdout0_32ck42 AVG v(dout0_32) FROM=629.9n TO=630.1n

.meas tran Vdout0_33ck42 AVG v(dout0_33) FROM=629.9n TO=630.1n

.meas tran Vdout0_34ck42 AVG v(dout0_34) FROM=629.9n TO=630.1n

.meas tran Vdout0_35ck42 AVG v(dout0_35) FROM=629.9n TO=630.1n

.meas tran Vdout0_36ck42 AVG v(dout0_36) FROM=629.9n TO=630.1n

.meas tran Vdout0_37ck42 AVG v(dout0_37) FROM=629.9n TO=630.1n

.meas tran Vdout0_38ck42 AVG v(dout0_38) FROM=629.9n TO=630.1n

.meas tran Vdout0_39ck42 AVG v(dout0_39) FROM=629.9n TO=630.1n

.meas tran Vdout0_40ck42 AVG v(dout0_40) FROM=629.9n TO=630.1n

.meas tran Vdout0_41ck42 AVG v(dout0_41) FROM=629.9n TO=630.1n

.meas tran Vdout0_42ck42 AVG v(dout0_42) FROM=629.9n TO=630.1n

.meas tran Vdout0_43ck42 AVG v(dout0_43) FROM=629.9n TO=630.1n

.meas tran Vdout0_44ck42 AVG v(dout0_44) FROM=629.9n TO=630.1n

.meas tran Vdout0_45ck42 AVG v(dout0_45) FROM=629.9n TO=630.1n

.meas tran Vdout0_46ck42 AVG v(dout0_46) FROM=629.9n TO=630.1n

.meas tran Vdout0_47ck42 AVG v(dout0_47) FROM=629.9n TO=630.1n

.meas tran Vdout0_48ck42 AVG v(dout0_48) FROM=629.9n TO=630.1n

.meas tran Vdout0_49ck42 AVG v(dout0_49) FROM=629.9n TO=630.1n

.meas tran Vdout0_50ck42 AVG v(dout0_50) FROM=629.9n TO=630.1n

.meas tran Vdout0_51ck42 AVG v(dout0_51) FROM=629.9n TO=630.1n

.meas tran Vdout0_52ck42 AVG v(dout0_52) FROM=629.9n TO=630.1n

.meas tran Vdout0_53ck42 AVG v(dout0_53) FROM=629.9n TO=630.1n

.meas tran Vdout0_54ck42 AVG v(dout0_54) FROM=629.9n TO=630.1n

.meas tran Vdout0_55ck42 AVG v(dout0_55) FROM=629.9n TO=630.1n

.meas tran Vdout0_56ck42 AVG v(dout0_56) FROM=629.9n TO=630.1n

.meas tran Vdout0_57ck42 AVG v(dout0_57) FROM=629.9n TO=630.1n

.meas tran Vdout0_58ck42 AVG v(dout0_58) FROM=629.9n TO=630.1n

.meas tran Vdout0_59ck42 AVG v(dout0_59) FROM=629.9n TO=630.1n

.meas tran Vdout0_60ck42 AVG v(dout0_60) FROM=629.9n TO=630.1n

.meas tran Vdout0_61ck42 AVG v(dout0_61) FROM=629.9n TO=630.1n

.meas tran Vdout0_62ck42 AVG v(dout0_62) FROM=629.9n TO=630.1n

.meas tran Vdout0_63ck42 AVG v(dout0_63) FROM=629.9n TO=630.1n

.meas tran Vdout0_64ck42 AVG v(dout0_64) FROM=629.9n TO=630.1n

.meas tran Vdout0_65ck42 AVG v(dout0_65) FROM=629.9n TO=630.1n

.meas tran Vdout0_66ck42 AVG v(dout0_66) FROM=629.9n TO=630.1n

.meas tran Vdout0_67ck42 AVG v(dout0_67) FROM=629.9n TO=630.1n

.meas tran Vdout0_68ck42 AVG v(dout0_68) FROM=629.9n TO=630.1n

.meas tran Vdout0_69ck42 AVG v(dout0_69) FROM=629.9n TO=630.1n

.meas tran Vdout0_70ck42 AVG v(dout0_70) FROM=629.9n TO=630.1n

.meas tran Vdout0_71ck42 AVG v(dout0_71) FROM=629.9n TO=630.1n

.meas tran Vdout0_72ck42 AVG v(dout0_72) FROM=629.9n TO=630.1n

.meas tran Vdout0_73ck42 AVG v(dout0_73) FROM=629.9n TO=630.1n

.meas tran Vdout0_74ck42 AVG v(dout0_74) FROM=629.9n TO=630.1n

.meas tran Vdout0_75ck42 AVG v(dout0_75) FROM=629.9n TO=630.1n

.meas tran Vdout0_76ck42 AVG v(dout0_76) FROM=629.9n TO=630.1n

.meas tran Vdout0_77ck42 AVG v(dout0_77) FROM=629.9n TO=630.1n

.meas tran Vdout0_78ck42 AVG v(dout0_78) FROM=629.9n TO=630.1n

.meas tran Vdout0_79ck42 AVG v(dout0_79) FROM=629.9n TO=630.1n

.meas tran Vdout1_0ck43 AVG v(dout1_0) FROM=629.9n TO=630.1n

.meas tran Vdout1_1ck43 AVG v(dout1_1) FROM=629.9n TO=630.1n

.meas tran Vdout1_2ck43 AVG v(dout1_2) FROM=629.9n TO=630.1n

.meas tran Vdout1_3ck43 AVG v(dout1_3) FROM=629.9n TO=630.1n

.meas tran Vdout1_4ck43 AVG v(dout1_4) FROM=629.9n TO=630.1n

.meas tran Vdout1_5ck43 AVG v(dout1_5) FROM=629.9n TO=630.1n

.meas tran Vdout1_6ck43 AVG v(dout1_6) FROM=629.9n TO=630.1n

.meas tran Vdout1_7ck43 AVG v(dout1_7) FROM=629.9n TO=630.1n

.meas tran Vdout1_8ck43 AVG v(dout1_8) FROM=629.9n TO=630.1n

.meas tran Vdout1_9ck43 AVG v(dout1_9) FROM=629.9n TO=630.1n

.meas tran Vdout1_10ck43 AVG v(dout1_10) FROM=629.9n TO=630.1n

.meas tran Vdout1_11ck43 AVG v(dout1_11) FROM=629.9n TO=630.1n

.meas tran Vdout1_12ck43 AVG v(dout1_12) FROM=629.9n TO=630.1n

.meas tran Vdout1_13ck43 AVG v(dout1_13) FROM=629.9n TO=630.1n

.meas tran Vdout1_14ck43 AVG v(dout1_14) FROM=629.9n TO=630.1n

.meas tran Vdout1_15ck43 AVG v(dout1_15) FROM=629.9n TO=630.1n

.meas tran Vdout1_16ck43 AVG v(dout1_16) FROM=629.9n TO=630.1n

.meas tran Vdout1_17ck43 AVG v(dout1_17) FROM=629.9n TO=630.1n

.meas tran Vdout1_18ck43 AVG v(dout1_18) FROM=629.9n TO=630.1n

.meas tran Vdout1_19ck43 AVG v(dout1_19) FROM=629.9n TO=630.1n

.meas tran Vdout1_20ck43 AVG v(dout1_20) FROM=629.9n TO=630.1n

.meas tran Vdout1_21ck43 AVG v(dout1_21) FROM=629.9n TO=630.1n

.meas tran Vdout1_22ck43 AVG v(dout1_22) FROM=629.9n TO=630.1n

.meas tran Vdout1_23ck43 AVG v(dout1_23) FROM=629.9n TO=630.1n

.meas tran Vdout1_24ck43 AVG v(dout1_24) FROM=629.9n TO=630.1n

.meas tran Vdout1_25ck43 AVG v(dout1_25) FROM=629.9n TO=630.1n

.meas tran Vdout1_26ck43 AVG v(dout1_26) FROM=629.9n TO=630.1n

.meas tran Vdout1_27ck43 AVG v(dout1_27) FROM=629.9n TO=630.1n

.meas tran Vdout1_28ck43 AVG v(dout1_28) FROM=629.9n TO=630.1n

.meas tran Vdout1_29ck43 AVG v(dout1_29) FROM=629.9n TO=630.1n

.meas tran Vdout1_30ck43 AVG v(dout1_30) FROM=629.9n TO=630.1n

.meas tran Vdout1_31ck43 AVG v(dout1_31) FROM=629.9n TO=630.1n

.meas tran Vdout1_32ck43 AVG v(dout1_32) FROM=629.9n TO=630.1n

.meas tran Vdout1_33ck43 AVG v(dout1_33) FROM=629.9n TO=630.1n

.meas tran Vdout1_34ck43 AVG v(dout1_34) FROM=629.9n TO=630.1n

.meas tran Vdout1_35ck43 AVG v(dout1_35) FROM=629.9n TO=630.1n

.meas tran Vdout1_36ck43 AVG v(dout1_36) FROM=629.9n TO=630.1n

.meas tran Vdout1_37ck43 AVG v(dout1_37) FROM=629.9n TO=630.1n

.meas tran Vdout1_38ck43 AVG v(dout1_38) FROM=629.9n TO=630.1n

.meas tran Vdout1_39ck43 AVG v(dout1_39) FROM=629.9n TO=630.1n

.meas tran Vdout1_40ck43 AVG v(dout1_40) FROM=629.9n TO=630.1n

.meas tran Vdout1_41ck43 AVG v(dout1_41) FROM=629.9n TO=630.1n

.meas tran Vdout1_42ck43 AVG v(dout1_42) FROM=629.9n TO=630.1n

.meas tran Vdout1_43ck43 AVG v(dout1_43) FROM=629.9n TO=630.1n

.meas tran Vdout1_44ck43 AVG v(dout1_44) FROM=629.9n TO=630.1n

.meas tran Vdout1_45ck43 AVG v(dout1_45) FROM=629.9n TO=630.1n

.meas tran Vdout1_46ck43 AVG v(dout1_46) FROM=629.9n TO=630.1n

.meas tran Vdout1_47ck43 AVG v(dout1_47) FROM=629.9n TO=630.1n

.meas tran Vdout1_48ck43 AVG v(dout1_48) FROM=629.9n TO=630.1n

.meas tran Vdout1_49ck43 AVG v(dout1_49) FROM=629.9n TO=630.1n

.meas tran Vdout1_50ck43 AVG v(dout1_50) FROM=629.9n TO=630.1n

.meas tran Vdout1_51ck43 AVG v(dout1_51) FROM=629.9n TO=630.1n

.meas tran Vdout1_52ck43 AVG v(dout1_52) FROM=629.9n TO=630.1n

.meas tran Vdout1_53ck43 AVG v(dout1_53) FROM=629.9n TO=630.1n

.meas tran Vdout1_54ck43 AVG v(dout1_54) FROM=629.9n TO=630.1n

.meas tran Vdout1_55ck43 AVG v(dout1_55) FROM=629.9n TO=630.1n

.meas tran Vdout1_56ck43 AVG v(dout1_56) FROM=629.9n TO=630.1n

.meas tran Vdout1_57ck43 AVG v(dout1_57) FROM=629.9n TO=630.1n

.meas tran Vdout1_58ck43 AVG v(dout1_58) FROM=629.9n TO=630.1n

.meas tran Vdout1_59ck43 AVG v(dout1_59) FROM=629.9n TO=630.1n

.meas tran Vdout1_60ck43 AVG v(dout1_60) FROM=629.9n TO=630.1n

.meas tran Vdout1_61ck43 AVG v(dout1_61) FROM=629.9n TO=630.1n

.meas tran Vdout1_62ck43 AVG v(dout1_62) FROM=629.9n TO=630.1n

.meas tran Vdout1_63ck43 AVG v(dout1_63) FROM=629.9n TO=630.1n

.meas tran Vdout1_64ck43 AVG v(dout1_64) FROM=629.9n TO=630.1n

.meas tran Vdout1_65ck43 AVG v(dout1_65) FROM=629.9n TO=630.1n

.meas tran Vdout1_66ck43 AVG v(dout1_66) FROM=629.9n TO=630.1n

.meas tran Vdout1_67ck43 AVG v(dout1_67) FROM=629.9n TO=630.1n

.meas tran Vdout1_68ck43 AVG v(dout1_68) FROM=629.9n TO=630.1n

.meas tran Vdout1_69ck43 AVG v(dout1_69) FROM=629.9n TO=630.1n

.meas tran Vdout1_70ck43 AVG v(dout1_70) FROM=629.9n TO=630.1n

.meas tran Vdout1_71ck43 AVG v(dout1_71) FROM=629.9n TO=630.1n

.meas tran Vdout1_72ck43 AVG v(dout1_72) FROM=629.9n TO=630.1n

.meas tran Vdout1_73ck43 AVG v(dout1_73) FROM=629.9n TO=630.1n

.meas tran Vdout1_74ck43 AVG v(dout1_74) FROM=629.9n TO=630.1n

.meas tran Vdout1_75ck43 AVG v(dout1_75) FROM=629.9n TO=630.1n

.meas tran Vdout1_76ck43 AVG v(dout1_76) FROM=629.9n TO=630.1n

.meas tran Vdout1_77ck43 AVG v(dout1_77) FROM=629.9n TO=630.1n

.meas tran Vdout1_78ck43 AVG v(dout1_78) FROM=629.9n TO=630.1n

.meas tran Vdout1_79ck43 AVG v(dout1_79) FROM=629.9n TO=630.1n

.meas tran Vdout0_0ck44 AVG v(dout0_0) FROM=649.9n TO=650.1n

.meas tran Vdout0_1ck44 AVG v(dout0_1) FROM=649.9n TO=650.1n

.meas tran Vdout0_2ck44 AVG v(dout0_2) FROM=649.9n TO=650.1n

.meas tran Vdout0_3ck44 AVG v(dout0_3) FROM=649.9n TO=650.1n

.meas tran Vdout0_4ck44 AVG v(dout0_4) FROM=649.9n TO=650.1n

.meas tran Vdout0_5ck44 AVG v(dout0_5) FROM=649.9n TO=650.1n

.meas tran Vdout0_6ck44 AVG v(dout0_6) FROM=649.9n TO=650.1n

.meas tran Vdout0_7ck44 AVG v(dout0_7) FROM=649.9n TO=650.1n

.meas tran Vdout0_8ck44 AVG v(dout0_8) FROM=649.9n TO=650.1n

.meas tran Vdout0_9ck44 AVG v(dout0_9) FROM=649.9n TO=650.1n

.meas tran Vdout0_10ck44 AVG v(dout0_10) FROM=649.9n TO=650.1n

.meas tran Vdout0_11ck44 AVG v(dout0_11) FROM=649.9n TO=650.1n

.meas tran Vdout0_12ck44 AVG v(dout0_12) FROM=649.9n TO=650.1n

.meas tran Vdout0_13ck44 AVG v(dout0_13) FROM=649.9n TO=650.1n

.meas tran Vdout0_14ck44 AVG v(dout0_14) FROM=649.9n TO=650.1n

.meas tran Vdout0_15ck44 AVG v(dout0_15) FROM=649.9n TO=650.1n

.meas tran Vdout0_16ck44 AVG v(dout0_16) FROM=649.9n TO=650.1n

.meas tran Vdout0_17ck44 AVG v(dout0_17) FROM=649.9n TO=650.1n

.meas tran Vdout0_18ck44 AVG v(dout0_18) FROM=649.9n TO=650.1n

.meas tran Vdout0_19ck44 AVG v(dout0_19) FROM=649.9n TO=650.1n

.meas tran Vdout0_20ck44 AVG v(dout0_20) FROM=649.9n TO=650.1n

.meas tran Vdout0_21ck44 AVG v(dout0_21) FROM=649.9n TO=650.1n

.meas tran Vdout0_22ck44 AVG v(dout0_22) FROM=649.9n TO=650.1n

.meas tran Vdout0_23ck44 AVG v(dout0_23) FROM=649.9n TO=650.1n

.meas tran Vdout0_24ck44 AVG v(dout0_24) FROM=649.9n TO=650.1n

.meas tran Vdout0_25ck44 AVG v(dout0_25) FROM=649.9n TO=650.1n

.meas tran Vdout0_26ck44 AVG v(dout0_26) FROM=649.9n TO=650.1n

.meas tran Vdout0_27ck44 AVG v(dout0_27) FROM=649.9n TO=650.1n

.meas tran Vdout0_28ck44 AVG v(dout0_28) FROM=649.9n TO=650.1n

.meas tran Vdout0_29ck44 AVG v(dout0_29) FROM=649.9n TO=650.1n

.meas tran Vdout0_30ck44 AVG v(dout0_30) FROM=649.9n TO=650.1n

.meas tran Vdout0_31ck44 AVG v(dout0_31) FROM=649.9n TO=650.1n

.meas tran Vdout0_32ck44 AVG v(dout0_32) FROM=649.9n TO=650.1n

.meas tran Vdout0_33ck44 AVG v(dout0_33) FROM=649.9n TO=650.1n

.meas tran Vdout0_34ck44 AVG v(dout0_34) FROM=649.9n TO=650.1n

.meas tran Vdout0_35ck44 AVG v(dout0_35) FROM=649.9n TO=650.1n

.meas tran Vdout0_36ck44 AVG v(dout0_36) FROM=649.9n TO=650.1n

.meas tran Vdout0_37ck44 AVG v(dout0_37) FROM=649.9n TO=650.1n

.meas tran Vdout0_38ck44 AVG v(dout0_38) FROM=649.9n TO=650.1n

.meas tran Vdout0_39ck44 AVG v(dout0_39) FROM=649.9n TO=650.1n

.meas tran Vdout0_40ck44 AVG v(dout0_40) FROM=649.9n TO=650.1n

.meas tran Vdout0_41ck44 AVG v(dout0_41) FROM=649.9n TO=650.1n

.meas tran Vdout0_42ck44 AVG v(dout0_42) FROM=649.9n TO=650.1n

.meas tran Vdout0_43ck44 AVG v(dout0_43) FROM=649.9n TO=650.1n

.meas tran Vdout0_44ck44 AVG v(dout0_44) FROM=649.9n TO=650.1n

.meas tran Vdout0_45ck44 AVG v(dout0_45) FROM=649.9n TO=650.1n

.meas tran Vdout0_46ck44 AVG v(dout0_46) FROM=649.9n TO=650.1n

.meas tran Vdout0_47ck44 AVG v(dout0_47) FROM=649.9n TO=650.1n

.meas tran Vdout0_48ck44 AVG v(dout0_48) FROM=649.9n TO=650.1n

.meas tran Vdout0_49ck44 AVG v(dout0_49) FROM=649.9n TO=650.1n

.meas tran Vdout0_50ck44 AVG v(dout0_50) FROM=649.9n TO=650.1n

.meas tran Vdout0_51ck44 AVG v(dout0_51) FROM=649.9n TO=650.1n

.meas tran Vdout0_52ck44 AVG v(dout0_52) FROM=649.9n TO=650.1n

.meas tran Vdout0_53ck44 AVG v(dout0_53) FROM=649.9n TO=650.1n

.meas tran Vdout0_54ck44 AVG v(dout0_54) FROM=649.9n TO=650.1n

.meas tran Vdout0_55ck44 AVG v(dout0_55) FROM=649.9n TO=650.1n

.meas tran Vdout0_56ck44 AVG v(dout0_56) FROM=649.9n TO=650.1n

.meas tran Vdout0_57ck44 AVG v(dout0_57) FROM=649.9n TO=650.1n

.meas tran Vdout0_58ck44 AVG v(dout0_58) FROM=649.9n TO=650.1n

.meas tran Vdout0_59ck44 AVG v(dout0_59) FROM=649.9n TO=650.1n

.meas tran Vdout0_60ck44 AVG v(dout0_60) FROM=649.9n TO=650.1n

.meas tran Vdout0_61ck44 AVG v(dout0_61) FROM=649.9n TO=650.1n

.meas tran Vdout0_62ck44 AVG v(dout0_62) FROM=649.9n TO=650.1n

.meas tran Vdout0_63ck44 AVG v(dout0_63) FROM=649.9n TO=650.1n

.meas tran Vdout0_64ck44 AVG v(dout0_64) FROM=649.9n TO=650.1n

.meas tran Vdout0_65ck44 AVG v(dout0_65) FROM=649.9n TO=650.1n

.meas tran Vdout0_66ck44 AVG v(dout0_66) FROM=649.9n TO=650.1n

.meas tran Vdout0_67ck44 AVG v(dout0_67) FROM=649.9n TO=650.1n

.meas tran Vdout0_68ck44 AVG v(dout0_68) FROM=649.9n TO=650.1n

.meas tran Vdout0_69ck44 AVG v(dout0_69) FROM=649.9n TO=650.1n

.meas tran Vdout0_70ck44 AVG v(dout0_70) FROM=649.9n TO=650.1n

.meas tran Vdout0_71ck44 AVG v(dout0_71) FROM=649.9n TO=650.1n

.meas tran Vdout0_72ck44 AVG v(dout0_72) FROM=649.9n TO=650.1n

.meas tran Vdout0_73ck44 AVG v(dout0_73) FROM=649.9n TO=650.1n

.meas tran Vdout0_74ck44 AVG v(dout0_74) FROM=649.9n TO=650.1n

.meas tran Vdout0_75ck44 AVG v(dout0_75) FROM=649.9n TO=650.1n

.meas tran Vdout0_76ck44 AVG v(dout0_76) FROM=649.9n TO=650.1n

.meas tran Vdout0_77ck44 AVG v(dout0_77) FROM=649.9n TO=650.1n

.meas tran Vdout0_78ck44 AVG v(dout0_78) FROM=649.9n TO=650.1n

.meas tran Vdout0_79ck44 AVG v(dout0_79) FROM=649.9n TO=650.1n

.meas tran Vdout1_0ck45 AVG v(dout1_0) FROM=669.9n TO=670.1n

.meas tran Vdout1_1ck45 AVG v(dout1_1) FROM=669.9n TO=670.1n

.meas tran Vdout1_2ck45 AVG v(dout1_2) FROM=669.9n TO=670.1n

.meas tran Vdout1_3ck45 AVG v(dout1_3) FROM=669.9n TO=670.1n

.meas tran Vdout1_4ck45 AVG v(dout1_4) FROM=669.9n TO=670.1n

.meas tran Vdout1_5ck45 AVG v(dout1_5) FROM=669.9n TO=670.1n

.meas tran Vdout1_6ck45 AVG v(dout1_6) FROM=669.9n TO=670.1n

.meas tran Vdout1_7ck45 AVG v(dout1_7) FROM=669.9n TO=670.1n

.meas tran Vdout1_8ck45 AVG v(dout1_8) FROM=669.9n TO=670.1n

.meas tran Vdout1_9ck45 AVG v(dout1_9) FROM=669.9n TO=670.1n

.meas tran Vdout1_10ck45 AVG v(dout1_10) FROM=669.9n TO=670.1n

.meas tran Vdout1_11ck45 AVG v(dout1_11) FROM=669.9n TO=670.1n

.meas tran Vdout1_12ck45 AVG v(dout1_12) FROM=669.9n TO=670.1n

.meas tran Vdout1_13ck45 AVG v(dout1_13) FROM=669.9n TO=670.1n

.meas tran Vdout1_14ck45 AVG v(dout1_14) FROM=669.9n TO=670.1n

.meas tran Vdout1_15ck45 AVG v(dout1_15) FROM=669.9n TO=670.1n

.meas tran Vdout1_16ck45 AVG v(dout1_16) FROM=669.9n TO=670.1n

.meas tran Vdout1_17ck45 AVG v(dout1_17) FROM=669.9n TO=670.1n

.meas tran Vdout1_18ck45 AVG v(dout1_18) FROM=669.9n TO=670.1n

.meas tran Vdout1_19ck45 AVG v(dout1_19) FROM=669.9n TO=670.1n

.meas tran Vdout1_20ck45 AVG v(dout1_20) FROM=669.9n TO=670.1n

.meas tran Vdout1_21ck45 AVG v(dout1_21) FROM=669.9n TO=670.1n

.meas tran Vdout1_22ck45 AVG v(dout1_22) FROM=669.9n TO=670.1n

.meas tran Vdout1_23ck45 AVG v(dout1_23) FROM=669.9n TO=670.1n

.meas tran Vdout1_24ck45 AVG v(dout1_24) FROM=669.9n TO=670.1n

.meas tran Vdout1_25ck45 AVG v(dout1_25) FROM=669.9n TO=670.1n

.meas tran Vdout1_26ck45 AVG v(dout1_26) FROM=669.9n TO=670.1n

.meas tran Vdout1_27ck45 AVG v(dout1_27) FROM=669.9n TO=670.1n

.meas tran Vdout1_28ck45 AVG v(dout1_28) FROM=669.9n TO=670.1n

.meas tran Vdout1_29ck45 AVG v(dout1_29) FROM=669.9n TO=670.1n

.meas tran Vdout1_30ck45 AVG v(dout1_30) FROM=669.9n TO=670.1n

.meas tran Vdout1_31ck45 AVG v(dout1_31) FROM=669.9n TO=670.1n

.meas tran Vdout1_32ck45 AVG v(dout1_32) FROM=669.9n TO=670.1n

.meas tran Vdout1_33ck45 AVG v(dout1_33) FROM=669.9n TO=670.1n

.meas tran Vdout1_34ck45 AVG v(dout1_34) FROM=669.9n TO=670.1n

.meas tran Vdout1_35ck45 AVG v(dout1_35) FROM=669.9n TO=670.1n

.meas tran Vdout1_36ck45 AVG v(dout1_36) FROM=669.9n TO=670.1n

.meas tran Vdout1_37ck45 AVG v(dout1_37) FROM=669.9n TO=670.1n

.meas tran Vdout1_38ck45 AVG v(dout1_38) FROM=669.9n TO=670.1n

.meas tran Vdout1_39ck45 AVG v(dout1_39) FROM=669.9n TO=670.1n

.meas tran Vdout1_40ck45 AVG v(dout1_40) FROM=669.9n TO=670.1n

.meas tran Vdout1_41ck45 AVG v(dout1_41) FROM=669.9n TO=670.1n

.meas tran Vdout1_42ck45 AVG v(dout1_42) FROM=669.9n TO=670.1n

.meas tran Vdout1_43ck45 AVG v(dout1_43) FROM=669.9n TO=670.1n

.meas tran Vdout1_44ck45 AVG v(dout1_44) FROM=669.9n TO=670.1n

.meas tran Vdout1_45ck45 AVG v(dout1_45) FROM=669.9n TO=670.1n

.meas tran Vdout1_46ck45 AVG v(dout1_46) FROM=669.9n TO=670.1n

.meas tran Vdout1_47ck45 AVG v(dout1_47) FROM=669.9n TO=670.1n

.meas tran Vdout1_48ck45 AVG v(dout1_48) FROM=669.9n TO=670.1n

.meas tran Vdout1_49ck45 AVG v(dout1_49) FROM=669.9n TO=670.1n

.meas tran Vdout1_50ck45 AVG v(dout1_50) FROM=669.9n TO=670.1n

.meas tran Vdout1_51ck45 AVG v(dout1_51) FROM=669.9n TO=670.1n

.meas tran Vdout1_52ck45 AVG v(dout1_52) FROM=669.9n TO=670.1n

.meas tran Vdout1_53ck45 AVG v(dout1_53) FROM=669.9n TO=670.1n

.meas tran Vdout1_54ck45 AVG v(dout1_54) FROM=669.9n TO=670.1n

.meas tran Vdout1_55ck45 AVG v(dout1_55) FROM=669.9n TO=670.1n

.meas tran Vdout1_56ck45 AVG v(dout1_56) FROM=669.9n TO=670.1n

.meas tran Vdout1_57ck45 AVG v(dout1_57) FROM=669.9n TO=670.1n

.meas tran Vdout1_58ck45 AVG v(dout1_58) FROM=669.9n TO=670.1n

.meas tran Vdout1_59ck45 AVG v(dout1_59) FROM=669.9n TO=670.1n

.meas tran Vdout1_60ck45 AVG v(dout1_60) FROM=669.9n TO=670.1n

.meas tran Vdout1_61ck45 AVG v(dout1_61) FROM=669.9n TO=670.1n

.meas tran Vdout1_62ck45 AVG v(dout1_62) FROM=669.9n TO=670.1n

.meas tran Vdout1_63ck45 AVG v(dout1_63) FROM=669.9n TO=670.1n

.meas tran Vdout1_64ck45 AVG v(dout1_64) FROM=669.9n TO=670.1n

.meas tran Vdout1_65ck45 AVG v(dout1_65) FROM=669.9n TO=670.1n

.meas tran Vdout1_66ck45 AVG v(dout1_66) FROM=669.9n TO=670.1n

.meas tran Vdout1_67ck45 AVG v(dout1_67) FROM=669.9n TO=670.1n

.meas tran Vdout1_68ck45 AVG v(dout1_68) FROM=669.9n TO=670.1n

.meas tran Vdout1_69ck45 AVG v(dout1_69) FROM=669.9n TO=670.1n

.meas tran Vdout1_70ck45 AVG v(dout1_70) FROM=669.9n TO=670.1n

.meas tran Vdout1_71ck45 AVG v(dout1_71) FROM=669.9n TO=670.1n

.meas tran Vdout1_72ck45 AVG v(dout1_72) FROM=669.9n TO=670.1n

.meas tran Vdout1_73ck45 AVG v(dout1_73) FROM=669.9n TO=670.1n

.meas tran Vdout1_74ck45 AVG v(dout1_74) FROM=669.9n TO=670.1n

.meas tran Vdout1_75ck45 AVG v(dout1_75) FROM=669.9n TO=670.1n

.meas tran Vdout1_76ck45 AVG v(dout1_76) FROM=669.9n TO=670.1n

.meas tran Vdout1_77ck45 AVG v(dout1_77) FROM=669.9n TO=670.1n

.meas tran Vdout1_78ck45 AVG v(dout1_78) FROM=669.9n TO=670.1n

.meas tran Vdout1_79ck45 AVG v(dout1_79) FROM=669.9n TO=670.1n

.meas tran Vdout1_0ck46 AVG v(dout1_0) FROM=689.9n TO=690.1n

.meas tran Vdout1_1ck46 AVG v(dout1_1) FROM=689.9n TO=690.1n

.meas tran Vdout1_2ck46 AVG v(dout1_2) FROM=689.9n TO=690.1n

.meas tran Vdout1_3ck46 AVG v(dout1_3) FROM=689.9n TO=690.1n

.meas tran Vdout1_4ck46 AVG v(dout1_4) FROM=689.9n TO=690.1n

.meas tran Vdout1_5ck46 AVG v(dout1_5) FROM=689.9n TO=690.1n

.meas tran Vdout1_6ck46 AVG v(dout1_6) FROM=689.9n TO=690.1n

.meas tran Vdout1_7ck46 AVG v(dout1_7) FROM=689.9n TO=690.1n

.meas tran Vdout1_8ck46 AVG v(dout1_8) FROM=689.9n TO=690.1n

.meas tran Vdout1_9ck46 AVG v(dout1_9) FROM=689.9n TO=690.1n

.meas tran Vdout1_10ck46 AVG v(dout1_10) FROM=689.9n TO=690.1n

.meas tran Vdout1_11ck46 AVG v(dout1_11) FROM=689.9n TO=690.1n

.meas tran Vdout1_12ck46 AVG v(dout1_12) FROM=689.9n TO=690.1n

.meas tran Vdout1_13ck46 AVG v(dout1_13) FROM=689.9n TO=690.1n

.meas tran Vdout1_14ck46 AVG v(dout1_14) FROM=689.9n TO=690.1n

.meas tran Vdout1_15ck46 AVG v(dout1_15) FROM=689.9n TO=690.1n

.meas tran Vdout1_16ck46 AVG v(dout1_16) FROM=689.9n TO=690.1n

.meas tran Vdout1_17ck46 AVG v(dout1_17) FROM=689.9n TO=690.1n

.meas tran Vdout1_18ck46 AVG v(dout1_18) FROM=689.9n TO=690.1n

.meas tran Vdout1_19ck46 AVG v(dout1_19) FROM=689.9n TO=690.1n

.meas tran Vdout1_20ck46 AVG v(dout1_20) FROM=689.9n TO=690.1n

.meas tran Vdout1_21ck46 AVG v(dout1_21) FROM=689.9n TO=690.1n

.meas tran Vdout1_22ck46 AVG v(dout1_22) FROM=689.9n TO=690.1n

.meas tran Vdout1_23ck46 AVG v(dout1_23) FROM=689.9n TO=690.1n

.meas tran Vdout1_24ck46 AVG v(dout1_24) FROM=689.9n TO=690.1n

.meas tran Vdout1_25ck46 AVG v(dout1_25) FROM=689.9n TO=690.1n

.meas tran Vdout1_26ck46 AVG v(dout1_26) FROM=689.9n TO=690.1n

.meas tran Vdout1_27ck46 AVG v(dout1_27) FROM=689.9n TO=690.1n

.meas tran Vdout1_28ck46 AVG v(dout1_28) FROM=689.9n TO=690.1n

.meas tran Vdout1_29ck46 AVG v(dout1_29) FROM=689.9n TO=690.1n

.meas tran Vdout1_30ck46 AVG v(dout1_30) FROM=689.9n TO=690.1n

.meas tran Vdout1_31ck46 AVG v(dout1_31) FROM=689.9n TO=690.1n

.meas tran Vdout1_32ck46 AVG v(dout1_32) FROM=689.9n TO=690.1n

.meas tran Vdout1_33ck46 AVG v(dout1_33) FROM=689.9n TO=690.1n

.meas tran Vdout1_34ck46 AVG v(dout1_34) FROM=689.9n TO=690.1n

.meas tran Vdout1_35ck46 AVG v(dout1_35) FROM=689.9n TO=690.1n

.meas tran Vdout1_36ck46 AVG v(dout1_36) FROM=689.9n TO=690.1n

.meas tran Vdout1_37ck46 AVG v(dout1_37) FROM=689.9n TO=690.1n

.meas tran Vdout1_38ck46 AVG v(dout1_38) FROM=689.9n TO=690.1n

.meas tran Vdout1_39ck46 AVG v(dout1_39) FROM=689.9n TO=690.1n

.meas tran Vdout1_40ck46 AVG v(dout1_40) FROM=689.9n TO=690.1n

.meas tran Vdout1_41ck46 AVG v(dout1_41) FROM=689.9n TO=690.1n

.meas tran Vdout1_42ck46 AVG v(dout1_42) FROM=689.9n TO=690.1n

.meas tran Vdout1_43ck46 AVG v(dout1_43) FROM=689.9n TO=690.1n

.meas tran Vdout1_44ck46 AVG v(dout1_44) FROM=689.9n TO=690.1n

.meas tran Vdout1_45ck46 AVG v(dout1_45) FROM=689.9n TO=690.1n

.meas tran Vdout1_46ck46 AVG v(dout1_46) FROM=689.9n TO=690.1n

.meas tran Vdout1_47ck46 AVG v(dout1_47) FROM=689.9n TO=690.1n

.meas tran Vdout1_48ck46 AVG v(dout1_48) FROM=689.9n TO=690.1n

.meas tran Vdout1_49ck46 AVG v(dout1_49) FROM=689.9n TO=690.1n

.meas tran Vdout1_50ck46 AVG v(dout1_50) FROM=689.9n TO=690.1n

.meas tran Vdout1_51ck46 AVG v(dout1_51) FROM=689.9n TO=690.1n

.meas tran Vdout1_52ck46 AVG v(dout1_52) FROM=689.9n TO=690.1n

.meas tran Vdout1_53ck46 AVG v(dout1_53) FROM=689.9n TO=690.1n

.meas tran Vdout1_54ck46 AVG v(dout1_54) FROM=689.9n TO=690.1n

.meas tran Vdout1_55ck46 AVG v(dout1_55) FROM=689.9n TO=690.1n

.meas tran Vdout1_56ck46 AVG v(dout1_56) FROM=689.9n TO=690.1n

.meas tran Vdout1_57ck46 AVG v(dout1_57) FROM=689.9n TO=690.1n

.meas tran Vdout1_58ck46 AVG v(dout1_58) FROM=689.9n TO=690.1n

.meas tran Vdout1_59ck46 AVG v(dout1_59) FROM=689.9n TO=690.1n

.meas tran Vdout1_60ck46 AVG v(dout1_60) FROM=689.9n TO=690.1n

.meas tran Vdout1_61ck46 AVG v(dout1_61) FROM=689.9n TO=690.1n

.meas tran Vdout1_62ck46 AVG v(dout1_62) FROM=689.9n TO=690.1n

.meas tran Vdout1_63ck46 AVG v(dout1_63) FROM=689.9n TO=690.1n

.meas tran Vdout1_64ck46 AVG v(dout1_64) FROM=689.9n TO=690.1n

.meas tran Vdout1_65ck46 AVG v(dout1_65) FROM=689.9n TO=690.1n

.meas tran Vdout1_66ck46 AVG v(dout1_66) FROM=689.9n TO=690.1n

.meas tran Vdout1_67ck46 AVG v(dout1_67) FROM=689.9n TO=690.1n

.meas tran Vdout1_68ck46 AVG v(dout1_68) FROM=689.9n TO=690.1n

.meas tran Vdout1_69ck46 AVG v(dout1_69) FROM=689.9n TO=690.1n

.meas tran Vdout1_70ck46 AVG v(dout1_70) FROM=689.9n TO=690.1n

.meas tran Vdout1_71ck46 AVG v(dout1_71) FROM=689.9n TO=690.1n

.meas tran Vdout1_72ck46 AVG v(dout1_72) FROM=689.9n TO=690.1n

.meas tran Vdout1_73ck46 AVG v(dout1_73) FROM=689.9n TO=690.1n

.meas tran Vdout1_74ck46 AVG v(dout1_74) FROM=689.9n TO=690.1n

.meas tran Vdout1_75ck46 AVG v(dout1_75) FROM=689.9n TO=690.1n

.meas tran Vdout1_76ck46 AVG v(dout1_76) FROM=689.9n TO=690.1n

.meas tran Vdout1_77ck46 AVG v(dout1_77) FROM=689.9n TO=690.1n

.meas tran Vdout1_78ck46 AVG v(dout1_78) FROM=689.9n TO=690.1n

.meas tran Vdout1_79ck46 AVG v(dout1_79) FROM=689.9n TO=690.1n

.meas tran Vdout0_0ck47 AVG v(dout0_0) FROM=699.9n TO=700.1n

.meas tran Vdout0_1ck47 AVG v(dout0_1) FROM=699.9n TO=700.1n

.meas tran Vdout0_2ck47 AVG v(dout0_2) FROM=699.9n TO=700.1n

.meas tran Vdout0_3ck47 AVG v(dout0_3) FROM=699.9n TO=700.1n

.meas tran Vdout0_4ck47 AVG v(dout0_4) FROM=699.9n TO=700.1n

.meas tran Vdout0_5ck47 AVG v(dout0_5) FROM=699.9n TO=700.1n

.meas tran Vdout0_6ck47 AVG v(dout0_6) FROM=699.9n TO=700.1n

.meas tran Vdout0_7ck47 AVG v(dout0_7) FROM=699.9n TO=700.1n

.meas tran Vdout0_8ck47 AVG v(dout0_8) FROM=699.9n TO=700.1n

.meas tran Vdout0_9ck47 AVG v(dout0_9) FROM=699.9n TO=700.1n

.meas tran Vdout0_10ck47 AVG v(dout0_10) FROM=699.9n TO=700.1n

.meas tran Vdout0_11ck47 AVG v(dout0_11) FROM=699.9n TO=700.1n

.meas tran Vdout0_12ck47 AVG v(dout0_12) FROM=699.9n TO=700.1n

.meas tran Vdout0_13ck47 AVG v(dout0_13) FROM=699.9n TO=700.1n

.meas tran Vdout0_14ck47 AVG v(dout0_14) FROM=699.9n TO=700.1n

.meas tran Vdout0_15ck47 AVG v(dout0_15) FROM=699.9n TO=700.1n

.meas tran Vdout0_16ck47 AVG v(dout0_16) FROM=699.9n TO=700.1n

.meas tran Vdout0_17ck47 AVG v(dout0_17) FROM=699.9n TO=700.1n

.meas tran Vdout0_18ck47 AVG v(dout0_18) FROM=699.9n TO=700.1n

.meas tran Vdout0_19ck47 AVG v(dout0_19) FROM=699.9n TO=700.1n

.meas tran Vdout0_20ck47 AVG v(dout0_20) FROM=699.9n TO=700.1n

.meas tran Vdout0_21ck47 AVG v(dout0_21) FROM=699.9n TO=700.1n

.meas tran Vdout0_22ck47 AVG v(dout0_22) FROM=699.9n TO=700.1n

.meas tran Vdout0_23ck47 AVG v(dout0_23) FROM=699.9n TO=700.1n

.meas tran Vdout0_24ck47 AVG v(dout0_24) FROM=699.9n TO=700.1n

.meas tran Vdout0_25ck47 AVG v(dout0_25) FROM=699.9n TO=700.1n

.meas tran Vdout0_26ck47 AVG v(dout0_26) FROM=699.9n TO=700.1n

.meas tran Vdout0_27ck47 AVG v(dout0_27) FROM=699.9n TO=700.1n

.meas tran Vdout0_28ck47 AVG v(dout0_28) FROM=699.9n TO=700.1n

.meas tran Vdout0_29ck47 AVG v(dout0_29) FROM=699.9n TO=700.1n

.meas tran Vdout0_30ck47 AVG v(dout0_30) FROM=699.9n TO=700.1n

.meas tran Vdout0_31ck47 AVG v(dout0_31) FROM=699.9n TO=700.1n

.meas tran Vdout0_32ck47 AVG v(dout0_32) FROM=699.9n TO=700.1n

.meas tran Vdout0_33ck47 AVG v(dout0_33) FROM=699.9n TO=700.1n

.meas tran Vdout0_34ck47 AVG v(dout0_34) FROM=699.9n TO=700.1n

.meas tran Vdout0_35ck47 AVG v(dout0_35) FROM=699.9n TO=700.1n

.meas tran Vdout0_36ck47 AVG v(dout0_36) FROM=699.9n TO=700.1n

.meas tran Vdout0_37ck47 AVG v(dout0_37) FROM=699.9n TO=700.1n

.meas tran Vdout0_38ck47 AVG v(dout0_38) FROM=699.9n TO=700.1n

.meas tran Vdout0_39ck47 AVG v(dout0_39) FROM=699.9n TO=700.1n

.meas tran Vdout0_40ck47 AVG v(dout0_40) FROM=699.9n TO=700.1n

.meas tran Vdout0_41ck47 AVG v(dout0_41) FROM=699.9n TO=700.1n

.meas tran Vdout0_42ck47 AVG v(dout0_42) FROM=699.9n TO=700.1n

.meas tran Vdout0_43ck47 AVG v(dout0_43) FROM=699.9n TO=700.1n

.meas tran Vdout0_44ck47 AVG v(dout0_44) FROM=699.9n TO=700.1n

.meas tran Vdout0_45ck47 AVG v(dout0_45) FROM=699.9n TO=700.1n

.meas tran Vdout0_46ck47 AVG v(dout0_46) FROM=699.9n TO=700.1n

.meas tran Vdout0_47ck47 AVG v(dout0_47) FROM=699.9n TO=700.1n

.meas tran Vdout0_48ck47 AVG v(dout0_48) FROM=699.9n TO=700.1n

.meas tran Vdout0_49ck47 AVG v(dout0_49) FROM=699.9n TO=700.1n

.meas tran Vdout0_50ck47 AVG v(dout0_50) FROM=699.9n TO=700.1n

.meas tran Vdout0_51ck47 AVG v(dout0_51) FROM=699.9n TO=700.1n

.meas tran Vdout0_52ck47 AVG v(dout0_52) FROM=699.9n TO=700.1n

.meas tran Vdout0_53ck47 AVG v(dout0_53) FROM=699.9n TO=700.1n

.meas tran Vdout0_54ck47 AVG v(dout0_54) FROM=699.9n TO=700.1n

.meas tran Vdout0_55ck47 AVG v(dout0_55) FROM=699.9n TO=700.1n

.meas tran Vdout0_56ck47 AVG v(dout0_56) FROM=699.9n TO=700.1n

.meas tran Vdout0_57ck47 AVG v(dout0_57) FROM=699.9n TO=700.1n

.meas tran Vdout0_58ck47 AVG v(dout0_58) FROM=699.9n TO=700.1n

.meas tran Vdout0_59ck47 AVG v(dout0_59) FROM=699.9n TO=700.1n

.meas tran Vdout0_60ck47 AVG v(dout0_60) FROM=699.9n TO=700.1n

.meas tran Vdout0_61ck47 AVG v(dout0_61) FROM=699.9n TO=700.1n

.meas tran Vdout0_62ck47 AVG v(dout0_62) FROM=699.9n TO=700.1n

.meas tran Vdout0_63ck47 AVG v(dout0_63) FROM=699.9n TO=700.1n

.meas tran Vdout0_64ck47 AVG v(dout0_64) FROM=699.9n TO=700.1n

.meas tran Vdout0_65ck47 AVG v(dout0_65) FROM=699.9n TO=700.1n

.meas tran Vdout0_66ck47 AVG v(dout0_66) FROM=699.9n TO=700.1n

.meas tran Vdout0_67ck47 AVG v(dout0_67) FROM=699.9n TO=700.1n

.meas tran Vdout0_68ck47 AVG v(dout0_68) FROM=699.9n TO=700.1n

.meas tran Vdout0_69ck47 AVG v(dout0_69) FROM=699.9n TO=700.1n

.meas tran Vdout0_70ck47 AVG v(dout0_70) FROM=699.9n TO=700.1n

.meas tran Vdout0_71ck47 AVG v(dout0_71) FROM=699.9n TO=700.1n

.meas tran Vdout0_72ck47 AVG v(dout0_72) FROM=699.9n TO=700.1n

.meas tran Vdout0_73ck47 AVG v(dout0_73) FROM=699.9n TO=700.1n

.meas tran Vdout0_74ck47 AVG v(dout0_74) FROM=699.9n TO=700.1n

.meas tran Vdout0_75ck47 AVG v(dout0_75) FROM=699.9n TO=700.1n

.meas tran Vdout0_76ck47 AVG v(dout0_76) FROM=699.9n TO=700.1n

.meas tran Vdout0_77ck47 AVG v(dout0_77) FROM=699.9n TO=700.1n

.meas tran Vdout0_78ck47 AVG v(dout0_78) FROM=699.9n TO=700.1n

.meas tran Vdout0_79ck47 AVG v(dout0_79) FROM=699.9n TO=700.1n

.meas tran Vdout1_0ck48 AVG v(dout1_0) FROM=699.9n TO=700.1n

.meas tran Vdout1_1ck48 AVG v(dout1_1) FROM=699.9n TO=700.1n

.meas tran Vdout1_2ck48 AVG v(dout1_2) FROM=699.9n TO=700.1n

.meas tran Vdout1_3ck48 AVG v(dout1_3) FROM=699.9n TO=700.1n

.meas tran Vdout1_4ck48 AVG v(dout1_4) FROM=699.9n TO=700.1n

.meas tran Vdout1_5ck48 AVG v(dout1_5) FROM=699.9n TO=700.1n

.meas tran Vdout1_6ck48 AVG v(dout1_6) FROM=699.9n TO=700.1n

.meas tran Vdout1_7ck48 AVG v(dout1_7) FROM=699.9n TO=700.1n

.meas tran Vdout1_8ck48 AVG v(dout1_8) FROM=699.9n TO=700.1n

.meas tran Vdout1_9ck48 AVG v(dout1_9) FROM=699.9n TO=700.1n

.meas tran Vdout1_10ck48 AVG v(dout1_10) FROM=699.9n TO=700.1n

.meas tran Vdout1_11ck48 AVG v(dout1_11) FROM=699.9n TO=700.1n

.meas tran Vdout1_12ck48 AVG v(dout1_12) FROM=699.9n TO=700.1n

.meas tran Vdout1_13ck48 AVG v(dout1_13) FROM=699.9n TO=700.1n

.meas tran Vdout1_14ck48 AVG v(dout1_14) FROM=699.9n TO=700.1n

.meas tran Vdout1_15ck48 AVG v(dout1_15) FROM=699.9n TO=700.1n

.meas tran Vdout1_16ck48 AVG v(dout1_16) FROM=699.9n TO=700.1n

.meas tran Vdout1_17ck48 AVG v(dout1_17) FROM=699.9n TO=700.1n

.meas tran Vdout1_18ck48 AVG v(dout1_18) FROM=699.9n TO=700.1n

.meas tran Vdout1_19ck48 AVG v(dout1_19) FROM=699.9n TO=700.1n

.meas tran Vdout1_20ck48 AVG v(dout1_20) FROM=699.9n TO=700.1n

.meas tran Vdout1_21ck48 AVG v(dout1_21) FROM=699.9n TO=700.1n

.meas tran Vdout1_22ck48 AVG v(dout1_22) FROM=699.9n TO=700.1n

.meas tran Vdout1_23ck48 AVG v(dout1_23) FROM=699.9n TO=700.1n

.meas tran Vdout1_24ck48 AVG v(dout1_24) FROM=699.9n TO=700.1n

.meas tran Vdout1_25ck48 AVG v(dout1_25) FROM=699.9n TO=700.1n

.meas tran Vdout1_26ck48 AVG v(dout1_26) FROM=699.9n TO=700.1n

.meas tran Vdout1_27ck48 AVG v(dout1_27) FROM=699.9n TO=700.1n

.meas tran Vdout1_28ck48 AVG v(dout1_28) FROM=699.9n TO=700.1n

.meas tran Vdout1_29ck48 AVG v(dout1_29) FROM=699.9n TO=700.1n

.meas tran Vdout1_30ck48 AVG v(dout1_30) FROM=699.9n TO=700.1n

.meas tran Vdout1_31ck48 AVG v(dout1_31) FROM=699.9n TO=700.1n

.meas tran Vdout1_32ck48 AVG v(dout1_32) FROM=699.9n TO=700.1n

.meas tran Vdout1_33ck48 AVG v(dout1_33) FROM=699.9n TO=700.1n

.meas tran Vdout1_34ck48 AVG v(dout1_34) FROM=699.9n TO=700.1n

.meas tran Vdout1_35ck48 AVG v(dout1_35) FROM=699.9n TO=700.1n

.meas tran Vdout1_36ck48 AVG v(dout1_36) FROM=699.9n TO=700.1n

.meas tran Vdout1_37ck48 AVG v(dout1_37) FROM=699.9n TO=700.1n

.meas tran Vdout1_38ck48 AVG v(dout1_38) FROM=699.9n TO=700.1n

.meas tran Vdout1_39ck48 AVG v(dout1_39) FROM=699.9n TO=700.1n

.meas tran Vdout1_40ck48 AVG v(dout1_40) FROM=699.9n TO=700.1n

.meas tran Vdout1_41ck48 AVG v(dout1_41) FROM=699.9n TO=700.1n

.meas tran Vdout1_42ck48 AVG v(dout1_42) FROM=699.9n TO=700.1n

.meas tran Vdout1_43ck48 AVG v(dout1_43) FROM=699.9n TO=700.1n

.meas tran Vdout1_44ck48 AVG v(dout1_44) FROM=699.9n TO=700.1n

.meas tran Vdout1_45ck48 AVG v(dout1_45) FROM=699.9n TO=700.1n

.meas tran Vdout1_46ck48 AVG v(dout1_46) FROM=699.9n TO=700.1n

.meas tran Vdout1_47ck48 AVG v(dout1_47) FROM=699.9n TO=700.1n

.meas tran Vdout1_48ck48 AVG v(dout1_48) FROM=699.9n TO=700.1n

.meas tran Vdout1_49ck48 AVG v(dout1_49) FROM=699.9n TO=700.1n

.meas tran Vdout1_50ck48 AVG v(dout1_50) FROM=699.9n TO=700.1n

.meas tran Vdout1_51ck48 AVG v(dout1_51) FROM=699.9n TO=700.1n

.meas tran Vdout1_52ck48 AVG v(dout1_52) FROM=699.9n TO=700.1n

.meas tran Vdout1_53ck48 AVG v(dout1_53) FROM=699.9n TO=700.1n

.meas tran Vdout1_54ck48 AVG v(dout1_54) FROM=699.9n TO=700.1n

.meas tran Vdout1_55ck48 AVG v(dout1_55) FROM=699.9n TO=700.1n

.meas tran Vdout1_56ck48 AVG v(dout1_56) FROM=699.9n TO=700.1n

.meas tran Vdout1_57ck48 AVG v(dout1_57) FROM=699.9n TO=700.1n

.meas tran Vdout1_58ck48 AVG v(dout1_58) FROM=699.9n TO=700.1n

.meas tran Vdout1_59ck48 AVG v(dout1_59) FROM=699.9n TO=700.1n

.meas tran Vdout1_60ck48 AVG v(dout1_60) FROM=699.9n TO=700.1n

.meas tran Vdout1_61ck48 AVG v(dout1_61) FROM=699.9n TO=700.1n

.meas tran Vdout1_62ck48 AVG v(dout1_62) FROM=699.9n TO=700.1n

.meas tran Vdout1_63ck48 AVG v(dout1_63) FROM=699.9n TO=700.1n

.meas tran Vdout1_64ck48 AVG v(dout1_64) FROM=699.9n TO=700.1n

.meas tran Vdout1_65ck48 AVG v(dout1_65) FROM=699.9n TO=700.1n

.meas tran Vdout1_66ck48 AVG v(dout1_66) FROM=699.9n TO=700.1n

.meas tran Vdout1_67ck48 AVG v(dout1_67) FROM=699.9n TO=700.1n

.meas tran Vdout1_68ck48 AVG v(dout1_68) FROM=699.9n TO=700.1n

.meas tran Vdout1_69ck48 AVG v(dout1_69) FROM=699.9n TO=700.1n

.meas tran Vdout1_70ck48 AVG v(dout1_70) FROM=699.9n TO=700.1n

.meas tran Vdout1_71ck48 AVG v(dout1_71) FROM=699.9n TO=700.1n

.meas tran Vdout1_72ck48 AVG v(dout1_72) FROM=699.9n TO=700.1n

.meas tran Vdout1_73ck48 AVG v(dout1_73) FROM=699.9n TO=700.1n

.meas tran Vdout1_74ck48 AVG v(dout1_74) FROM=699.9n TO=700.1n

.meas tran Vdout1_75ck48 AVG v(dout1_75) FROM=699.9n TO=700.1n

.meas tran Vdout1_76ck48 AVG v(dout1_76) FROM=699.9n TO=700.1n

.meas tran Vdout1_77ck48 AVG v(dout1_77) FROM=699.9n TO=700.1n

.meas tran Vdout1_78ck48 AVG v(dout1_78) FROM=699.9n TO=700.1n

.meas tran Vdout1_79ck48 AVG v(dout1_79) FROM=699.9n TO=700.1n

.meas tran Vdout0_0ck49 AVG v(dout0_0) FROM=709.9n TO=710.1n

.meas tran Vdout0_1ck49 AVG v(dout0_1) FROM=709.9n TO=710.1n

.meas tran Vdout0_2ck49 AVG v(dout0_2) FROM=709.9n TO=710.1n

.meas tran Vdout0_3ck49 AVG v(dout0_3) FROM=709.9n TO=710.1n

.meas tran Vdout0_4ck49 AVG v(dout0_4) FROM=709.9n TO=710.1n

.meas tran Vdout0_5ck49 AVG v(dout0_5) FROM=709.9n TO=710.1n

.meas tran Vdout0_6ck49 AVG v(dout0_6) FROM=709.9n TO=710.1n

.meas tran Vdout0_7ck49 AVG v(dout0_7) FROM=709.9n TO=710.1n

.meas tran Vdout0_8ck49 AVG v(dout0_8) FROM=709.9n TO=710.1n

.meas tran Vdout0_9ck49 AVG v(dout0_9) FROM=709.9n TO=710.1n

.meas tran Vdout0_10ck49 AVG v(dout0_10) FROM=709.9n TO=710.1n

.meas tran Vdout0_11ck49 AVG v(dout0_11) FROM=709.9n TO=710.1n

.meas tran Vdout0_12ck49 AVG v(dout0_12) FROM=709.9n TO=710.1n

.meas tran Vdout0_13ck49 AVG v(dout0_13) FROM=709.9n TO=710.1n

.meas tran Vdout0_14ck49 AVG v(dout0_14) FROM=709.9n TO=710.1n

.meas tran Vdout0_15ck49 AVG v(dout0_15) FROM=709.9n TO=710.1n

.meas tran Vdout0_16ck49 AVG v(dout0_16) FROM=709.9n TO=710.1n

.meas tran Vdout0_17ck49 AVG v(dout0_17) FROM=709.9n TO=710.1n

.meas tran Vdout0_18ck49 AVG v(dout0_18) FROM=709.9n TO=710.1n

.meas tran Vdout0_19ck49 AVG v(dout0_19) FROM=709.9n TO=710.1n

.meas tran Vdout0_20ck49 AVG v(dout0_20) FROM=709.9n TO=710.1n

.meas tran Vdout0_21ck49 AVG v(dout0_21) FROM=709.9n TO=710.1n

.meas tran Vdout0_22ck49 AVG v(dout0_22) FROM=709.9n TO=710.1n

.meas tran Vdout0_23ck49 AVG v(dout0_23) FROM=709.9n TO=710.1n

.meas tran Vdout0_24ck49 AVG v(dout0_24) FROM=709.9n TO=710.1n

.meas tran Vdout0_25ck49 AVG v(dout0_25) FROM=709.9n TO=710.1n

.meas tran Vdout0_26ck49 AVG v(dout0_26) FROM=709.9n TO=710.1n

.meas tran Vdout0_27ck49 AVG v(dout0_27) FROM=709.9n TO=710.1n

.meas tran Vdout0_28ck49 AVG v(dout0_28) FROM=709.9n TO=710.1n

.meas tran Vdout0_29ck49 AVG v(dout0_29) FROM=709.9n TO=710.1n

.meas tran Vdout0_30ck49 AVG v(dout0_30) FROM=709.9n TO=710.1n

.meas tran Vdout0_31ck49 AVG v(dout0_31) FROM=709.9n TO=710.1n

.meas tran Vdout0_32ck49 AVG v(dout0_32) FROM=709.9n TO=710.1n

.meas tran Vdout0_33ck49 AVG v(dout0_33) FROM=709.9n TO=710.1n

.meas tran Vdout0_34ck49 AVG v(dout0_34) FROM=709.9n TO=710.1n

.meas tran Vdout0_35ck49 AVG v(dout0_35) FROM=709.9n TO=710.1n

.meas tran Vdout0_36ck49 AVG v(dout0_36) FROM=709.9n TO=710.1n

.meas tran Vdout0_37ck49 AVG v(dout0_37) FROM=709.9n TO=710.1n

.meas tran Vdout0_38ck49 AVG v(dout0_38) FROM=709.9n TO=710.1n

.meas tran Vdout0_39ck49 AVG v(dout0_39) FROM=709.9n TO=710.1n

.meas tran Vdout0_40ck49 AVG v(dout0_40) FROM=709.9n TO=710.1n

.meas tran Vdout0_41ck49 AVG v(dout0_41) FROM=709.9n TO=710.1n

.meas tran Vdout0_42ck49 AVG v(dout0_42) FROM=709.9n TO=710.1n

.meas tran Vdout0_43ck49 AVG v(dout0_43) FROM=709.9n TO=710.1n

.meas tran Vdout0_44ck49 AVG v(dout0_44) FROM=709.9n TO=710.1n

.meas tran Vdout0_45ck49 AVG v(dout0_45) FROM=709.9n TO=710.1n

.meas tran Vdout0_46ck49 AVG v(dout0_46) FROM=709.9n TO=710.1n

.meas tran Vdout0_47ck49 AVG v(dout0_47) FROM=709.9n TO=710.1n

.meas tran Vdout0_48ck49 AVG v(dout0_48) FROM=709.9n TO=710.1n

.meas tran Vdout0_49ck49 AVG v(dout0_49) FROM=709.9n TO=710.1n

.meas tran Vdout0_50ck49 AVG v(dout0_50) FROM=709.9n TO=710.1n

.meas tran Vdout0_51ck49 AVG v(dout0_51) FROM=709.9n TO=710.1n

.meas tran Vdout0_52ck49 AVG v(dout0_52) FROM=709.9n TO=710.1n

.meas tran Vdout0_53ck49 AVG v(dout0_53) FROM=709.9n TO=710.1n

.meas tran Vdout0_54ck49 AVG v(dout0_54) FROM=709.9n TO=710.1n

.meas tran Vdout0_55ck49 AVG v(dout0_55) FROM=709.9n TO=710.1n

.meas tran Vdout0_56ck49 AVG v(dout0_56) FROM=709.9n TO=710.1n

.meas tran Vdout0_57ck49 AVG v(dout0_57) FROM=709.9n TO=710.1n

.meas tran Vdout0_58ck49 AVG v(dout0_58) FROM=709.9n TO=710.1n

.meas tran Vdout0_59ck49 AVG v(dout0_59) FROM=709.9n TO=710.1n

.meas tran Vdout0_60ck49 AVG v(dout0_60) FROM=709.9n TO=710.1n

.meas tran Vdout0_61ck49 AVG v(dout0_61) FROM=709.9n TO=710.1n

.meas tran Vdout0_62ck49 AVG v(dout0_62) FROM=709.9n TO=710.1n

.meas tran Vdout0_63ck49 AVG v(dout0_63) FROM=709.9n TO=710.1n

.meas tran Vdout0_64ck49 AVG v(dout0_64) FROM=709.9n TO=710.1n

.meas tran Vdout0_65ck49 AVG v(dout0_65) FROM=709.9n TO=710.1n

.meas tran Vdout0_66ck49 AVG v(dout0_66) FROM=709.9n TO=710.1n

.meas tran Vdout0_67ck49 AVG v(dout0_67) FROM=709.9n TO=710.1n

.meas tran Vdout0_68ck49 AVG v(dout0_68) FROM=709.9n TO=710.1n

.meas tran Vdout0_69ck49 AVG v(dout0_69) FROM=709.9n TO=710.1n

.meas tran Vdout0_70ck49 AVG v(dout0_70) FROM=709.9n TO=710.1n

.meas tran Vdout0_71ck49 AVG v(dout0_71) FROM=709.9n TO=710.1n

.meas tran Vdout0_72ck49 AVG v(dout0_72) FROM=709.9n TO=710.1n

.meas tran Vdout0_73ck49 AVG v(dout0_73) FROM=709.9n TO=710.1n

.meas tran Vdout0_74ck49 AVG v(dout0_74) FROM=709.9n TO=710.1n

.meas tran Vdout0_75ck49 AVG v(dout0_75) FROM=709.9n TO=710.1n

.meas tran Vdout0_76ck49 AVG v(dout0_76) FROM=709.9n TO=710.1n

.meas tran Vdout0_77ck49 AVG v(dout0_77) FROM=709.9n TO=710.1n

.meas tran Vdout0_78ck49 AVG v(dout0_78) FROM=709.9n TO=710.1n

.meas tran Vdout0_79ck49 AVG v(dout0_79) FROM=709.9n TO=710.1n

.meas tran Vdout1_0ck50 AVG v(dout1_0) FROM=709.9n TO=710.1n

.meas tran Vdout1_1ck50 AVG v(dout1_1) FROM=709.9n TO=710.1n

.meas tran Vdout1_2ck50 AVG v(dout1_2) FROM=709.9n TO=710.1n

.meas tran Vdout1_3ck50 AVG v(dout1_3) FROM=709.9n TO=710.1n

.meas tran Vdout1_4ck50 AVG v(dout1_4) FROM=709.9n TO=710.1n

.meas tran Vdout1_5ck50 AVG v(dout1_5) FROM=709.9n TO=710.1n

.meas tran Vdout1_6ck50 AVG v(dout1_6) FROM=709.9n TO=710.1n

.meas tran Vdout1_7ck50 AVG v(dout1_7) FROM=709.9n TO=710.1n

.meas tran Vdout1_8ck50 AVG v(dout1_8) FROM=709.9n TO=710.1n

.meas tran Vdout1_9ck50 AVG v(dout1_9) FROM=709.9n TO=710.1n

.meas tran Vdout1_10ck50 AVG v(dout1_10) FROM=709.9n TO=710.1n

.meas tran Vdout1_11ck50 AVG v(dout1_11) FROM=709.9n TO=710.1n

.meas tran Vdout1_12ck50 AVG v(dout1_12) FROM=709.9n TO=710.1n

.meas tran Vdout1_13ck50 AVG v(dout1_13) FROM=709.9n TO=710.1n

.meas tran Vdout1_14ck50 AVG v(dout1_14) FROM=709.9n TO=710.1n

.meas tran Vdout1_15ck50 AVG v(dout1_15) FROM=709.9n TO=710.1n

.meas tran Vdout1_16ck50 AVG v(dout1_16) FROM=709.9n TO=710.1n

.meas tran Vdout1_17ck50 AVG v(dout1_17) FROM=709.9n TO=710.1n

.meas tran Vdout1_18ck50 AVG v(dout1_18) FROM=709.9n TO=710.1n

.meas tran Vdout1_19ck50 AVG v(dout1_19) FROM=709.9n TO=710.1n

.meas tran Vdout1_20ck50 AVG v(dout1_20) FROM=709.9n TO=710.1n

.meas tran Vdout1_21ck50 AVG v(dout1_21) FROM=709.9n TO=710.1n

.meas tran Vdout1_22ck50 AVG v(dout1_22) FROM=709.9n TO=710.1n

.meas tran Vdout1_23ck50 AVG v(dout1_23) FROM=709.9n TO=710.1n

.meas tran Vdout1_24ck50 AVG v(dout1_24) FROM=709.9n TO=710.1n

.meas tran Vdout1_25ck50 AVG v(dout1_25) FROM=709.9n TO=710.1n

.meas tran Vdout1_26ck50 AVG v(dout1_26) FROM=709.9n TO=710.1n

.meas tran Vdout1_27ck50 AVG v(dout1_27) FROM=709.9n TO=710.1n

.meas tran Vdout1_28ck50 AVG v(dout1_28) FROM=709.9n TO=710.1n

.meas tran Vdout1_29ck50 AVG v(dout1_29) FROM=709.9n TO=710.1n

.meas tran Vdout1_30ck50 AVG v(dout1_30) FROM=709.9n TO=710.1n

.meas tran Vdout1_31ck50 AVG v(dout1_31) FROM=709.9n TO=710.1n

.meas tran Vdout1_32ck50 AVG v(dout1_32) FROM=709.9n TO=710.1n

.meas tran Vdout1_33ck50 AVG v(dout1_33) FROM=709.9n TO=710.1n

.meas tran Vdout1_34ck50 AVG v(dout1_34) FROM=709.9n TO=710.1n

.meas tran Vdout1_35ck50 AVG v(dout1_35) FROM=709.9n TO=710.1n

.meas tran Vdout1_36ck50 AVG v(dout1_36) FROM=709.9n TO=710.1n

.meas tran Vdout1_37ck50 AVG v(dout1_37) FROM=709.9n TO=710.1n

.meas tran Vdout1_38ck50 AVG v(dout1_38) FROM=709.9n TO=710.1n

.meas tran Vdout1_39ck50 AVG v(dout1_39) FROM=709.9n TO=710.1n

.meas tran Vdout1_40ck50 AVG v(dout1_40) FROM=709.9n TO=710.1n

.meas tran Vdout1_41ck50 AVG v(dout1_41) FROM=709.9n TO=710.1n

.meas tran Vdout1_42ck50 AVG v(dout1_42) FROM=709.9n TO=710.1n

.meas tran Vdout1_43ck50 AVG v(dout1_43) FROM=709.9n TO=710.1n

.meas tran Vdout1_44ck50 AVG v(dout1_44) FROM=709.9n TO=710.1n

.meas tran Vdout1_45ck50 AVG v(dout1_45) FROM=709.9n TO=710.1n

.meas tran Vdout1_46ck50 AVG v(dout1_46) FROM=709.9n TO=710.1n

.meas tran Vdout1_47ck50 AVG v(dout1_47) FROM=709.9n TO=710.1n

.meas tran Vdout1_48ck50 AVG v(dout1_48) FROM=709.9n TO=710.1n

.meas tran Vdout1_49ck50 AVG v(dout1_49) FROM=709.9n TO=710.1n

.meas tran Vdout1_50ck50 AVG v(dout1_50) FROM=709.9n TO=710.1n

.meas tran Vdout1_51ck50 AVG v(dout1_51) FROM=709.9n TO=710.1n

.meas tran Vdout1_52ck50 AVG v(dout1_52) FROM=709.9n TO=710.1n

.meas tran Vdout1_53ck50 AVG v(dout1_53) FROM=709.9n TO=710.1n

.meas tran Vdout1_54ck50 AVG v(dout1_54) FROM=709.9n TO=710.1n

.meas tran Vdout1_55ck50 AVG v(dout1_55) FROM=709.9n TO=710.1n

.meas tran Vdout1_56ck50 AVG v(dout1_56) FROM=709.9n TO=710.1n

.meas tran Vdout1_57ck50 AVG v(dout1_57) FROM=709.9n TO=710.1n

.meas tran Vdout1_58ck50 AVG v(dout1_58) FROM=709.9n TO=710.1n

.meas tran Vdout1_59ck50 AVG v(dout1_59) FROM=709.9n TO=710.1n

.meas tran Vdout1_60ck50 AVG v(dout1_60) FROM=709.9n TO=710.1n

.meas tran Vdout1_61ck50 AVG v(dout1_61) FROM=709.9n TO=710.1n

.meas tran Vdout1_62ck50 AVG v(dout1_62) FROM=709.9n TO=710.1n

.meas tran Vdout1_63ck50 AVG v(dout1_63) FROM=709.9n TO=710.1n

.meas tran Vdout1_64ck50 AVG v(dout1_64) FROM=709.9n TO=710.1n

.meas tran Vdout1_65ck50 AVG v(dout1_65) FROM=709.9n TO=710.1n

.meas tran Vdout1_66ck50 AVG v(dout1_66) FROM=709.9n TO=710.1n

.meas tran Vdout1_67ck50 AVG v(dout1_67) FROM=709.9n TO=710.1n

.meas tran Vdout1_68ck50 AVG v(dout1_68) FROM=709.9n TO=710.1n

.meas tran Vdout1_69ck50 AVG v(dout1_69) FROM=709.9n TO=710.1n

.meas tran Vdout1_70ck50 AVG v(dout1_70) FROM=709.9n TO=710.1n

.meas tran Vdout1_71ck50 AVG v(dout1_71) FROM=709.9n TO=710.1n

.meas tran Vdout1_72ck50 AVG v(dout1_72) FROM=709.9n TO=710.1n

.meas tran Vdout1_73ck50 AVG v(dout1_73) FROM=709.9n TO=710.1n

.meas tran Vdout1_74ck50 AVG v(dout1_74) FROM=709.9n TO=710.1n

.meas tran Vdout1_75ck50 AVG v(dout1_75) FROM=709.9n TO=710.1n

.meas tran Vdout1_76ck50 AVG v(dout1_76) FROM=709.9n TO=710.1n

.meas tran Vdout1_77ck50 AVG v(dout1_77) FROM=709.9n TO=710.1n

.meas tran Vdout1_78ck50 AVG v(dout1_78) FROM=709.9n TO=710.1n

.meas tran Vdout1_79ck50 AVG v(dout1_79) FROM=709.9n TO=710.1n

.meas tran Vdout1_0ck51 AVG v(dout1_0) FROM=729.9n TO=730.1n

.meas tran Vdout1_1ck51 AVG v(dout1_1) FROM=729.9n TO=730.1n

.meas tran Vdout1_2ck51 AVG v(dout1_2) FROM=729.9n TO=730.1n

.meas tran Vdout1_3ck51 AVG v(dout1_3) FROM=729.9n TO=730.1n

.meas tran Vdout1_4ck51 AVG v(dout1_4) FROM=729.9n TO=730.1n

.meas tran Vdout1_5ck51 AVG v(dout1_5) FROM=729.9n TO=730.1n

.meas tran Vdout1_6ck51 AVG v(dout1_6) FROM=729.9n TO=730.1n

.meas tran Vdout1_7ck51 AVG v(dout1_7) FROM=729.9n TO=730.1n

.meas tran Vdout1_8ck51 AVG v(dout1_8) FROM=729.9n TO=730.1n

.meas tran Vdout1_9ck51 AVG v(dout1_9) FROM=729.9n TO=730.1n

.meas tran Vdout1_10ck51 AVG v(dout1_10) FROM=729.9n TO=730.1n

.meas tran Vdout1_11ck51 AVG v(dout1_11) FROM=729.9n TO=730.1n

.meas tran Vdout1_12ck51 AVG v(dout1_12) FROM=729.9n TO=730.1n

.meas tran Vdout1_13ck51 AVG v(dout1_13) FROM=729.9n TO=730.1n

.meas tran Vdout1_14ck51 AVG v(dout1_14) FROM=729.9n TO=730.1n

.meas tran Vdout1_15ck51 AVG v(dout1_15) FROM=729.9n TO=730.1n

.meas tran Vdout1_16ck51 AVG v(dout1_16) FROM=729.9n TO=730.1n

.meas tran Vdout1_17ck51 AVG v(dout1_17) FROM=729.9n TO=730.1n

.meas tran Vdout1_18ck51 AVG v(dout1_18) FROM=729.9n TO=730.1n

.meas tran Vdout1_19ck51 AVG v(dout1_19) FROM=729.9n TO=730.1n

.meas tran Vdout1_20ck51 AVG v(dout1_20) FROM=729.9n TO=730.1n

.meas tran Vdout1_21ck51 AVG v(dout1_21) FROM=729.9n TO=730.1n

.meas tran Vdout1_22ck51 AVG v(dout1_22) FROM=729.9n TO=730.1n

.meas tran Vdout1_23ck51 AVG v(dout1_23) FROM=729.9n TO=730.1n

.meas tran Vdout1_24ck51 AVG v(dout1_24) FROM=729.9n TO=730.1n

.meas tran Vdout1_25ck51 AVG v(dout1_25) FROM=729.9n TO=730.1n

.meas tran Vdout1_26ck51 AVG v(dout1_26) FROM=729.9n TO=730.1n

.meas tran Vdout1_27ck51 AVG v(dout1_27) FROM=729.9n TO=730.1n

.meas tran Vdout1_28ck51 AVG v(dout1_28) FROM=729.9n TO=730.1n

.meas tran Vdout1_29ck51 AVG v(dout1_29) FROM=729.9n TO=730.1n

.meas tran Vdout1_30ck51 AVG v(dout1_30) FROM=729.9n TO=730.1n

.meas tran Vdout1_31ck51 AVG v(dout1_31) FROM=729.9n TO=730.1n

.meas tran Vdout1_32ck51 AVG v(dout1_32) FROM=729.9n TO=730.1n

.meas tran Vdout1_33ck51 AVG v(dout1_33) FROM=729.9n TO=730.1n

.meas tran Vdout1_34ck51 AVG v(dout1_34) FROM=729.9n TO=730.1n

.meas tran Vdout1_35ck51 AVG v(dout1_35) FROM=729.9n TO=730.1n

.meas tran Vdout1_36ck51 AVG v(dout1_36) FROM=729.9n TO=730.1n

.meas tran Vdout1_37ck51 AVG v(dout1_37) FROM=729.9n TO=730.1n

.meas tran Vdout1_38ck51 AVG v(dout1_38) FROM=729.9n TO=730.1n

.meas tran Vdout1_39ck51 AVG v(dout1_39) FROM=729.9n TO=730.1n

.meas tran Vdout1_40ck51 AVG v(dout1_40) FROM=729.9n TO=730.1n

.meas tran Vdout1_41ck51 AVG v(dout1_41) FROM=729.9n TO=730.1n

.meas tran Vdout1_42ck51 AVG v(dout1_42) FROM=729.9n TO=730.1n

.meas tran Vdout1_43ck51 AVG v(dout1_43) FROM=729.9n TO=730.1n

.meas tran Vdout1_44ck51 AVG v(dout1_44) FROM=729.9n TO=730.1n

.meas tran Vdout1_45ck51 AVG v(dout1_45) FROM=729.9n TO=730.1n

.meas tran Vdout1_46ck51 AVG v(dout1_46) FROM=729.9n TO=730.1n

.meas tran Vdout1_47ck51 AVG v(dout1_47) FROM=729.9n TO=730.1n

.meas tran Vdout1_48ck51 AVG v(dout1_48) FROM=729.9n TO=730.1n

.meas tran Vdout1_49ck51 AVG v(dout1_49) FROM=729.9n TO=730.1n

.meas tran Vdout1_50ck51 AVG v(dout1_50) FROM=729.9n TO=730.1n

.meas tran Vdout1_51ck51 AVG v(dout1_51) FROM=729.9n TO=730.1n

.meas tran Vdout1_52ck51 AVG v(dout1_52) FROM=729.9n TO=730.1n

.meas tran Vdout1_53ck51 AVG v(dout1_53) FROM=729.9n TO=730.1n

.meas tran Vdout1_54ck51 AVG v(dout1_54) FROM=729.9n TO=730.1n

.meas tran Vdout1_55ck51 AVG v(dout1_55) FROM=729.9n TO=730.1n

.meas tran Vdout1_56ck51 AVG v(dout1_56) FROM=729.9n TO=730.1n

.meas tran Vdout1_57ck51 AVG v(dout1_57) FROM=729.9n TO=730.1n

.meas tran Vdout1_58ck51 AVG v(dout1_58) FROM=729.9n TO=730.1n

.meas tran Vdout1_59ck51 AVG v(dout1_59) FROM=729.9n TO=730.1n

.meas tran Vdout1_60ck51 AVG v(dout1_60) FROM=729.9n TO=730.1n

.meas tran Vdout1_61ck51 AVG v(dout1_61) FROM=729.9n TO=730.1n

.meas tran Vdout1_62ck51 AVG v(dout1_62) FROM=729.9n TO=730.1n

.meas tran Vdout1_63ck51 AVG v(dout1_63) FROM=729.9n TO=730.1n

.meas tran Vdout1_64ck51 AVG v(dout1_64) FROM=729.9n TO=730.1n

.meas tran Vdout1_65ck51 AVG v(dout1_65) FROM=729.9n TO=730.1n

.meas tran Vdout1_66ck51 AVG v(dout1_66) FROM=729.9n TO=730.1n

.meas tran Vdout1_67ck51 AVG v(dout1_67) FROM=729.9n TO=730.1n

.meas tran Vdout1_68ck51 AVG v(dout1_68) FROM=729.9n TO=730.1n

.meas tran Vdout1_69ck51 AVG v(dout1_69) FROM=729.9n TO=730.1n

.meas tran Vdout1_70ck51 AVG v(dout1_70) FROM=729.9n TO=730.1n

.meas tran Vdout1_71ck51 AVG v(dout1_71) FROM=729.9n TO=730.1n

.meas tran Vdout1_72ck51 AVG v(dout1_72) FROM=729.9n TO=730.1n

.meas tran Vdout1_73ck51 AVG v(dout1_73) FROM=729.9n TO=730.1n

.meas tran Vdout1_74ck51 AVG v(dout1_74) FROM=729.9n TO=730.1n

.meas tran Vdout1_75ck51 AVG v(dout1_75) FROM=729.9n TO=730.1n

.meas tran Vdout1_76ck51 AVG v(dout1_76) FROM=729.9n TO=730.1n

.meas tran Vdout1_77ck51 AVG v(dout1_77) FROM=729.9n TO=730.1n

.meas tran Vdout1_78ck51 AVG v(dout1_78) FROM=729.9n TO=730.1n

.meas tran Vdout1_79ck51 AVG v(dout1_79) FROM=729.9n TO=730.1n

.meas tran Vdout0_0ck52 AVG v(dout0_0) FROM=749.9n TO=750.1n

.meas tran Vdout0_1ck52 AVG v(dout0_1) FROM=749.9n TO=750.1n

.meas tran Vdout0_2ck52 AVG v(dout0_2) FROM=749.9n TO=750.1n

.meas tran Vdout0_3ck52 AVG v(dout0_3) FROM=749.9n TO=750.1n

.meas tran Vdout0_4ck52 AVG v(dout0_4) FROM=749.9n TO=750.1n

.meas tran Vdout0_5ck52 AVG v(dout0_5) FROM=749.9n TO=750.1n

.meas tran Vdout0_6ck52 AVG v(dout0_6) FROM=749.9n TO=750.1n

.meas tran Vdout0_7ck52 AVG v(dout0_7) FROM=749.9n TO=750.1n

.meas tran Vdout0_8ck52 AVG v(dout0_8) FROM=749.9n TO=750.1n

.meas tran Vdout0_9ck52 AVG v(dout0_9) FROM=749.9n TO=750.1n

.meas tran Vdout0_10ck52 AVG v(dout0_10) FROM=749.9n TO=750.1n

.meas tran Vdout0_11ck52 AVG v(dout0_11) FROM=749.9n TO=750.1n

.meas tran Vdout0_12ck52 AVG v(dout0_12) FROM=749.9n TO=750.1n

.meas tran Vdout0_13ck52 AVG v(dout0_13) FROM=749.9n TO=750.1n

.meas tran Vdout0_14ck52 AVG v(dout0_14) FROM=749.9n TO=750.1n

.meas tran Vdout0_15ck52 AVG v(dout0_15) FROM=749.9n TO=750.1n

.meas tran Vdout0_16ck52 AVG v(dout0_16) FROM=749.9n TO=750.1n

.meas tran Vdout0_17ck52 AVG v(dout0_17) FROM=749.9n TO=750.1n

.meas tran Vdout0_18ck52 AVG v(dout0_18) FROM=749.9n TO=750.1n

.meas tran Vdout0_19ck52 AVG v(dout0_19) FROM=749.9n TO=750.1n

.meas tran Vdout0_20ck52 AVG v(dout0_20) FROM=749.9n TO=750.1n

.meas tran Vdout0_21ck52 AVG v(dout0_21) FROM=749.9n TO=750.1n

.meas tran Vdout0_22ck52 AVG v(dout0_22) FROM=749.9n TO=750.1n

.meas tran Vdout0_23ck52 AVG v(dout0_23) FROM=749.9n TO=750.1n

.meas tran Vdout0_24ck52 AVG v(dout0_24) FROM=749.9n TO=750.1n

.meas tran Vdout0_25ck52 AVG v(dout0_25) FROM=749.9n TO=750.1n

.meas tran Vdout0_26ck52 AVG v(dout0_26) FROM=749.9n TO=750.1n

.meas tran Vdout0_27ck52 AVG v(dout0_27) FROM=749.9n TO=750.1n

.meas tran Vdout0_28ck52 AVG v(dout0_28) FROM=749.9n TO=750.1n

.meas tran Vdout0_29ck52 AVG v(dout0_29) FROM=749.9n TO=750.1n

.meas tran Vdout0_30ck52 AVG v(dout0_30) FROM=749.9n TO=750.1n

.meas tran Vdout0_31ck52 AVG v(dout0_31) FROM=749.9n TO=750.1n

.meas tran Vdout0_32ck52 AVG v(dout0_32) FROM=749.9n TO=750.1n

.meas tran Vdout0_33ck52 AVG v(dout0_33) FROM=749.9n TO=750.1n

.meas tran Vdout0_34ck52 AVG v(dout0_34) FROM=749.9n TO=750.1n

.meas tran Vdout0_35ck52 AVG v(dout0_35) FROM=749.9n TO=750.1n

.meas tran Vdout0_36ck52 AVG v(dout0_36) FROM=749.9n TO=750.1n

.meas tran Vdout0_37ck52 AVG v(dout0_37) FROM=749.9n TO=750.1n

.meas tran Vdout0_38ck52 AVG v(dout0_38) FROM=749.9n TO=750.1n

.meas tran Vdout0_39ck52 AVG v(dout0_39) FROM=749.9n TO=750.1n

.meas tran Vdout0_40ck52 AVG v(dout0_40) FROM=749.9n TO=750.1n

.meas tran Vdout0_41ck52 AVG v(dout0_41) FROM=749.9n TO=750.1n

.meas tran Vdout0_42ck52 AVG v(dout0_42) FROM=749.9n TO=750.1n

.meas tran Vdout0_43ck52 AVG v(dout0_43) FROM=749.9n TO=750.1n

.meas tran Vdout0_44ck52 AVG v(dout0_44) FROM=749.9n TO=750.1n

.meas tran Vdout0_45ck52 AVG v(dout0_45) FROM=749.9n TO=750.1n

.meas tran Vdout0_46ck52 AVG v(dout0_46) FROM=749.9n TO=750.1n

.meas tran Vdout0_47ck52 AVG v(dout0_47) FROM=749.9n TO=750.1n

.meas tran Vdout0_48ck52 AVG v(dout0_48) FROM=749.9n TO=750.1n

.meas tran Vdout0_49ck52 AVG v(dout0_49) FROM=749.9n TO=750.1n

.meas tran Vdout0_50ck52 AVG v(dout0_50) FROM=749.9n TO=750.1n

.meas tran Vdout0_51ck52 AVG v(dout0_51) FROM=749.9n TO=750.1n

.meas tran Vdout0_52ck52 AVG v(dout0_52) FROM=749.9n TO=750.1n

.meas tran Vdout0_53ck52 AVG v(dout0_53) FROM=749.9n TO=750.1n

.meas tran Vdout0_54ck52 AVG v(dout0_54) FROM=749.9n TO=750.1n

.meas tran Vdout0_55ck52 AVG v(dout0_55) FROM=749.9n TO=750.1n

.meas tran Vdout0_56ck52 AVG v(dout0_56) FROM=749.9n TO=750.1n

.meas tran Vdout0_57ck52 AVG v(dout0_57) FROM=749.9n TO=750.1n

.meas tran Vdout0_58ck52 AVG v(dout0_58) FROM=749.9n TO=750.1n

.meas tran Vdout0_59ck52 AVG v(dout0_59) FROM=749.9n TO=750.1n

.meas tran Vdout0_60ck52 AVG v(dout0_60) FROM=749.9n TO=750.1n

.meas tran Vdout0_61ck52 AVG v(dout0_61) FROM=749.9n TO=750.1n

.meas tran Vdout0_62ck52 AVG v(dout0_62) FROM=749.9n TO=750.1n

.meas tran Vdout0_63ck52 AVG v(dout0_63) FROM=749.9n TO=750.1n

.meas tran Vdout0_64ck52 AVG v(dout0_64) FROM=749.9n TO=750.1n

.meas tran Vdout0_65ck52 AVG v(dout0_65) FROM=749.9n TO=750.1n

.meas tran Vdout0_66ck52 AVG v(dout0_66) FROM=749.9n TO=750.1n

.meas tran Vdout0_67ck52 AVG v(dout0_67) FROM=749.9n TO=750.1n

.meas tran Vdout0_68ck52 AVG v(dout0_68) FROM=749.9n TO=750.1n

.meas tran Vdout0_69ck52 AVG v(dout0_69) FROM=749.9n TO=750.1n

.meas tran Vdout0_70ck52 AVG v(dout0_70) FROM=749.9n TO=750.1n

.meas tran Vdout0_71ck52 AVG v(dout0_71) FROM=749.9n TO=750.1n

.meas tran Vdout0_72ck52 AVG v(dout0_72) FROM=749.9n TO=750.1n

.meas tran Vdout0_73ck52 AVG v(dout0_73) FROM=749.9n TO=750.1n

.meas tran Vdout0_74ck52 AVG v(dout0_74) FROM=749.9n TO=750.1n

.meas tran Vdout0_75ck52 AVG v(dout0_75) FROM=749.9n TO=750.1n

.meas tran Vdout0_76ck52 AVG v(dout0_76) FROM=749.9n TO=750.1n

.meas tran Vdout0_77ck52 AVG v(dout0_77) FROM=749.9n TO=750.1n

.meas tran Vdout0_78ck52 AVG v(dout0_78) FROM=749.9n TO=750.1n

.meas tran Vdout0_79ck52 AVG v(dout0_79) FROM=749.9n TO=750.1n

.meas tran Vdout1_0ck53 AVG v(dout1_0) FROM=749.9n TO=750.1n

.meas tran Vdout1_1ck53 AVG v(dout1_1) FROM=749.9n TO=750.1n

.meas tran Vdout1_2ck53 AVG v(dout1_2) FROM=749.9n TO=750.1n

.meas tran Vdout1_3ck53 AVG v(dout1_3) FROM=749.9n TO=750.1n

.meas tran Vdout1_4ck53 AVG v(dout1_4) FROM=749.9n TO=750.1n

.meas tran Vdout1_5ck53 AVG v(dout1_5) FROM=749.9n TO=750.1n

.meas tran Vdout1_6ck53 AVG v(dout1_6) FROM=749.9n TO=750.1n

.meas tran Vdout1_7ck53 AVG v(dout1_7) FROM=749.9n TO=750.1n

.meas tran Vdout1_8ck53 AVG v(dout1_8) FROM=749.9n TO=750.1n

.meas tran Vdout1_9ck53 AVG v(dout1_9) FROM=749.9n TO=750.1n

.meas tran Vdout1_10ck53 AVG v(dout1_10) FROM=749.9n TO=750.1n

.meas tran Vdout1_11ck53 AVG v(dout1_11) FROM=749.9n TO=750.1n

.meas tran Vdout1_12ck53 AVG v(dout1_12) FROM=749.9n TO=750.1n

.meas tran Vdout1_13ck53 AVG v(dout1_13) FROM=749.9n TO=750.1n

.meas tran Vdout1_14ck53 AVG v(dout1_14) FROM=749.9n TO=750.1n

.meas tran Vdout1_15ck53 AVG v(dout1_15) FROM=749.9n TO=750.1n

.meas tran Vdout1_16ck53 AVG v(dout1_16) FROM=749.9n TO=750.1n

.meas tran Vdout1_17ck53 AVG v(dout1_17) FROM=749.9n TO=750.1n

.meas tran Vdout1_18ck53 AVG v(dout1_18) FROM=749.9n TO=750.1n

.meas tran Vdout1_19ck53 AVG v(dout1_19) FROM=749.9n TO=750.1n

.meas tran Vdout1_20ck53 AVG v(dout1_20) FROM=749.9n TO=750.1n

.meas tran Vdout1_21ck53 AVG v(dout1_21) FROM=749.9n TO=750.1n

.meas tran Vdout1_22ck53 AVG v(dout1_22) FROM=749.9n TO=750.1n

.meas tran Vdout1_23ck53 AVG v(dout1_23) FROM=749.9n TO=750.1n

.meas tran Vdout1_24ck53 AVG v(dout1_24) FROM=749.9n TO=750.1n

.meas tran Vdout1_25ck53 AVG v(dout1_25) FROM=749.9n TO=750.1n

.meas tran Vdout1_26ck53 AVG v(dout1_26) FROM=749.9n TO=750.1n

.meas tran Vdout1_27ck53 AVG v(dout1_27) FROM=749.9n TO=750.1n

.meas tran Vdout1_28ck53 AVG v(dout1_28) FROM=749.9n TO=750.1n

.meas tran Vdout1_29ck53 AVG v(dout1_29) FROM=749.9n TO=750.1n

.meas tran Vdout1_30ck53 AVG v(dout1_30) FROM=749.9n TO=750.1n

.meas tran Vdout1_31ck53 AVG v(dout1_31) FROM=749.9n TO=750.1n

.meas tran Vdout1_32ck53 AVG v(dout1_32) FROM=749.9n TO=750.1n

.meas tran Vdout1_33ck53 AVG v(dout1_33) FROM=749.9n TO=750.1n

.meas tran Vdout1_34ck53 AVG v(dout1_34) FROM=749.9n TO=750.1n

.meas tran Vdout1_35ck53 AVG v(dout1_35) FROM=749.9n TO=750.1n

.meas tran Vdout1_36ck53 AVG v(dout1_36) FROM=749.9n TO=750.1n

.meas tran Vdout1_37ck53 AVG v(dout1_37) FROM=749.9n TO=750.1n

.meas tran Vdout1_38ck53 AVG v(dout1_38) FROM=749.9n TO=750.1n

.meas tran Vdout1_39ck53 AVG v(dout1_39) FROM=749.9n TO=750.1n

.meas tran Vdout1_40ck53 AVG v(dout1_40) FROM=749.9n TO=750.1n

.meas tran Vdout1_41ck53 AVG v(dout1_41) FROM=749.9n TO=750.1n

.meas tran Vdout1_42ck53 AVG v(dout1_42) FROM=749.9n TO=750.1n

.meas tran Vdout1_43ck53 AVG v(dout1_43) FROM=749.9n TO=750.1n

.meas tran Vdout1_44ck53 AVG v(dout1_44) FROM=749.9n TO=750.1n

.meas tran Vdout1_45ck53 AVG v(dout1_45) FROM=749.9n TO=750.1n

.meas tran Vdout1_46ck53 AVG v(dout1_46) FROM=749.9n TO=750.1n

.meas tran Vdout1_47ck53 AVG v(dout1_47) FROM=749.9n TO=750.1n

.meas tran Vdout1_48ck53 AVG v(dout1_48) FROM=749.9n TO=750.1n

.meas tran Vdout1_49ck53 AVG v(dout1_49) FROM=749.9n TO=750.1n

.meas tran Vdout1_50ck53 AVG v(dout1_50) FROM=749.9n TO=750.1n

.meas tran Vdout1_51ck53 AVG v(dout1_51) FROM=749.9n TO=750.1n

.meas tran Vdout1_52ck53 AVG v(dout1_52) FROM=749.9n TO=750.1n

.meas tran Vdout1_53ck53 AVG v(dout1_53) FROM=749.9n TO=750.1n

.meas tran Vdout1_54ck53 AVG v(dout1_54) FROM=749.9n TO=750.1n

.meas tran Vdout1_55ck53 AVG v(dout1_55) FROM=749.9n TO=750.1n

.meas tran Vdout1_56ck53 AVG v(dout1_56) FROM=749.9n TO=750.1n

.meas tran Vdout1_57ck53 AVG v(dout1_57) FROM=749.9n TO=750.1n

.meas tran Vdout1_58ck53 AVG v(dout1_58) FROM=749.9n TO=750.1n

.meas tran Vdout1_59ck53 AVG v(dout1_59) FROM=749.9n TO=750.1n

.meas tran Vdout1_60ck53 AVG v(dout1_60) FROM=749.9n TO=750.1n

.meas tran Vdout1_61ck53 AVG v(dout1_61) FROM=749.9n TO=750.1n

.meas tran Vdout1_62ck53 AVG v(dout1_62) FROM=749.9n TO=750.1n

.meas tran Vdout1_63ck53 AVG v(dout1_63) FROM=749.9n TO=750.1n

.meas tran Vdout1_64ck53 AVG v(dout1_64) FROM=749.9n TO=750.1n

.meas tran Vdout1_65ck53 AVG v(dout1_65) FROM=749.9n TO=750.1n

.meas tran Vdout1_66ck53 AVG v(dout1_66) FROM=749.9n TO=750.1n

.meas tran Vdout1_67ck53 AVG v(dout1_67) FROM=749.9n TO=750.1n

.meas tran Vdout1_68ck53 AVG v(dout1_68) FROM=749.9n TO=750.1n

.meas tran Vdout1_69ck53 AVG v(dout1_69) FROM=749.9n TO=750.1n

.meas tran Vdout1_70ck53 AVG v(dout1_70) FROM=749.9n TO=750.1n

.meas tran Vdout1_71ck53 AVG v(dout1_71) FROM=749.9n TO=750.1n

.meas tran Vdout1_72ck53 AVG v(dout1_72) FROM=749.9n TO=750.1n

.meas tran Vdout1_73ck53 AVG v(dout1_73) FROM=749.9n TO=750.1n

.meas tran Vdout1_74ck53 AVG v(dout1_74) FROM=749.9n TO=750.1n

.meas tran Vdout1_75ck53 AVG v(dout1_75) FROM=749.9n TO=750.1n

.meas tran Vdout1_76ck53 AVG v(dout1_76) FROM=749.9n TO=750.1n

.meas tran Vdout1_77ck53 AVG v(dout1_77) FROM=749.9n TO=750.1n

.meas tran Vdout1_78ck53 AVG v(dout1_78) FROM=749.9n TO=750.1n

.meas tran Vdout1_79ck53 AVG v(dout1_79) FROM=749.9n TO=750.1n

.meas tran Vdout1_0ck54 AVG v(dout1_0) FROM=759.9n TO=760.1n

.meas tran Vdout1_1ck54 AVG v(dout1_1) FROM=759.9n TO=760.1n

.meas tran Vdout1_2ck54 AVG v(dout1_2) FROM=759.9n TO=760.1n

.meas tran Vdout1_3ck54 AVG v(dout1_3) FROM=759.9n TO=760.1n

.meas tran Vdout1_4ck54 AVG v(dout1_4) FROM=759.9n TO=760.1n

.meas tran Vdout1_5ck54 AVG v(dout1_5) FROM=759.9n TO=760.1n

.meas tran Vdout1_6ck54 AVG v(dout1_6) FROM=759.9n TO=760.1n

.meas tran Vdout1_7ck54 AVG v(dout1_7) FROM=759.9n TO=760.1n

.meas tran Vdout1_8ck54 AVG v(dout1_8) FROM=759.9n TO=760.1n

.meas tran Vdout1_9ck54 AVG v(dout1_9) FROM=759.9n TO=760.1n

.meas tran Vdout1_10ck54 AVG v(dout1_10) FROM=759.9n TO=760.1n

.meas tran Vdout1_11ck54 AVG v(dout1_11) FROM=759.9n TO=760.1n

.meas tran Vdout1_12ck54 AVG v(dout1_12) FROM=759.9n TO=760.1n

.meas tran Vdout1_13ck54 AVG v(dout1_13) FROM=759.9n TO=760.1n

.meas tran Vdout1_14ck54 AVG v(dout1_14) FROM=759.9n TO=760.1n

.meas tran Vdout1_15ck54 AVG v(dout1_15) FROM=759.9n TO=760.1n

.meas tran Vdout1_16ck54 AVG v(dout1_16) FROM=759.9n TO=760.1n

.meas tran Vdout1_17ck54 AVG v(dout1_17) FROM=759.9n TO=760.1n

.meas tran Vdout1_18ck54 AVG v(dout1_18) FROM=759.9n TO=760.1n

.meas tran Vdout1_19ck54 AVG v(dout1_19) FROM=759.9n TO=760.1n

.meas tran Vdout1_20ck54 AVG v(dout1_20) FROM=759.9n TO=760.1n

.meas tran Vdout1_21ck54 AVG v(dout1_21) FROM=759.9n TO=760.1n

.meas tran Vdout1_22ck54 AVG v(dout1_22) FROM=759.9n TO=760.1n

.meas tran Vdout1_23ck54 AVG v(dout1_23) FROM=759.9n TO=760.1n

.meas tran Vdout1_24ck54 AVG v(dout1_24) FROM=759.9n TO=760.1n

.meas tran Vdout1_25ck54 AVG v(dout1_25) FROM=759.9n TO=760.1n

.meas tran Vdout1_26ck54 AVG v(dout1_26) FROM=759.9n TO=760.1n

.meas tran Vdout1_27ck54 AVG v(dout1_27) FROM=759.9n TO=760.1n

.meas tran Vdout1_28ck54 AVG v(dout1_28) FROM=759.9n TO=760.1n

.meas tran Vdout1_29ck54 AVG v(dout1_29) FROM=759.9n TO=760.1n

.meas tran Vdout1_30ck54 AVG v(dout1_30) FROM=759.9n TO=760.1n

.meas tran Vdout1_31ck54 AVG v(dout1_31) FROM=759.9n TO=760.1n

.meas tran Vdout1_32ck54 AVG v(dout1_32) FROM=759.9n TO=760.1n

.meas tran Vdout1_33ck54 AVG v(dout1_33) FROM=759.9n TO=760.1n

.meas tran Vdout1_34ck54 AVG v(dout1_34) FROM=759.9n TO=760.1n

.meas tran Vdout1_35ck54 AVG v(dout1_35) FROM=759.9n TO=760.1n

.meas tran Vdout1_36ck54 AVG v(dout1_36) FROM=759.9n TO=760.1n

.meas tran Vdout1_37ck54 AVG v(dout1_37) FROM=759.9n TO=760.1n

.meas tran Vdout1_38ck54 AVG v(dout1_38) FROM=759.9n TO=760.1n

.meas tran Vdout1_39ck54 AVG v(dout1_39) FROM=759.9n TO=760.1n

.meas tran Vdout1_40ck54 AVG v(dout1_40) FROM=759.9n TO=760.1n

.meas tran Vdout1_41ck54 AVG v(dout1_41) FROM=759.9n TO=760.1n

.meas tran Vdout1_42ck54 AVG v(dout1_42) FROM=759.9n TO=760.1n

.meas tran Vdout1_43ck54 AVG v(dout1_43) FROM=759.9n TO=760.1n

.meas tran Vdout1_44ck54 AVG v(dout1_44) FROM=759.9n TO=760.1n

.meas tran Vdout1_45ck54 AVG v(dout1_45) FROM=759.9n TO=760.1n

.meas tran Vdout1_46ck54 AVG v(dout1_46) FROM=759.9n TO=760.1n

.meas tran Vdout1_47ck54 AVG v(dout1_47) FROM=759.9n TO=760.1n

.meas tran Vdout1_48ck54 AVG v(dout1_48) FROM=759.9n TO=760.1n

.meas tran Vdout1_49ck54 AVG v(dout1_49) FROM=759.9n TO=760.1n

.meas tran Vdout1_50ck54 AVG v(dout1_50) FROM=759.9n TO=760.1n

.meas tran Vdout1_51ck54 AVG v(dout1_51) FROM=759.9n TO=760.1n

.meas tran Vdout1_52ck54 AVG v(dout1_52) FROM=759.9n TO=760.1n

.meas tran Vdout1_53ck54 AVG v(dout1_53) FROM=759.9n TO=760.1n

.meas tran Vdout1_54ck54 AVG v(dout1_54) FROM=759.9n TO=760.1n

.meas tran Vdout1_55ck54 AVG v(dout1_55) FROM=759.9n TO=760.1n

.meas tran Vdout1_56ck54 AVG v(dout1_56) FROM=759.9n TO=760.1n

.meas tran Vdout1_57ck54 AVG v(dout1_57) FROM=759.9n TO=760.1n

.meas tran Vdout1_58ck54 AVG v(dout1_58) FROM=759.9n TO=760.1n

.meas tran Vdout1_59ck54 AVG v(dout1_59) FROM=759.9n TO=760.1n

.meas tran Vdout1_60ck54 AVG v(dout1_60) FROM=759.9n TO=760.1n

.meas tran Vdout1_61ck54 AVG v(dout1_61) FROM=759.9n TO=760.1n

.meas tran Vdout1_62ck54 AVG v(dout1_62) FROM=759.9n TO=760.1n

.meas tran Vdout1_63ck54 AVG v(dout1_63) FROM=759.9n TO=760.1n

.meas tran Vdout1_64ck54 AVG v(dout1_64) FROM=759.9n TO=760.1n

.meas tran Vdout1_65ck54 AVG v(dout1_65) FROM=759.9n TO=760.1n

.meas tran Vdout1_66ck54 AVG v(dout1_66) FROM=759.9n TO=760.1n

.meas tran Vdout1_67ck54 AVG v(dout1_67) FROM=759.9n TO=760.1n

.meas tran Vdout1_68ck54 AVG v(dout1_68) FROM=759.9n TO=760.1n

.meas tran Vdout1_69ck54 AVG v(dout1_69) FROM=759.9n TO=760.1n

.meas tran Vdout1_70ck54 AVG v(dout1_70) FROM=759.9n TO=760.1n

.meas tran Vdout1_71ck54 AVG v(dout1_71) FROM=759.9n TO=760.1n

.meas tran Vdout1_72ck54 AVG v(dout1_72) FROM=759.9n TO=760.1n

.meas tran Vdout1_73ck54 AVG v(dout1_73) FROM=759.9n TO=760.1n

.meas tran Vdout1_74ck54 AVG v(dout1_74) FROM=759.9n TO=760.1n

.meas tran Vdout1_75ck54 AVG v(dout1_75) FROM=759.9n TO=760.1n

.meas tran Vdout1_76ck54 AVG v(dout1_76) FROM=759.9n TO=760.1n

.meas tran Vdout1_77ck54 AVG v(dout1_77) FROM=759.9n TO=760.1n

.meas tran Vdout1_78ck54 AVG v(dout1_78) FROM=759.9n TO=760.1n

.meas tran Vdout1_79ck54 AVG v(dout1_79) FROM=759.9n TO=760.1n

.meas tran Vdout0_0ck55 AVG v(dout0_0) FROM=769.9n TO=770.1n

.meas tran Vdout0_1ck55 AVG v(dout0_1) FROM=769.9n TO=770.1n

.meas tran Vdout0_2ck55 AVG v(dout0_2) FROM=769.9n TO=770.1n

.meas tran Vdout0_3ck55 AVG v(dout0_3) FROM=769.9n TO=770.1n

.meas tran Vdout0_4ck55 AVG v(dout0_4) FROM=769.9n TO=770.1n

.meas tran Vdout0_5ck55 AVG v(dout0_5) FROM=769.9n TO=770.1n

.meas tran Vdout0_6ck55 AVG v(dout0_6) FROM=769.9n TO=770.1n

.meas tran Vdout0_7ck55 AVG v(dout0_7) FROM=769.9n TO=770.1n

.meas tran Vdout0_8ck55 AVG v(dout0_8) FROM=769.9n TO=770.1n

.meas tran Vdout0_9ck55 AVG v(dout0_9) FROM=769.9n TO=770.1n

.meas tran Vdout0_10ck55 AVG v(dout0_10) FROM=769.9n TO=770.1n

.meas tran Vdout0_11ck55 AVG v(dout0_11) FROM=769.9n TO=770.1n

.meas tran Vdout0_12ck55 AVG v(dout0_12) FROM=769.9n TO=770.1n

.meas tran Vdout0_13ck55 AVG v(dout0_13) FROM=769.9n TO=770.1n

.meas tran Vdout0_14ck55 AVG v(dout0_14) FROM=769.9n TO=770.1n

.meas tran Vdout0_15ck55 AVG v(dout0_15) FROM=769.9n TO=770.1n

.meas tran Vdout0_16ck55 AVG v(dout0_16) FROM=769.9n TO=770.1n

.meas tran Vdout0_17ck55 AVG v(dout0_17) FROM=769.9n TO=770.1n

.meas tran Vdout0_18ck55 AVG v(dout0_18) FROM=769.9n TO=770.1n

.meas tran Vdout0_19ck55 AVG v(dout0_19) FROM=769.9n TO=770.1n

.meas tran Vdout0_20ck55 AVG v(dout0_20) FROM=769.9n TO=770.1n

.meas tran Vdout0_21ck55 AVG v(dout0_21) FROM=769.9n TO=770.1n

.meas tran Vdout0_22ck55 AVG v(dout0_22) FROM=769.9n TO=770.1n

.meas tran Vdout0_23ck55 AVG v(dout0_23) FROM=769.9n TO=770.1n

.meas tran Vdout0_24ck55 AVG v(dout0_24) FROM=769.9n TO=770.1n

.meas tran Vdout0_25ck55 AVG v(dout0_25) FROM=769.9n TO=770.1n

.meas tran Vdout0_26ck55 AVG v(dout0_26) FROM=769.9n TO=770.1n

.meas tran Vdout0_27ck55 AVG v(dout0_27) FROM=769.9n TO=770.1n

.meas tran Vdout0_28ck55 AVG v(dout0_28) FROM=769.9n TO=770.1n

.meas tran Vdout0_29ck55 AVG v(dout0_29) FROM=769.9n TO=770.1n

.meas tran Vdout0_30ck55 AVG v(dout0_30) FROM=769.9n TO=770.1n

.meas tran Vdout0_31ck55 AVG v(dout0_31) FROM=769.9n TO=770.1n

.meas tran Vdout0_32ck55 AVG v(dout0_32) FROM=769.9n TO=770.1n

.meas tran Vdout0_33ck55 AVG v(dout0_33) FROM=769.9n TO=770.1n

.meas tran Vdout0_34ck55 AVG v(dout0_34) FROM=769.9n TO=770.1n

.meas tran Vdout0_35ck55 AVG v(dout0_35) FROM=769.9n TO=770.1n

.meas tran Vdout0_36ck55 AVG v(dout0_36) FROM=769.9n TO=770.1n

.meas tran Vdout0_37ck55 AVG v(dout0_37) FROM=769.9n TO=770.1n

.meas tran Vdout0_38ck55 AVG v(dout0_38) FROM=769.9n TO=770.1n

.meas tran Vdout0_39ck55 AVG v(dout0_39) FROM=769.9n TO=770.1n

.meas tran Vdout0_40ck55 AVG v(dout0_40) FROM=769.9n TO=770.1n

.meas tran Vdout0_41ck55 AVG v(dout0_41) FROM=769.9n TO=770.1n

.meas tran Vdout0_42ck55 AVG v(dout0_42) FROM=769.9n TO=770.1n

.meas tran Vdout0_43ck55 AVG v(dout0_43) FROM=769.9n TO=770.1n

.meas tran Vdout0_44ck55 AVG v(dout0_44) FROM=769.9n TO=770.1n

.meas tran Vdout0_45ck55 AVG v(dout0_45) FROM=769.9n TO=770.1n

.meas tran Vdout0_46ck55 AVG v(dout0_46) FROM=769.9n TO=770.1n

.meas tran Vdout0_47ck55 AVG v(dout0_47) FROM=769.9n TO=770.1n

.meas tran Vdout0_48ck55 AVG v(dout0_48) FROM=769.9n TO=770.1n

.meas tran Vdout0_49ck55 AVG v(dout0_49) FROM=769.9n TO=770.1n

.meas tran Vdout0_50ck55 AVG v(dout0_50) FROM=769.9n TO=770.1n

.meas tran Vdout0_51ck55 AVG v(dout0_51) FROM=769.9n TO=770.1n

.meas tran Vdout0_52ck55 AVG v(dout0_52) FROM=769.9n TO=770.1n

.meas tran Vdout0_53ck55 AVG v(dout0_53) FROM=769.9n TO=770.1n

.meas tran Vdout0_54ck55 AVG v(dout0_54) FROM=769.9n TO=770.1n

.meas tran Vdout0_55ck55 AVG v(dout0_55) FROM=769.9n TO=770.1n

.meas tran Vdout0_56ck55 AVG v(dout0_56) FROM=769.9n TO=770.1n

.meas tran Vdout0_57ck55 AVG v(dout0_57) FROM=769.9n TO=770.1n

.meas tran Vdout0_58ck55 AVG v(dout0_58) FROM=769.9n TO=770.1n

.meas tran Vdout0_59ck55 AVG v(dout0_59) FROM=769.9n TO=770.1n

.meas tran Vdout0_60ck55 AVG v(dout0_60) FROM=769.9n TO=770.1n

.meas tran Vdout0_61ck55 AVG v(dout0_61) FROM=769.9n TO=770.1n

.meas tran Vdout0_62ck55 AVG v(dout0_62) FROM=769.9n TO=770.1n

.meas tran Vdout0_63ck55 AVG v(dout0_63) FROM=769.9n TO=770.1n

.meas tran Vdout0_64ck55 AVG v(dout0_64) FROM=769.9n TO=770.1n

.meas tran Vdout0_65ck55 AVG v(dout0_65) FROM=769.9n TO=770.1n

.meas tran Vdout0_66ck55 AVG v(dout0_66) FROM=769.9n TO=770.1n

.meas tran Vdout0_67ck55 AVG v(dout0_67) FROM=769.9n TO=770.1n

.meas tran Vdout0_68ck55 AVG v(dout0_68) FROM=769.9n TO=770.1n

.meas tran Vdout0_69ck55 AVG v(dout0_69) FROM=769.9n TO=770.1n

.meas tran Vdout0_70ck55 AVG v(dout0_70) FROM=769.9n TO=770.1n

.meas tran Vdout0_71ck55 AVG v(dout0_71) FROM=769.9n TO=770.1n

.meas tran Vdout0_72ck55 AVG v(dout0_72) FROM=769.9n TO=770.1n

.meas tran Vdout0_73ck55 AVG v(dout0_73) FROM=769.9n TO=770.1n

.meas tran Vdout0_74ck55 AVG v(dout0_74) FROM=769.9n TO=770.1n

.meas tran Vdout0_75ck55 AVG v(dout0_75) FROM=769.9n TO=770.1n

.meas tran Vdout0_76ck55 AVG v(dout0_76) FROM=769.9n TO=770.1n

.meas tran Vdout0_77ck55 AVG v(dout0_77) FROM=769.9n TO=770.1n

.meas tran Vdout0_78ck55 AVG v(dout0_78) FROM=769.9n TO=770.1n

.meas tran Vdout0_79ck55 AVG v(dout0_79) FROM=769.9n TO=770.1n

.meas tran Vdout1_0ck56 AVG v(dout1_0) FROM=779.9n TO=780.1n

.meas tran Vdout1_1ck56 AVG v(dout1_1) FROM=779.9n TO=780.1n

.meas tran Vdout1_2ck56 AVG v(dout1_2) FROM=779.9n TO=780.1n

.meas tran Vdout1_3ck56 AVG v(dout1_3) FROM=779.9n TO=780.1n

.meas tran Vdout1_4ck56 AVG v(dout1_4) FROM=779.9n TO=780.1n

.meas tran Vdout1_5ck56 AVG v(dout1_5) FROM=779.9n TO=780.1n

.meas tran Vdout1_6ck56 AVG v(dout1_6) FROM=779.9n TO=780.1n

.meas tran Vdout1_7ck56 AVG v(dout1_7) FROM=779.9n TO=780.1n

.meas tran Vdout1_8ck56 AVG v(dout1_8) FROM=779.9n TO=780.1n

.meas tran Vdout1_9ck56 AVG v(dout1_9) FROM=779.9n TO=780.1n

.meas tran Vdout1_10ck56 AVG v(dout1_10) FROM=779.9n TO=780.1n

.meas tran Vdout1_11ck56 AVG v(dout1_11) FROM=779.9n TO=780.1n

.meas tran Vdout1_12ck56 AVG v(dout1_12) FROM=779.9n TO=780.1n

.meas tran Vdout1_13ck56 AVG v(dout1_13) FROM=779.9n TO=780.1n

.meas tran Vdout1_14ck56 AVG v(dout1_14) FROM=779.9n TO=780.1n

.meas tran Vdout1_15ck56 AVG v(dout1_15) FROM=779.9n TO=780.1n

.meas tran Vdout1_16ck56 AVG v(dout1_16) FROM=779.9n TO=780.1n

.meas tran Vdout1_17ck56 AVG v(dout1_17) FROM=779.9n TO=780.1n

.meas tran Vdout1_18ck56 AVG v(dout1_18) FROM=779.9n TO=780.1n

.meas tran Vdout1_19ck56 AVG v(dout1_19) FROM=779.9n TO=780.1n

.meas tran Vdout1_20ck56 AVG v(dout1_20) FROM=779.9n TO=780.1n

.meas tran Vdout1_21ck56 AVG v(dout1_21) FROM=779.9n TO=780.1n

.meas tran Vdout1_22ck56 AVG v(dout1_22) FROM=779.9n TO=780.1n

.meas tran Vdout1_23ck56 AVG v(dout1_23) FROM=779.9n TO=780.1n

.meas tran Vdout1_24ck56 AVG v(dout1_24) FROM=779.9n TO=780.1n

.meas tran Vdout1_25ck56 AVG v(dout1_25) FROM=779.9n TO=780.1n

.meas tran Vdout1_26ck56 AVG v(dout1_26) FROM=779.9n TO=780.1n

.meas tran Vdout1_27ck56 AVG v(dout1_27) FROM=779.9n TO=780.1n

.meas tran Vdout1_28ck56 AVG v(dout1_28) FROM=779.9n TO=780.1n

.meas tran Vdout1_29ck56 AVG v(dout1_29) FROM=779.9n TO=780.1n

.meas tran Vdout1_30ck56 AVG v(dout1_30) FROM=779.9n TO=780.1n

.meas tran Vdout1_31ck56 AVG v(dout1_31) FROM=779.9n TO=780.1n

.meas tran Vdout1_32ck56 AVG v(dout1_32) FROM=779.9n TO=780.1n

.meas tran Vdout1_33ck56 AVG v(dout1_33) FROM=779.9n TO=780.1n

.meas tran Vdout1_34ck56 AVG v(dout1_34) FROM=779.9n TO=780.1n

.meas tran Vdout1_35ck56 AVG v(dout1_35) FROM=779.9n TO=780.1n

.meas tran Vdout1_36ck56 AVG v(dout1_36) FROM=779.9n TO=780.1n

.meas tran Vdout1_37ck56 AVG v(dout1_37) FROM=779.9n TO=780.1n

.meas tran Vdout1_38ck56 AVG v(dout1_38) FROM=779.9n TO=780.1n

.meas tran Vdout1_39ck56 AVG v(dout1_39) FROM=779.9n TO=780.1n

.meas tran Vdout1_40ck56 AVG v(dout1_40) FROM=779.9n TO=780.1n

.meas tran Vdout1_41ck56 AVG v(dout1_41) FROM=779.9n TO=780.1n

.meas tran Vdout1_42ck56 AVG v(dout1_42) FROM=779.9n TO=780.1n

.meas tran Vdout1_43ck56 AVG v(dout1_43) FROM=779.9n TO=780.1n

.meas tran Vdout1_44ck56 AVG v(dout1_44) FROM=779.9n TO=780.1n

.meas tran Vdout1_45ck56 AVG v(dout1_45) FROM=779.9n TO=780.1n

.meas tran Vdout1_46ck56 AVG v(dout1_46) FROM=779.9n TO=780.1n

.meas tran Vdout1_47ck56 AVG v(dout1_47) FROM=779.9n TO=780.1n

.meas tran Vdout1_48ck56 AVG v(dout1_48) FROM=779.9n TO=780.1n

.meas tran Vdout1_49ck56 AVG v(dout1_49) FROM=779.9n TO=780.1n

.meas tran Vdout1_50ck56 AVG v(dout1_50) FROM=779.9n TO=780.1n

.meas tran Vdout1_51ck56 AVG v(dout1_51) FROM=779.9n TO=780.1n

.meas tran Vdout1_52ck56 AVG v(dout1_52) FROM=779.9n TO=780.1n

.meas tran Vdout1_53ck56 AVG v(dout1_53) FROM=779.9n TO=780.1n

.meas tran Vdout1_54ck56 AVG v(dout1_54) FROM=779.9n TO=780.1n

.meas tran Vdout1_55ck56 AVG v(dout1_55) FROM=779.9n TO=780.1n

.meas tran Vdout1_56ck56 AVG v(dout1_56) FROM=779.9n TO=780.1n

.meas tran Vdout1_57ck56 AVG v(dout1_57) FROM=779.9n TO=780.1n

.meas tran Vdout1_58ck56 AVG v(dout1_58) FROM=779.9n TO=780.1n

.meas tran Vdout1_59ck56 AVG v(dout1_59) FROM=779.9n TO=780.1n

.meas tran Vdout1_60ck56 AVG v(dout1_60) FROM=779.9n TO=780.1n

.meas tran Vdout1_61ck56 AVG v(dout1_61) FROM=779.9n TO=780.1n

.meas tran Vdout1_62ck56 AVG v(dout1_62) FROM=779.9n TO=780.1n

.meas tran Vdout1_63ck56 AVG v(dout1_63) FROM=779.9n TO=780.1n

.meas tran Vdout1_64ck56 AVG v(dout1_64) FROM=779.9n TO=780.1n

.meas tran Vdout1_65ck56 AVG v(dout1_65) FROM=779.9n TO=780.1n

.meas tran Vdout1_66ck56 AVG v(dout1_66) FROM=779.9n TO=780.1n

.meas tran Vdout1_67ck56 AVG v(dout1_67) FROM=779.9n TO=780.1n

.meas tran Vdout1_68ck56 AVG v(dout1_68) FROM=779.9n TO=780.1n

.meas tran Vdout1_69ck56 AVG v(dout1_69) FROM=779.9n TO=780.1n

.meas tran Vdout1_70ck56 AVG v(dout1_70) FROM=779.9n TO=780.1n

.meas tran Vdout1_71ck56 AVG v(dout1_71) FROM=779.9n TO=780.1n

.meas tran Vdout1_72ck56 AVG v(dout1_72) FROM=779.9n TO=780.1n

.meas tran Vdout1_73ck56 AVG v(dout1_73) FROM=779.9n TO=780.1n

.meas tran Vdout1_74ck56 AVG v(dout1_74) FROM=779.9n TO=780.1n

.meas tran Vdout1_75ck56 AVG v(dout1_75) FROM=779.9n TO=780.1n

.meas tran Vdout1_76ck56 AVG v(dout1_76) FROM=779.9n TO=780.1n

.meas tran Vdout1_77ck56 AVG v(dout1_77) FROM=779.9n TO=780.1n

.meas tran Vdout1_78ck56 AVG v(dout1_78) FROM=779.9n TO=780.1n

.meas tran Vdout1_79ck56 AVG v(dout1_79) FROM=779.9n TO=780.1n

.meas tran Vdout1_0ck57 AVG v(dout1_0) FROM=789.9n TO=790.1n

.meas tran Vdout1_1ck57 AVG v(dout1_1) FROM=789.9n TO=790.1n

.meas tran Vdout1_2ck57 AVG v(dout1_2) FROM=789.9n TO=790.1n

.meas tran Vdout1_3ck57 AVG v(dout1_3) FROM=789.9n TO=790.1n

.meas tran Vdout1_4ck57 AVG v(dout1_4) FROM=789.9n TO=790.1n

.meas tran Vdout1_5ck57 AVG v(dout1_5) FROM=789.9n TO=790.1n

.meas tran Vdout1_6ck57 AVG v(dout1_6) FROM=789.9n TO=790.1n

.meas tran Vdout1_7ck57 AVG v(dout1_7) FROM=789.9n TO=790.1n

.meas tran Vdout1_8ck57 AVG v(dout1_8) FROM=789.9n TO=790.1n

.meas tran Vdout1_9ck57 AVG v(dout1_9) FROM=789.9n TO=790.1n

.meas tran Vdout1_10ck57 AVG v(dout1_10) FROM=789.9n TO=790.1n

.meas tran Vdout1_11ck57 AVG v(dout1_11) FROM=789.9n TO=790.1n

.meas tran Vdout1_12ck57 AVG v(dout1_12) FROM=789.9n TO=790.1n

.meas tran Vdout1_13ck57 AVG v(dout1_13) FROM=789.9n TO=790.1n

.meas tran Vdout1_14ck57 AVG v(dout1_14) FROM=789.9n TO=790.1n

.meas tran Vdout1_15ck57 AVG v(dout1_15) FROM=789.9n TO=790.1n

.meas tran Vdout1_16ck57 AVG v(dout1_16) FROM=789.9n TO=790.1n

.meas tran Vdout1_17ck57 AVG v(dout1_17) FROM=789.9n TO=790.1n

.meas tran Vdout1_18ck57 AVG v(dout1_18) FROM=789.9n TO=790.1n

.meas tran Vdout1_19ck57 AVG v(dout1_19) FROM=789.9n TO=790.1n

.meas tran Vdout1_20ck57 AVG v(dout1_20) FROM=789.9n TO=790.1n

.meas tran Vdout1_21ck57 AVG v(dout1_21) FROM=789.9n TO=790.1n

.meas tran Vdout1_22ck57 AVG v(dout1_22) FROM=789.9n TO=790.1n

.meas tran Vdout1_23ck57 AVG v(dout1_23) FROM=789.9n TO=790.1n

.meas tran Vdout1_24ck57 AVG v(dout1_24) FROM=789.9n TO=790.1n

.meas tran Vdout1_25ck57 AVG v(dout1_25) FROM=789.9n TO=790.1n

.meas tran Vdout1_26ck57 AVG v(dout1_26) FROM=789.9n TO=790.1n

.meas tran Vdout1_27ck57 AVG v(dout1_27) FROM=789.9n TO=790.1n

.meas tran Vdout1_28ck57 AVG v(dout1_28) FROM=789.9n TO=790.1n

.meas tran Vdout1_29ck57 AVG v(dout1_29) FROM=789.9n TO=790.1n

.meas tran Vdout1_30ck57 AVG v(dout1_30) FROM=789.9n TO=790.1n

.meas tran Vdout1_31ck57 AVG v(dout1_31) FROM=789.9n TO=790.1n

.meas tran Vdout1_32ck57 AVG v(dout1_32) FROM=789.9n TO=790.1n

.meas tran Vdout1_33ck57 AVG v(dout1_33) FROM=789.9n TO=790.1n

.meas tran Vdout1_34ck57 AVG v(dout1_34) FROM=789.9n TO=790.1n

.meas tran Vdout1_35ck57 AVG v(dout1_35) FROM=789.9n TO=790.1n

.meas tran Vdout1_36ck57 AVG v(dout1_36) FROM=789.9n TO=790.1n

.meas tran Vdout1_37ck57 AVG v(dout1_37) FROM=789.9n TO=790.1n

.meas tran Vdout1_38ck57 AVG v(dout1_38) FROM=789.9n TO=790.1n

.meas tran Vdout1_39ck57 AVG v(dout1_39) FROM=789.9n TO=790.1n

.meas tran Vdout1_40ck57 AVG v(dout1_40) FROM=789.9n TO=790.1n

.meas tran Vdout1_41ck57 AVG v(dout1_41) FROM=789.9n TO=790.1n

.meas tran Vdout1_42ck57 AVG v(dout1_42) FROM=789.9n TO=790.1n

.meas tran Vdout1_43ck57 AVG v(dout1_43) FROM=789.9n TO=790.1n

.meas tran Vdout1_44ck57 AVG v(dout1_44) FROM=789.9n TO=790.1n

.meas tran Vdout1_45ck57 AVG v(dout1_45) FROM=789.9n TO=790.1n

.meas tran Vdout1_46ck57 AVG v(dout1_46) FROM=789.9n TO=790.1n

.meas tran Vdout1_47ck57 AVG v(dout1_47) FROM=789.9n TO=790.1n

.meas tran Vdout1_48ck57 AVG v(dout1_48) FROM=789.9n TO=790.1n

.meas tran Vdout1_49ck57 AVG v(dout1_49) FROM=789.9n TO=790.1n

.meas tran Vdout1_50ck57 AVG v(dout1_50) FROM=789.9n TO=790.1n

.meas tran Vdout1_51ck57 AVG v(dout1_51) FROM=789.9n TO=790.1n

.meas tran Vdout1_52ck57 AVG v(dout1_52) FROM=789.9n TO=790.1n

.meas tran Vdout1_53ck57 AVG v(dout1_53) FROM=789.9n TO=790.1n

.meas tran Vdout1_54ck57 AVG v(dout1_54) FROM=789.9n TO=790.1n

.meas tran Vdout1_55ck57 AVG v(dout1_55) FROM=789.9n TO=790.1n

.meas tran Vdout1_56ck57 AVG v(dout1_56) FROM=789.9n TO=790.1n

.meas tran Vdout1_57ck57 AVG v(dout1_57) FROM=789.9n TO=790.1n

.meas tran Vdout1_58ck57 AVG v(dout1_58) FROM=789.9n TO=790.1n

.meas tran Vdout1_59ck57 AVG v(dout1_59) FROM=789.9n TO=790.1n

.meas tran Vdout1_60ck57 AVG v(dout1_60) FROM=789.9n TO=790.1n

.meas tran Vdout1_61ck57 AVG v(dout1_61) FROM=789.9n TO=790.1n

.meas tran Vdout1_62ck57 AVG v(dout1_62) FROM=789.9n TO=790.1n

.meas tran Vdout1_63ck57 AVG v(dout1_63) FROM=789.9n TO=790.1n

.meas tran Vdout1_64ck57 AVG v(dout1_64) FROM=789.9n TO=790.1n

.meas tran Vdout1_65ck57 AVG v(dout1_65) FROM=789.9n TO=790.1n

.meas tran Vdout1_66ck57 AVG v(dout1_66) FROM=789.9n TO=790.1n

.meas tran Vdout1_67ck57 AVG v(dout1_67) FROM=789.9n TO=790.1n

.meas tran Vdout1_68ck57 AVG v(dout1_68) FROM=789.9n TO=790.1n

.meas tran Vdout1_69ck57 AVG v(dout1_69) FROM=789.9n TO=790.1n

.meas tran Vdout1_70ck57 AVG v(dout1_70) FROM=789.9n TO=790.1n

.meas tran Vdout1_71ck57 AVG v(dout1_71) FROM=789.9n TO=790.1n

.meas tran Vdout1_72ck57 AVG v(dout1_72) FROM=789.9n TO=790.1n

.meas tran Vdout1_73ck57 AVG v(dout1_73) FROM=789.9n TO=790.1n

.meas tran Vdout1_74ck57 AVG v(dout1_74) FROM=789.9n TO=790.1n

.meas tran Vdout1_75ck57 AVG v(dout1_75) FROM=789.9n TO=790.1n

.meas tran Vdout1_76ck57 AVG v(dout1_76) FROM=789.9n TO=790.1n

.meas tran Vdout1_77ck57 AVG v(dout1_77) FROM=789.9n TO=790.1n

.meas tran Vdout1_78ck57 AVG v(dout1_78) FROM=789.9n TO=790.1n

.meas tran Vdout1_79ck57 AVG v(dout1_79) FROM=789.9n TO=790.1n

.meas tran Vdout0_0ck58 AVG v(dout0_0) FROM=809.9n TO=810.1n

.meas tran Vdout0_1ck58 AVG v(dout0_1) FROM=809.9n TO=810.1n

.meas tran Vdout0_2ck58 AVG v(dout0_2) FROM=809.9n TO=810.1n

.meas tran Vdout0_3ck58 AVG v(dout0_3) FROM=809.9n TO=810.1n

.meas tran Vdout0_4ck58 AVG v(dout0_4) FROM=809.9n TO=810.1n

.meas tran Vdout0_5ck58 AVG v(dout0_5) FROM=809.9n TO=810.1n

.meas tran Vdout0_6ck58 AVG v(dout0_6) FROM=809.9n TO=810.1n

.meas tran Vdout0_7ck58 AVG v(dout0_7) FROM=809.9n TO=810.1n

.meas tran Vdout0_8ck58 AVG v(dout0_8) FROM=809.9n TO=810.1n

.meas tran Vdout0_9ck58 AVG v(dout0_9) FROM=809.9n TO=810.1n

.meas tran Vdout0_10ck58 AVG v(dout0_10) FROM=809.9n TO=810.1n

.meas tran Vdout0_11ck58 AVG v(dout0_11) FROM=809.9n TO=810.1n

.meas tran Vdout0_12ck58 AVG v(dout0_12) FROM=809.9n TO=810.1n

.meas tran Vdout0_13ck58 AVG v(dout0_13) FROM=809.9n TO=810.1n

.meas tran Vdout0_14ck58 AVG v(dout0_14) FROM=809.9n TO=810.1n

.meas tran Vdout0_15ck58 AVG v(dout0_15) FROM=809.9n TO=810.1n

.meas tran Vdout0_16ck58 AVG v(dout0_16) FROM=809.9n TO=810.1n

.meas tran Vdout0_17ck58 AVG v(dout0_17) FROM=809.9n TO=810.1n

.meas tran Vdout0_18ck58 AVG v(dout0_18) FROM=809.9n TO=810.1n

.meas tran Vdout0_19ck58 AVG v(dout0_19) FROM=809.9n TO=810.1n

.meas tran Vdout0_20ck58 AVG v(dout0_20) FROM=809.9n TO=810.1n

.meas tran Vdout0_21ck58 AVG v(dout0_21) FROM=809.9n TO=810.1n

.meas tran Vdout0_22ck58 AVG v(dout0_22) FROM=809.9n TO=810.1n

.meas tran Vdout0_23ck58 AVG v(dout0_23) FROM=809.9n TO=810.1n

.meas tran Vdout0_24ck58 AVG v(dout0_24) FROM=809.9n TO=810.1n

.meas tran Vdout0_25ck58 AVG v(dout0_25) FROM=809.9n TO=810.1n

.meas tran Vdout0_26ck58 AVG v(dout0_26) FROM=809.9n TO=810.1n

.meas tran Vdout0_27ck58 AVG v(dout0_27) FROM=809.9n TO=810.1n

.meas tran Vdout0_28ck58 AVG v(dout0_28) FROM=809.9n TO=810.1n

.meas tran Vdout0_29ck58 AVG v(dout0_29) FROM=809.9n TO=810.1n

.meas tran Vdout0_30ck58 AVG v(dout0_30) FROM=809.9n TO=810.1n

.meas tran Vdout0_31ck58 AVG v(dout0_31) FROM=809.9n TO=810.1n

.meas tran Vdout0_32ck58 AVG v(dout0_32) FROM=809.9n TO=810.1n

.meas tran Vdout0_33ck58 AVG v(dout0_33) FROM=809.9n TO=810.1n

.meas tran Vdout0_34ck58 AVG v(dout0_34) FROM=809.9n TO=810.1n

.meas tran Vdout0_35ck58 AVG v(dout0_35) FROM=809.9n TO=810.1n

.meas tran Vdout0_36ck58 AVG v(dout0_36) FROM=809.9n TO=810.1n

.meas tran Vdout0_37ck58 AVG v(dout0_37) FROM=809.9n TO=810.1n

.meas tran Vdout0_38ck58 AVG v(dout0_38) FROM=809.9n TO=810.1n

.meas tran Vdout0_39ck58 AVG v(dout0_39) FROM=809.9n TO=810.1n

.meas tran Vdout0_40ck58 AVG v(dout0_40) FROM=809.9n TO=810.1n

.meas tran Vdout0_41ck58 AVG v(dout0_41) FROM=809.9n TO=810.1n

.meas tran Vdout0_42ck58 AVG v(dout0_42) FROM=809.9n TO=810.1n

.meas tran Vdout0_43ck58 AVG v(dout0_43) FROM=809.9n TO=810.1n

.meas tran Vdout0_44ck58 AVG v(dout0_44) FROM=809.9n TO=810.1n

.meas tran Vdout0_45ck58 AVG v(dout0_45) FROM=809.9n TO=810.1n

.meas tran Vdout0_46ck58 AVG v(dout0_46) FROM=809.9n TO=810.1n

.meas tran Vdout0_47ck58 AVG v(dout0_47) FROM=809.9n TO=810.1n

.meas tran Vdout0_48ck58 AVG v(dout0_48) FROM=809.9n TO=810.1n

.meas tran Vdout0_49ck58 AVG v(dout0_49) FROM=809.9n TO=810.1n

.meas tran Vdout0_50ck58 AVG v(dout0_50) FROM=809.9n TO=810.1n

.meas tran Vdout0_51ck58 AVG v(dout0_51) FROM=809.9n TO=810.1n

.meas tran Vdout0_52ck58 AVG v(dout0_52) FROM=809.9n TO=810.1n

.meas tran Vdout0_53ck58 AVG v(dout0_53) FROM=809.9n TO=810.1n

.meas tran Vdout0_54ck58 AVG v(dout0_54) FROM=809.9n TO=810.1n

.meas tran Vdout0_55ck58 AVG v(dout0_55) FROM=809.9n TO=810.1n

.meas tran Vdout0_56ck58 AVG v(dout0_56) FROM=809.9n TO=810.1n

.meas tran Vdout0_57ck58 AVG v(dout0_57) FROM=809.9n TO=810.1n

.meas tran Vdout0_58ck58 AVG v(dout0_58) FROM=809.9n TO=810.1n

.meas tran Vdout0_59ck58 AVG v(dout0_59) FROM=809.9n TO=810.1n

.meas tran Vdout0_60ck58 AVG v(dout0_60) FROM=809.9n TO=810.1n

.meas tran Vdout0_61ck58 AVG v(dout0_61) FROM=809.9n TO=810.1n

.meas tran Vdout0_62ck58 AVG v(dout0_62) FROM=809.9n TO=810.1n

.meas tran Vdout0_63ck58 AVG v(dout0_63) FROM=809.9n TO=810.1n

.meas tran Vdout0_64ck58 AVG v(dout0_64) FROM=809.9n TO=810.1n

.meas tran Vdout0_65ck58 AVG v(dout0_65) FROM=809.9n TO=810.1n

.meas tran Vdout0_66ck58 AVG v(dout0_66) FROM=809.9n TO=810.1n

.meas tran Vdout0_67ck58 AVG v(dout0_67) FROM=809.9n TO=810.1n

.meas tran Vdout0_68ck58 AVG v(dout0_68) FROM=809.9n TO=810.1n

.meas tran Vdout0_69ck58 AVG v(dout0_69) FROM=809.9n TO=810.1n

.meas tran Vdout0_70ck58 AVG v(dout0_70) FROM=809.9n TO=810.1n

.meas tran Vdout0_71ck58 AVG v(dout0_71) FROM=809.9n TO=810.1n

.meas tran Vdout0_72ck58 AVG v(dout0_72) FROM=809.9n TO=810.1n

.meas tran Vdout0_73ck58 AVG v(dout0_73) FROM=809.9n TO=810.1n

.meas tran Vdout0_74ck58 AVG v(dout0_74) FROM=809.9n TO=810.1n

.meas tran Vdout0_75ck58 AVG v(dout0_75) FROM=809.9n TO=810.1n

.meas tran Vdout0_76ck58 AVG v(dout0_76) FROM=809.9n TO=810.1n

.meas tran Vdout0_77ck58 AVG v(dout0_77) FROM=809.9n TO=810.1n

.meas tran Vdout0_78ck58 AVG v(dout0_78) FROM=809.9n TO=810.1n

.meas tran Vdout0_79ck58 AVG v(dout0_79) FROM=809.9n TO=810.1n

.meas tran Vdout1_0ck59 AVG v(dout1_0) FROM=809.9n TO=810.1n

.meas tran Vdout1_1ck59 AVG v(dout1_1) FROM=809.9n TO=810.1n

.meas tran Vdout1_2ck59 AVG v(dout1_2) FROM=809.9n TO=810.1n

.meas tran Vdout1_3ck59 AVG v(dout1_3) FROM=809.9n TO=810.1n

.meas tran Vdout1_4ck59 AVG v(dout1_4) FROM=809.9n TO=810.1n

.meas tran Vdout1_5ck59 AVG v(dout1_5) FROM=809.9n TO=810.1n

.meas tran Vdout1_6ck59 AVG v(dout1_6) FROM=809.9n TO=810.1n

.meas tran Vdout1_7ck59 AVG v(dout1_7) FROM=809.9n TO=810.1n

.meas tran Vdout1_8ck59 AVG v(dout1_8) FROM=809.9n TO=810.1n

.meas tran Vdout1_9ck59 AVG v(dout1_9) FROM=809.9n TO=810.1n

.meas tran Vdout1_10ck59 AVG v(dout1_10) FROM=809.9n TO=810.1n

.meas tran Vdout1_11ck59 AVG v(dout1_11) FROM=809.9n TO=810.1n

.meas tran Vdout1_12ck59 AVG v(dout1_12) FROM=809.9n TO=810.1n

.meas tran Vdout1_13ck59 AVG v(dout1_13) FROM=809.9n TO=810.1n

.meas tran Vdout1_14ck59 AVG v(dout1_14) FROM=809.9n TO=810.1n

.meas tran Vdout1_15ck59 AVG v(dout1_15) FROM=809.9n TO=810.1n

.meas tran Vdout1_16ck59 AVG v(dout1_16) FROM=809.9n TO=810.1n

.meas tran Vdout1_17ck59 AVG v(dout1_17) FROM=809.9n TO=810.1n

.meas tran Vdout1_18ck59 AVG v(dout1_18) FROM=809.9n TO=810.1n

.meas tran Vdout1_19ck59 AVG v(dout1_19) FROM=809.9n TO=810.1n

.meas tran Vdout1_20ck59 AVG v(dout1_20) FROM=809.9n TO=810.1n

.meas tran Vdout1_21ck59 AVG v(dout1_21) FROM=809.9n TO=810.1n

.meas tran Vdout1_22ck59 AVG v(dout1_22) FROM=809.9n TO=810.1n

.meas tran Vdout1_23ck59 AVG v(dout1_23) FROM=809.9n TO=810.1n

.meas tran Vdout1_24ck59 AVG v(dout1_24) FROM=809.9n TO=810.1n

.meas tran Vdout1_25ck59 AVG v(dout1_25) FROM=809.9n TO=810.1n

.meas tran Vdout1_26ck59 AVG v(dout1_26) FROM=809.9n TO=810.1n

.meas tran Vdout1_27ck59 AVG v(dout1_27) FROM=809.9n TO=810.1n

.meas tran Vdout1_28ck59 AVG v(dout1_28) FROM=809.9n TO=810.1n

.meas tran Vdout1_29ck59 AVG v(dout1_29) FROM=809.9n TO=810.1n

.meas tran Vdout1_30ck59 AVG v(dout1_30) FROM=809.9n TO=810.1n

.meas tran Vdout1_31ck59 AVG v(dout1_31) FROM=809.9n TO=810.1n

.meas tran Vdout1_32ck59 AVG v(dout1_32) FROM=809.9n TO=810.1n

.meas tran Vdout1_33ck59 AVG v(dout1_33) FROM=809.9n TO=810.1n

.meas tran Vdout1_34ck59 AVG v(dout1_34) FROM=809.9n TO=810.1n

.meas tran Vdout1_35ck59 AVG v(dout1_35) FROM=809.9n TO=810.1n

.meas tran Vdout1_36ck59 AVG v(dout1_36) FROM=809.9n TO=810.1n

.meas tran Vdout1_37ck59 AVG v(dout1_37) FROM=809.9n TO=810.1n

.meas tran Vdout1_38ck59 AVG v(dout1_38) FROM=809.9n TO=810.1n

.meas tran Vdout1_39ck59 AVG v(dout1_39) FROM=809.9n TO=810.1n

.meas tran Vdout1_40ck59 AVG v(dout1_40) FROM=809.9n TO=810.1n

.meas tran Vdout1_41ck59 AVG v(dout1_41) FROM=809.9n TO=810.1n

.meas tran Vdout1_42ck59 AVG v(dout1_42) FROM=809.9n TO=810.1n

.meas tran Vdout1_43ck59 AVG v(dout1_43) FROM=809.9n TO=810.1n

.meas tran Vdout1_44ck59 AVG v(dout1_44) FROM=809.9n TO=810.1n

.meas tran Vdout1_45ck59 AVG v(dout1_45) FROM=809.9n TO=810.1n

.meas tran Vdout1_46ck59 AVG v(dout1_46) FROM=809.9n TO=810.1n

.meas tran Vdout1_47ck59 AVG v(dout1_47) FROM=809.9n TO=810.1n

.meas tran Vdout1_48ck59 AVG v(dout1_48) FROM=809.9n TO=810.1n

.meas tran Vdout1_49ck59 AVG v(dout1_49) FROM=809.9n TO=810.1n

.meas tran Vdout1_50ck59 AVG v(dout1_50) FROM=809.9n TO=810.1n

.meas tran Vdout1_51ck59 AVG v(dout1_51) FROM=809.9n TO=810.1n

.meas tran Vdout1_52ck59 AVG v(dout1_52) FROM=809.9n TO=810.1n

.meas tran Vdout1_53ck59 AVG v(dout1_53) FROM=809.9n TO=810.1n

.meas tran Vdout1_54ck59 AVG v(dout1_54) FROM=809.9n TO=810.1n

.meas tran Vdout1_55ck59 AVG v(dout1_55) FROM=809.9n TO=810.1n

.meas tran Vdout1_56ck59 AVG v(dout1_56) FROM=809.9n TO=810.1n

.meas tran Vdout1_57ck59 AVG v(dout1_57) FROM=809.9n TO=810.1n

.meas tran Vdout1_58ck59 AVG v(dout1_58) FROM=809.9n TO=810.1n

.meas tran Vdout1_59ck59 AVG v(dout1_59) FROM=809.9n TO=810.1n

.meas tran Vdout1_60ck59 AVG v(dout1_60) FROM=809.9n TO=810.1n

.meas tran Vdout1_61ck59 AVG v(dout1_61) FROM=809.9n TO=810.1n

.meas tran Vdout1_62ck59 AVG v(dout1_62) FROM=809.9n TO=810.1n

.meas tran Vdout1_63ck59 AVG v(dout1_63) FROM=809.9n TO=810.1n

.meas tran Vdout1_64ck59 AVG v(dout1_64) FROM=809.9n TO=810.1n

.meas tran Vdout1_65ck59 AVG v(dout1_65) FROM=809.9n TO=810.1n

.meas tran Vdout1_66ck59 AVG v(dout1_66) FROM=809.9n TO=810.1n

.meas tran Vdout1_67ck59 AVG v(dout1_67) FROM=809.9n TO=810.1n

.meas tran Vdout1_68ck59 AVG v(dout1_68) FROM=809.9n TO=810.1n

.meas tran Vdout1_69ck59 AVG v(dout1_69) FROM=809.9n TO=810.1n

.meas tran Vdout1_70ck59 AVG v(dout1_70) FROM=809.9n TO=810.1n

.meas tran Vdout1_71ck59 AVG v(dout1_71) FROM=809.9n TO=810.1n

.meas tran Vdout1_72ck59 AVG v(dout1_72) FROM=809.9n TO=810.1n

.meas tran Vdout1_73ck59 AVG v(dout1_73) FROM=809.9n TO=810.1n

.meas tran Vdout1_74ck59 AVG v(dout1_74) FROM=809.9n TO=810.1n

.meas tran Vdout1_75ck59 AVG v(dout1_75) FROM=809.9n TO=810.1n

.meas tran Vdout1_76ck59 AVG v(dout1_76) FROM=809.9n TO=810.1n

.meas tran Vdout1_77ck59 AVG v(dout1_77) FROM=809.9n TO=810.1n

.meas tran Vdout1_78ck59 AVG v(dout1_78) FROM=809.9n TO=810.1n

.meas tran Vdout1_79ck59 AVG v(dout1_79) FROM=809.9n TO=810.1n

.meas tran Vdout1_0ck60 AVG v(dout1_0) FROM=819.9n TO=820.1n

.meas tran Vdout1_1ck60 AVG v(dout1_1) FROM=819.9n TO=820.1n

.meas tran Vdout1_2ck60 AVG v(dout1_2) FROM=819.9n TO=820.1n

.meas tran Vdout1_3ck60 AVG v(dout1_3) FROM=819.9n TO=820.1n

.meas tran Vdout1_4ck60 AVG v(dout1_4) FROM=819.9n TO=820.1n

.meas tran Vdout1_5ck60 AVG v(dout1_5) FROM=819.9n TO=820.1n

.meas tran Vdout1_6ck60 AVG v(dout1_6) FROM=819.9n TO=820.1n

.meas tran Vdout1_7ck60 AVG v(dout1_7) FROM=819.9n TO=820.1n

.meas tran Vdout1_8ck60 AVG v(dout1_8) FROM=819.9n TO=820.1n

.meas tran Vdout1_9ck60 AVG v(dout1_9) FROM=819.9n TO=820.1n

.meas tran Vdout1_10ck60 AVG v(dout1_10) FROM=819.9n TO=820.1n

.meas tran Vdout1_11ck60 AVG v(dout1_11) FROM=819.9n TO=820.1n

.meas tran Vdout1_12ck60 AVG v(dout1_12) FROM=819.9n TO=820.1n

.meas tran Vdout1_13ck60 AVG v(dout1_13) FROM=819.9n TO=820.1n

.meas tran Vdout1_14ck60 AVG v(dout1_14) FROM=819.9n TO=820.1n

.meas tran Vdout1_15ck60 AVG v(dout1_15) FROM=819.9n TO=820.1n

.meas tran Vdout1_16ck60 AVG v(dout1_16) FROM=819.9n TO=820.1n

.meas tran Vdout1_17ck60 AVG v(dout1_17) FROM=819.9n TO=820.1n

.meas tran Vdout1_18ck60 AVG v(dout1_18) FROM=819.9n TO=820.1n

.meas tran Vdout1_19ck60 AVG v(dout1_19) FROM=819.9n TO=820.1n

.meas tran Vdout1_20ck60 AVG v(dout1_20) FROM=819.9n TO=820.1n

.meas tran Vdout1_21ck60 AVG v(dout1_21) FROM=819.9n TO=820.1n

.meas tran Vdout1_22ck60 AVG v(dout1_22) FROM=819.9n TO=820.1n

.meas tran Vdout1_23ck60 AVG v(dout1_23) FROM=819.9n TO=820.1n

.meas tran Vdout1_24ck60 AVG v(dout1_24) FROM=819.9n TO=820.1n

.meas tran Vdout1_25ck60 AVG v(dout1_25) FROM=819.9n TO=820.1n

.meas tran Vdout1_26ck60 AVG v(dout1_26) FROM=819.9n TO=820.1n

.meas tran Vdout1_27ck60 AVG v(dout1_27) FROM=819.9n TO=820.1n

.meas tran Vdout1_28ck60 AVG v(dout1_28) FROM=819.9n TO=820.1n

.meas tran Vdout1_29ck60 AVG v(dout1_29) FROM=819.9n TO=820.1n

.meas tran Vdout1_30ck60 AVG v(dout1_30) FROM=819.9n TO=820.1n

.meas tran Vdout1_31ck60 AVG v(dout1_31) FROM=819.9n TO=820.1n

.meas tran Vdout1_32ck60 AVG v(dout1_32) FROM=819.9n TO=820.1n

.meas tran Vdout1_33ck60 AVG v(dout1_33) FROM=819.9n TO=820.1n

.meas tran Vdout1_34ck60 AVG v(dout1_34) FROM=819.9n TO=820.1n

.meas tran Vdout1_35ck60 AVG v(dout1_35) FROM=819.9n TO=820.1n

.meas tran Vdout1_36ck60 AVG v(dout1_36) FROM=819.9n TO=820.1n

.meas tran Vdout1_37ck60 AVG v(dout1_37) FROM=819.9n TO=820.1n

.meas tran Vdout1_38ck60 AVG v(dout1_38) FROM=819.9n TO=820.1n

.meas tran Vdout1_39ck60 AVG v(dout1_39) FROM=819.9n TO=820.1n

.meas tran Vdout1_40ck60 AVG v(dout1_40) FROM=819.9n TO=820.1n

.meas tran Vdout1_41ck60 AVG v(dout1_41) FROM=819.9n TO=820.1n

.meas tran Vdout1_42ck60 AVG v(dout1_42) FROM=819.9n TO=820.1n

.meas tran Vdout1_43ck60 AVG v(dout1_43) FROM=819.9n TO=820.1n

.meas tran Vdout1_44ck60 AVG v(dout1_44) FROM=819.9n TO=820.1n

.meas tran Vdout1_45ck60 AVG v(dout1_45) FROM=819.9n TO=820.1n

.meas tran Vdout1_46ck60 AVG v(dout1_46) FROM=819.9n TO=820.1n

.meas tran Vdout1_47ck60 AVG v(dout1_47) FROM=819.9n TO=820.1n

.meas tran Vdout1_48ck60 AVG v(dout1_48) FROM=819.9n TO=820.1n

.meas tran Vdout1_49ck60 AVG v(dout1_49) FROM=819.9n TO=820.1n

.meas tran Vdout1_50ck60 AVG v(dout1_50) FROM=819.9n TO=820.1n

.meas tran Vdout1_51ck60 AVG v(dout1_51) FROM=819.9n TO=820.1n

.meas tran Vdout1_52ck60 AVG v(dout1_52) FROM=819.9n TO=820.1n

.meas tran Vdout1_53ck60 AVG v(dout1_53) FROM=819.9n TO=820.1n

.meas tran Vdout1_54ck60 AVG v(dout1_54) FROM=819.9n TO=820.1n

.meas tran Vdout1_55ck60 AVG v(dout1_55) FROM=819.9n TO=820.1n

.meas tran Vdout1_56ck60 AVG v(dout1_56) FROM=819.9n TO=820.1n

.meas tran Vdout1_57ck60 AVG v(dout1_57) FROM=819.9n TO=820.1n

.meas tran Vdout1_58ck60 AVG v(dout1_58) FROM=819.9n TO=820.1n

.meas tran Vdout1_59ck60 AVG v(dout1_59) FROM=819.9n TO=820.1n

.meas tran Vdout1_60ck60 AVG v(dout1_60) FROM=819.9n TO=820.1n

.meas tran Vdout1_61ck60 AVG v(dout1_61) FROM=819.9n TO=820.1n

.meas tran Vdout1_62ck60 AVG v(dout1_62) FROM=819.9n TO=820.1n

.meas tran Vdout1_63ck60 AVG v(dout1_63) FROM=819.9n TO=820.1n

.meas tran Vdout1_64ck60 AVG v(dout1_64) FROM=819.9n TO=820.1n

.meas tran Vdout1_65ck60 AVG v(dout1_65) FROM=819.9n TO=820.1n

.meas tran Vdout1_66ck60 AVG v(dout1_66) FROM=819.9n TO=820.1n

.meas tran Vdout1_67ck60 AVG v(dout1_67) FROM=819.9n TO=820.1n

.meas tran Vdout1_68ck60 AVG v(dout1_68) FROM=819.9n TO=820.1n

.meas tran Vdout1_69ck60 AVG v(dout1_69) FROM=819.9n TO=820.1n

.meas tran Vdout1_70ck60 AVG v(dout1_70) FROM=819.9n TO=820.1n

.meas tran Vdout1_71ck60 AVG v(dout1_71) FROM=819.9n TO=820.1n

.meas tran Vdout1_72ck60 AVG v(dout1_72) FROM=819.9n TO=820.1n

.meas tran Vdout1_73ck60 AVG v(dout1_73) FROM=819.9n TO=820.1n

.meas tran Vdout1_74ck60 AVG v(dout1_74) FROM=819.9n TO=820.1n

.meas tran Vdout1_75ck60 AVG v(dout1_75) FROM=819.9n TO=820.1n

.meas tran Vdout1_76ck60 AVG v(dout1_76) FROM=819.9n TO=820.1n

.meas tran Vdout1_77ck60 AVG v(dout1_77) FROM=819.9n TO=820.1n

.meas tran Vdout1_78ck60 AVG v(dout1_78) FROM=819.9n TO=820.1n

.meas tran Vdout1_79ck60 AVG v(dout1_79) FROM=819.9n TO=820.1n

.meas tran Vdout0_0ck61 AVG v(dout0_0) FROM=829.9n TO=830.1n

.meas tran Vdout0_1ck61 AVG v(dout0_1) FROM=829.9n TO=830.1n

.meas tran Vdout0_2ck61 AVG v(dout0_2) FROM=829.9n TO=830.1n

.meas tran Vdout0_3ck61 AVG v(dout0_3) FROM=829.9n TO=830.1n

.meas tran Vdout0_4ck61 AVG v(dout0_4) FROM=829.9n TO=830.1n

.meas tran Vdout0_5ck61 AVG v(dout0_5) FROM=829.9n TO=830.1n

.meas tran Vdout0_6ck61 AVG v(dout0_6) FROM=829.9n TO=830.1n

.meas tran Vdout0_7ck61 AVG v(dout0_7) FROM=829.9n TO=830.1n

.meas tran Vdout0_8ck61 AVG v(dout0_8) FROM=829.9n TO=830.1n

.meas tran Vdout0_9ck61 AVG v(dout0_9) FROM=829.9n TO=830.1n

.meas tran Vdout0_10ck61 AVG v(dout0_10) FROM=829.9n TO=830.1n

.meas tran Vdout0_11ck61 AVG v(dout0_11) FROM=829.9n TO=830.1n

.meas tran Vdout0_12ck61 AVG v(dout0_12) FROM=829.9n TO=830.1n

.meas tran Vdout0_13ck61 AVG v(dout0_13) FROM=829.9n TO=830.1n

.meas tran Vdout0_14ck61 AVG v(dout0_14) FROM=829.9n TO=830.1n

.meas tran Vdout0_15ck61 AVG v(dout0_15) FROM=829.9n TO=830.1n

.meas tran Vdout0_16ck61 AVG v(dout0_16) FROM=829.9n TO=830.1n

.meas tran Vdout0_17ck61 AVG v(dout0_17) FROM=829.9n TO=830.1n

.meas tran Vdout0_18ck61 AVG v(dout0_18) FROM=829.9n TO=830.1n

.meas tran Vdout0_19ck61 AVG v(dout0_19) FROM=829.9n TO=830.1n

.meas tran Vdout0_20ck61 AVG v(dout0_20) FROM=829.9n TO=830.1n

.meas tran Vdout0_21ck61 AVG v(dout0_21) FROM=829.9n TO=830.1n

.meas tran Vdout0_22ck61 AVG v(dout0_22) FROM=829.9n TO=830.1n

.meas tran Vdout0_23ck61 AVG v(dout0_23) FROM=829.9n TO=830.1n

.meas tran Vdout0_24ck61 AVG v(dout0_24) FROM=829.9n TO=830.1n

.meas tran Vdout0_25ck61 AVG v(dout0_25) FROM=829.9n TO=830.1n

.meas tran Vdout0_26ck61 AVG v(dout0_26) FROM=829.9n TO=830.1n

.meas tran Vdout0_27ck61 AVG v(dout0_27) FROM=829.9n TO=830.1n

.meas tran Vdout0_28ck61 AVG v(dout0_28) FROM=829.9n TO=830.1n

.meas tran Vdout0_29ck61 AVG v(dout0_29) FROM=829.9n TO=830.1n

.meas tran Vdout0_30ck61 AVG v(dout0_30) FROM=829.9n TO=830.1n

.meas tran Vdout0_31ck61 AVG v(dout0_31) FROM=829.9n TO=830.1n

.meas tran Vdout0_32ck61 AVG v(dout0_32) FROM=829.9n TO=830.1n

.meas tran Vdout0_33ck61 AVG v(dout0_33) FROM=829.9n TO=830.1n

.meas tran Vdout0_34ck61 AVG v(dout0_34) FROM=829.9n TO=830.1n

.meas tran Vdout0_35ck61 AVG v(dout0_35) FROM=829.9n TO=830.1n

.meas tran Vdout0_36ck61 AVG v(dout0_36) FROM=829.9n TO=830.1n

.meas tran Vdout0_37ck61 AVG v(dout0_37) FROM=829.9n TO=830.1n

.meas tran Vdout0_38ck61 AVG v(dout0_38) FROM=829.9n TO=830.1n

.meas tran Vdout0_39ck61 AVG v(dout0_39) FROM=829.9n TO=830.1n

.meas tran Vdout0_40ck61 AVG v(dout0_40) FROM=829.9n TO=830.1n

.meas tran Vdout0_41ck61 AVG v(dout0_41) FROM=829.9n TO=830.1n

.meas tran Vdout0_42ck61 AVG v(dout0_42) FROM=829.9n TO=830.1n

.meas tran Vdout0_43ck61 AVG v(dout0_43) FROM=829.9n TO=830.1n

.meas tran Vdout0_44ck61 AVG v(dout0_44) FROM=829.9n TO=830.1n

.meas tran Vdout0_45ck61 AVG v(dout0_45) FROM=829.9n TO=830.1n

.meas tran Vdout0_46ck61 AVG v(dout0_46) FROM=829.9n TO=830.1n

.meas tran Vdout0_47ck61 AVG v(dout0_47) FROM=829.9n TO=830.1n

.meas tran Vdout0_48ck61 AVG v(dout0_48) FROM=829.9n TO=830.1n

.meas tran Vdout0_49ck61 AVG v(dout0_49) FROM=829.9n TO=830.1n

.meas tran Vdout0_50ck61 AVG v(dout0_50) FROM=829.9n TO=830.1n

.meas tran Vdout0_51ck61 AVG v(dout0_51) FROM=829.9n TO=830.1n

.meas tran Vdout0_52ck61 AVG v(dout0_52) FROM=829.9n TO=830.1n

.meas tran Vdout0_53ck61 AVG v(dout0_53) FROM=829.9n TO=830.1n

.meas tran Vdout0_54ck61 AVG v(dout0_54) FROM=829.9n TO=830.1n

.meas tran Vdout0_55ck61 AVG v(dout0_55) FROM=829.9n TO=830.1n

.meas tran Vdout0_56ck61 AVG v(dout0_56) FROM=829.9n TO=830.1n

.meas tran Vdout0_57ck61 AVG v(dout0_57) FROM=829.9n TO=830.1n

.meas tran Vdout0_58ck61 AVG v(dout0_58) FROM=829.9n TO=830.1n

.meas tran Vdout0_59ck61 AVG v(dout0_59) FROM=829.9n TO=830.1n

.meas tran Vdout0_60ck61 AVG v(dout0_60) FROM=829.9n TO=830.1n

.meas tran Vdout0_61ck61 AVG v(dout0_61) FROM=829.9n TO=830.1n

.meas tran Vdout0_62ck61 AVG v(dout0_62) FROM=829.9n TO=830.1n

.meas tran Vdout0_63ck61 AVG v(dout0_63) FROM=829.9n TO=830.1n

.meas tran Vdout0_64ck61 AVG v(dout0_64) FROM=829.9n TO=830.1n

.meas tran Vdout0_65ck61 AVG v(dout0_65) FROM=829.9n TO=830.1n

.meas tran Vdout0_66ck61 AVG v(dout0_66) FROM=829.9n TO=830.1n

.meas tran Vdout0_67ck61 AVG v(dout0_67) FROM=829.9n TO=830.1n

.meas tran Vdout0_68ck61 AVG v(dout0_68) FROM=829.9n TO=830.1n

.meas tran Vdout0_69ck61 AVG v(dout0_69) FROM=829.9n TO=830.1n

.meas tran Vdout0_70ck61 AVG v(dout0_70) FROM=829.9n TO=830.1n

.meas tran Vdout0_71ck61 AVG v(dout0_71) FROM=829.9n TO=830.1n

.meas tran Vdout0_72ck61 AVG v(dout0_72) FROM=829.9n TO=830.1n

.meas tran Vdout0_73ck61 AVG v(dout0_73) FROM=829.9n TO=830.1n

.meas tran Vdout0_74ck61 AVG v(dout0_74) FROM=829.9n TO=830.1n

.meas tran Vdout0_75ck61 AVG v(dout0_75) FROM=829.9n TO=830.1n

.meas tran Vdout0_76ck61 AVG v(dout0_76) FROM=829.9n TO=830.1n

.meas tran Vdout0_77ck61 AVG v(dout0_77) FROM=829.9n TO=830.1n

.meas tran Vdout0_78ck61 AVG v(dout0_78) FROM=829.9n TO=830.1n

.meas tran Vdout0_79ck61 AVG v(dout0_79) FROM=829.9n TO=830.1n

.meas tran Vdout1_0ck62 AVG v(dout1_0) FROM=829.9n TO=830.1n

.meas tran Vdout1_1ck62 AVG v(dout1_1) FROM=829.9n TO=830.1n

.meas tran Vdout1_2ck62 AVG v(dout1_2) FROM=829.9n TO=830.1n

.meas tran Vdout1_3ck62 AVG v(dout1_3) FROM=829.9n TO=830.1n

.meas tran Vdout1_4ck62 AVG v(dout1_4) FROM=829.9n TO=830.1n

.meas tran Vdout1_5ck62 AVG v(dout1_5) FROM=829.9n TO=830.1n

.meas tran Vdout1_6ck62 AVG v(dout1_6) FROM=829.9n TO=830.1n

.meas tran Vdout1_7ck62 AVG v(dout1_7) FROM=829.9n TO=830.1n

.meas tran Vdout1_8ck62 AVG v(dout1_8) FROM=829.9n TO=830.1n

.meas tran Vdout1_9ck62 AVG v(dout1_9) FROM=829.9n TO=830.1n

.meas tran Vdout1_10ck62 AVG v(dout1_10) FROM=829.9n TO=830.1n

.meas tran Vdout1_11ck62 AVG v(dout1_11) FROM=829.9n TO=830.1n

.meas tran Vdout1_12ck62 AVG v(dout1_12) FROM=829.9n TO=830.1n

.meas tran Vdout1_13ck62 AVG v(dout1_13) FROM=829.9n TO=830.1n

.meas tran Vdout1_14ck62 AVG v(dout1_14) FROM=829.9n TO=830.1n

.meas tran Vdout1_15ck62 AVG v(dout1_15) FROM=829.9n TO=830.1n

.meas tran Vdout1_16ck62 AVG v(dout1_16) FROM=829.9n TO=830.1n

.meas tran Vdout1_17ck62 AVG v(dout1_17) FROM=829.9n TO=830.1n

.meas tran Vdout1_18ck62 AVG v(dout1_18) FROM=829.9n TO=830.1n

.meas tran Vdout1_19ck62 AVG v(dout1_19) FROM=829.9n TO=830.1n

.meas tran Vdout1_20ck62 AVG v(dout1_20) FROM=829.9n TO=830.1n

.meas tran Vdout1_21ck62 AVG v(dout1_21) FROM=829.9n TO=830.1n

.meas tran Vdout1_22ck62 AVG v(dout1_22) FROM=829.9n TO=830.1n

.meas tran Vdout1_23ck62 AVG v(dout1_23) FROM=829.9n TO=830.1n

.meas tran Vdout1_24ck62 AVG v(dout1_24) FROM=829.9n TO=830.1n

.meas tran Vdout1_25ck62 AVG v(dout1_25) FROM=829.9n TO=830.1n

.meas tran Vdout1_26ck62 AVG v(dout1_26) FROM=829.9n TO=830.1n

.meas tran Vdout1_27ck62 AVG v(dout1_27) FROM=829.9n TO=830.1n

.meas tran Vdout1_28ck62 AVG v(dout1_28) FROM=829.9n TO=830.1n

.meas tran Vdout1_29ck62 AVG v(dout1_29) FROM=829.9n TO=830.1n

.meas tran Vdout1_30ck62 AVG v(dout1_30) FROM=829.9n TO=830.1n

.meas tran Vdout1_31ck62 AVG v(dout1_31) FROM=829.9n TO=830.1n

.meas tran Vdout1_32ck62 AVG v(dout1_32) FROM=829.9n TO=830.1n

.meas tran Vdout1_33ck62 AVG v(dout1_33) FROM=829.9n TO=830.1n

.meas tran Vdout1_34ck62 AVG v(dout1_34) FROM=829.9n TO=830.1n

.meas tran Vdout1_35ck62 AVG v(dout1_35) FROM=829.9n TO=830.1n

.meas tran Vdout1_36ck62 AVG v(dout1_36) FROM=829.9n TO=830.1n

.meas tran Vdout1_37ck62 AVG v(dout1_37) FROM=829.9n TO=830.1n

.meas tran Vdout1_38ck62 AVG v(dout1_38) FROM=829.9n TO=830.1n

.meas tran Vdout1_39ck62 AVG v(dout1_39) FROM=829.9n TO=830.1n

.meas tran Vdout1_40ck62 AVG v(dout1_40) FROM=829.9n TO=830.1n

.meas tran Vdout1_41ck62 AVG v(dout1_41) FROM=829.9n TO=830.1n

.meas tran Vdout1_42ck62 AVG v(dout1_42) FROM=829.9n TO=830.1n

.meas tran Vdout1_43ck62 AVG v(dout1_43) FROM=829.9n TO=830.1n

.meas tran Vdout1_44ck62 AVG v(dout1_44) FROM=829.9n TO=830.1n

.meas tran Vdout1_45ck62 AVG v(dout1_45) FROM=829.9n TO=830.1n

.meas tran Vdout1_46ck62 AVG v(dout1_46) FROM=829.9n TO=830.1n

.meas tran Vdout1_47ck62 AVG v(dout1_47) FROM=829.9n TO=830.1n

.meas tran Vdout1_48ck62 AVG v(dout1_48) FROM=829.9n TO=830.1n

.meas tran Vdout1_49ck62 AVG v(dout1_49) FROM=829.9n TO=830.1n

.meas tran Vdout1_50ck62 AVG v(dout1_50) FROM=829.9n TO=830.1n

.meas tran Vdout1_51ck62 AVG v(dout1_51) FROM=829.9n TO=830.1n

.meas tran Vdout1_52ck62 AVG v(dout1_52) FROM=829.9n TO=830.1n

.meas tran Vdout1_53ck62 AVG v(dout1_53) FROM=829.9n TO=830.1n

.meas tran Vdout1_54ck62 AVG v(dout1_54) FROM=829.9n TO=830.1n

.meas tran Vdout1_55ck62 AVG v(dout1_55) FROM=829.9n TO=830.1n

.meas tran Vdout1_56ck62 AVG v(dout1_56) FROM=829.9n TO=830.1n

.meas tran Vdout1_57ck62 AVG v(dout1_57) FROM=829.9n TO=830.1n

.meas tran Vdout1_58ck62 AVG v(dout1_58) FROM=829.9n TO=830.1n

.meas tran Vdout1_59ck62 AVG v(dout1_59) FROM=829.9n TO=830.1n

.meas tran Vdout1_60ck62 AVG v(dout1_60) FROM=829.9n TO=830.1n

.meas tran Vdout1_61ck62 AVG v(dout1_61) FROM=829.9n TO=830.1n

.meas tran Vdout1_62ck62 AVG v(dout1_62) FROM=829.9n TO=830.1n

.meas tran Vdout1_63ck62 AVG v(dout1_63) FROM=829.9n TO=830.1n

.meas tran Vdout1_64ck62 AVG v(dout1_64) FROM=829.9n TO=830.1n

.meas tran Vdout1_65ck62 AVG v(dout1_65) FROM=829.9n TO=830.1n

.meas tran Vdout1_66ck62 AVG v(dout1_66) FROM=829.9n TO=830.1n

.meas tran Vdout1_67ck62 AVG v(dout1_67) FROM=829.9n TO=830.1n

.meas tran Vdout1_68ck62 AVG v(dout1_68) FROM=829.9n TO=830.1n

.meas tran Vdout1_69ck62 AVG v(dout1_69) FROM=829.9n TO=830.1n

.meas tran Vdout1_70ck62 AVG v(dout1_70) FROM=829.9n TO=830.1n

.meas tran Vdout1_71ck62 AVG v(dout1_71) FROM=829.9n TO=830.1n

.meas tran Vdout1_72ck62 AVG v(dout1_72) FROM=829.9n TO=830.1n

.meas tran Vdout1_73ck62 AVG v(dout1_73) FROM=829.9n TO=830.1n

.meas tran Vdout1_74ck62 AVG v(dout1_74) FROM=829.9n TO=830.1n

.meas tran Vdout1_75ck62 AVG v(dout1_75) FROM=829.9n TO=830.1n

.meas tran Vdout1_76ck62 AVG v(dout1_76) FROM=829.9n TO=830.1n

.meas tran Vdout1_77ck62 AVG v(dout1_77) FROM=829.9n TO=830.1n

.meas tran Vdout1_78ck62 AVG v(dout1_78) FROM=829.9n TO=830.1n

.meas tran Vdout1_79ck62 AVG v(dout1_79) FROM=829.9n TO=830.1n

.meas tran Vdout1_0ck63 AVG v(dout1_0) FROM=839.9n TO=840.1n

.meas tran Vdout1_1ck63 AVG v(dout1_1) FROM=839.9n TO=840.1n

.meas tran Vdout1_2ck63 AVG v(dout1_2) FROM=839.9n TO=840.1n

.meas tran Vdout1_3ck63 AVG v(dout1_3) FROM=839.9n TO=840.1n

.meas tran Vdout1_4ck63 AVG v(dout1_4) FROM=839.9n TO=840.1n

.meas tran Vdout1_5ck63 AVG v(dout1_5) FROM=839.9n TO=840.1n

.meas tran Vdout1_6ck63 AVG v(dout1_6) FROM=839.9n TO=840.1n

.meas tran Vdout1_7ck63 AVG v(dout1_7) FROM=839.9n TO=840.1n

.meas tran Vdout1_8ck63 AVG v(dout1_8) FROM=839.9n TO=840.1n

.meas tran Vdout1_9ck63 AVG v(dout1_9) FROM=839.9n TO=840.1n

.meas tran Vdout1_10ck63 AVG v(dout1_10) FROM=839.9n TO=840.1n

.meas tran Vdout1_11ck63 AVG v(dout1_11) FROM=839.9n TO=840.1n

.meas tran Vdout1_12ck63 AVG v(dout1_12) FROM=839.9n TO=840.1n

.meas tran Vdout1_13ck63 AVG v(dout1_13) FROM=839.9n TO=840.1n

.meas tran Vdout1_14ck63 AVG v(dout1_14) FROM=839.9n TO=840.1n

.meas tran Vdout1_15ck63 AVG v(dout1_15) FROM=839.9n TO=840.1n

.meas tran Vdout1_16ck63 AVG v(dout1_16) FROM=839.9n TO=840.1n

.meas tran Vdout1_17ck63 AVG v(dout1_17) FROM=839.9n TO=840.1n

.meas tran Vdout1_18ck63 AVG v(dout1_18) FROM=839.9n TO=840.1n

.meas tran Vdout1_19ck63 AVG v(dout1_19) FROM=839.9n TO=840.1n

.meas tran Vdout1_20ck63 AVG v(dout1_20) FROM=839.9n TO=840.1n

.meas tran Vdout1_21ck63 AVG v(dout1_21) FROM=839.9n TO=840.1n

.meas tran Vdout1_22ck63 AVG v(dout1_22) FROM=839.9n TO=840.1n

.meas tran Vdout1_23ck63 AVG v(dout1_23) FROM=839.9n TO=840.1n

.meas tran Vdout1_24ck63 AVG v(dout1_24) FROM=839.9n TO=840.1n

.meas tran Vdout1_25ck63 AVG v(dout1_25) FROM=839.9n TO=840.1n

.meas tran Vdout1_26ck63 AVG v(dout1_26) FROM=839.9n TO=840.1n

.meas tran Vdout1_27ck63 AVG v(dout1_27) FROM=839.9n TO=840.1n

.meas tran Vdout1_28ck63 AVG v(dout1_28) FROM=839.9n TO=840.1n

.meas tran Vdout1_29ck63 AVG v(dout1_29) FROM=839.9n TO=840.1n

.meas tran Vdout1_30ck63 AVG v(dout1_30) FROM=839.9n TO=840.1n

.meas tran Vdout1_31ck63 AVG v(dout1_31) FROM=839.9n TO=840.1n

.meas tran Vdout1_32ck63 AVG v(dout1_32) FROM=839.9n TO=840.1n

.meas tran Vdout1_33ck63 AVG v(dout1_33) FROM=839.9n TO=840.1n

.meas tran Vdout1_34ck63 AVG v(dout1_34) FROM=839.9n TO=840.1n

.meas tran Vdout1_35ck63 AVG v(dout1_35) FROM=839.9n TO=840.1n

.meas tran Vdout1_36ck63 AVG v(dout1_36) FROM=839.9n TO=840.1n

.meas tran Vdout1_37ck63 AVG v(dout1_37) FROM=839.9n TO=840.1n

.meas tran Vdout1_38ck63 AVG v(dout1_38) FROM=839.9n TO=840.1n

.meas tran Vdout1_39ck63 AVG v(dout1_39) FROM=839.9n TO=840.1n

.meas tran Vdout1_40ck63 AVG v(dout1_40) FROM=839.9n TO=840.1n

.meas tran Vdout1_41ck63 AVG v(dout1_41) FROM=839.9n TO=840.1n

.meas tran Vdout1_42ck63 AVG v(dout1_42) FROM=839.9n TO=840.1n

.meas tran Vdout1_43ck63 AVG v(dout1_43) FROM=839.9n TO=840.1n

.meas tran Vdout1_44ck63 AVG v(dout1_44) FROM=839.9n TO=840.1n

.meas tran Vdout1_45ck63 AVG v(dout1_45) FROM=839.9n TO=840.1n

.meas tran Vdout1_46ck63 AVG v(dout1_46) FROM=839.9n TO=840.1n

.meas tran Vdout1_47ck63 AVG v(dout1_47) FROM=839.9n TO=840.1n

.meas tran Vdout1_48ck63 AVG v(dout1_48) FROM=839.9n TO=840.1n

.meas tran Vdout1_49ck63 AVG v(dout1_49) FROM=839.9n TO=840.1n

.meas tran Vdout1_50ck63 AVG v(dout1_50) FROM=839.9n TO=840.1n

.meas tran Vdout1_51ck63 AVG v(dout1_51) FROM=839.9n TO=840.1n

.meas tran Vdout1_52ck63 AVG v(dout1_52) FROM=839.9n TO=840.1n

.meas tran Vdout1_53ck63 AVG v(dout1_53) FROM=839.9n TO=840.1n

.meas tran Vdout1_54ck63 AVG v(dout1_54) FROM=839.9n TO=840.1n

.meas tran Vdout1_55ck63 AVG v(dout1_55) FROM=839.9n TO=840.1n

.meas tran Vdout1_56ck63 AVG v(dout1_56) FROM=839.9n TO=840.1n

.meas tran Vdout1_57ck63 AVG v(dout1_57) FROM=839.9n TO=840.1n

.meas tran Vdout1_58ck63 AVG v(dout1_58) FROM=839.9n TO=840.1n

.meas tran Vdout1_59ck63 AVG v(dout1_59) FROM=839.9n TO=840.1n

.meas tran Vdout1_60ck63 AVG v(dout1_60) FROM=839.9n TO=840.1n

.meas tran Vdout1_61ck63 AVG v(dout1_61) FROM=839.9n TO=840.1n

.meas tran Vdout1_62ck63 AVG v(dout1_62) FROM=839.9n TO=840.1n

.meas tran Vdout1_63ck63 AVG v(dout1_63) FROM=839.9n TO=840.1n

.meas tran Vdout1_64ck63 AVG v(dout1_64) FROM=839.9n TO=840.1n

.meas tran Vdout1_65ck63 AVG v(dout1_65) FROM=839.9n TO=840.1n

.meas tran Vdout1_66ck63 AVG v(dout1_66) FROM=839.9n TO=840.1n

.meas tran Vdout1_67ck63 AVG v(dout1_67) FROM=839.9n TO=840.1n

.meas tran Vdout1_68ck63 AVG v(dout1_68) FROM=839.9n TO=840.1n

.meas tran Vdout1_69ck63 AVG v(dout1_69) FROM=839.9n TO=840.1n

.meas tran Vdout1_70ck63 AVG v(dout1_70) FROM=839.9n TO=840.1n

.meas tran Vdout1_71ck63 AVG v(dout1_71) FROM=839.9n TO=840.1n

.meas tran Vdout1_72ck63 AVG v(dout1_72) FROM=839.9n TO=840.1n

.meas tran Vdout1_73ck63 AVG v(dout1_73) FROM=839.9n TO=840.1n

.meas tran Vdout1_74ck63 AVG v(dout1_74) FROM=839.9n TO=840.1n

.meas tran Vdout1_75ck63 AVG v(dout1_75) FROM=839.9n TO=840.1n

.meas tran Vdout1_76ck63 AVG v(dout1_76) FROM=839.9n TO=840.1n

.meas tran Vdout1_77ck63 AVG v(dout1_77) FROM=839.9n TO=840.1n

.meas tran Vdout1_78ck63 AVG v(dout1_78) FROM=839.9n TO=840.1n

.meas tran Vdout1_79ck63 AVG v(dout1_79) FROM=839.9n TO=840.1n

.meas tran Vdout1_0ck64 AVG v(dout1_0) FROM=849.9n TO=850.1n

.meas tran Vdout1_1ck64 AVG v(dout1_1) FROM=849.9n TO=850.1n

.meas tran Vdout1_2ck64 AVG v(dout1_2) FROM=849.9n TO=850.1n

.meas tran Vdout1_3ck64 AVG v(dout1_3) FROM=849.9n TO=850.1n

.meas tran Vdout1_4ck64 AVG v(dout1_4) FROM=849.9n TO=850.1n

.meas tran Vdout1_5ck64 AVG v(dout1_5) FROM=849.9n TO=850.1n

.meas tran Vdout1_6ck64 AVG v(dout1_6) FROM=849.9n TO=850.1n

.meas tran Vdout1_7ck64 AVG v(dout1_7) FROM=849.9n TO=850.1n

.meas tran Vdout1_8ck64 AVG v(dout1_8) FROM=849.9n TO=850.1n

.meas tran Vdout1_9ck64 AVG v(dout1_9) FROM=849.9n TO=850.1n

.meas tran Vdout1_10ck64 AVG v(dout1_10) FROM=849.9n TO=850.1n

.meas tran Vdout1_11ck64 AVG v(dout1_11) FROM=849.9n TO=850.1n

.meas tran Vdout1_12ck64 AVG v(dout1_12) FROM=849.9n TO=850.1n

.meas tran Vdout1_13ck64 AVG v(dout1_13) FROM=849.9n TO=850.1n

.meas tran Vdout1_14ck64 AVG v(dout1_14) FROM=849.9n TO=850.1n

.meas tran Vdout1_15ck64 AVG v(dout1_15) FROM=849.9n TO=850.1n

.meas tran Vdout1_16ck64 AVG v(dout1_16) FROM=849.9n TO=850.1n

.meas tran Vdout1_17ck64 AVG v(dout1_17) FROM=849.9n TO=850.1n

.meas tran Vdout1_18ck64 AVG v(dout1_18) FROM=849.9n TO=850.1n

.meas tran Vdout1_19ck64 AVG v(dout1_19) FROM=849.9n TO=850.1n

.meas tran Vdout1_20ck64 AVG v(dout1_20) FROM=849.9n TO=850.1n

.meas tran Vdout1_21ck64 AVG v(dout1_21) FROM=849.9n TO=850.1n

.meas tran Vdout1_22ck64 AVG v(dout1_22) FROM=849.9n TO=850.1n

.meas tran Vdout1_23ck64 AVG v(dout1_23) FROM=849.9n TO=850.1n

.meas tran Vdout1_24ck64 AVG v(dout1_24) FROM=849.9n TO=850.1n

.meas tran Vdout1_25ck64 AVG v(dout1_25) FROM=849.9n TO=850.1n

.meas tran Vdout1_26ck64 AVG v(dout1_26) FROM=849.9n TO=850.1n

.meas tran Vdout1_27ck64 AVG v(dout1_27) FROM=849.9n TO=850.1n

.meas tran Vdout1_28ck64 AVG v(dout1_28) FROM=849.9n TO=850.1n

.meas tran Vdout1_29ck64 AVG v(dout1_29) FROM=849.9n TO=850.1n

.meas tran Vdout1_30ck64 AVG v(dout1_30) FROM=849.9n TO=850.1n

.meas tran Vdout1_31ck64 AVG v(dout1_31) FROM=849.9n TO=850.1n

.meas tran Vdout1_32ck64 AVG v(dout1_32) FROM=849.9n TO=850.1n

.meas tran Vdout1_33ck64 AVG v(dout1_33) FROM=849.9n TO=850.1n

.meas tran Vdout1_34ck64 AVG v(dout1_34) FROM=849.9n TO=850.1n

.meas tran Vdout1_35ck64 AVG v(dout1_35) FROM=849.9n TO=850.1n

.meas tran Vdout1_36ck64 AVG v(dout1_36) FROM=849.9n TO=850.1n

.meas tran Vdout1_37ck64 AVG v(dout1_37) FROM=849.9n TO=850.1n

.meas tran Vdout1_38ck64 AVG v(dout1_38) FROM=849.9n TO=850.1n

.meas tran Vdout1_39ck64 AVG v(dout1_39) FROM=849.9n TO=850.1n

.meas tran Vdout1_40ck64 AVG v(dout1_40) FROM=849.9n TO=850.1n

.meas tran Vdout1_41ck64 AVG v(dout1_41) FROM=849.9n TO=850.1n

.meas tran Vdout1_42ck64 AVG v(dout1_42) FROM=849.9n TO=850.1n

.meas tran Vdout1_43ck64 AVG v(dout1_43) FROM=849.9n TO=850.1n

.meas tran Vdout1_44ck64 AVG v(dout1_44) FROM=849.9n TO=850.1n

.meas tran Vdout1_45ck64 AVG v(dout1_45) FROM=849.9n TO=850.1n

.meas tran Vdout1_46ck64 AVG v(dout1_46) FROM=849.9n TO=850.1n

.meas tran Vdout1_47ck64 AVG v(dout1_47) FROM=849.9n TO=850.1n

.meas tran Vdout1_48ck64 AVG v(dout1_48) FROM=849.9n TO=850.1n

.meas tran Vdout1_49ck64 AVG v(dout1_49) FROM=849.9n TO=850.1n

.meas tran Vdout1_50ck64 AVG v(dout1_50) FROM=849.9n TO=850.1n

.meas tran Vdout1_51ck64 AVG v(dout1_51) FROM=849.9n TO=850.1n

.meas tran Vdout1_52ck64 AVG v(dout1_52) FROM=849.9n TO=850.1n

.meas tran Vdout1_53ck64 AVG v(dout1_53) FROM=849.9n TO=850.1n

.meas tran Vdout1_54ck64 AVG v(dout1_54) FROM=849.9n TO=850.1n

.meas tran Vdout1_55ck64 AVG v(dout1_55) FROM=849.9n TO=850.1n

.meas tran Vdout1_56ck64 AVG v(dout1_56) FROM=849.9n TO=850.1n

.meas tran Vdout1_57ck64 AVG v(dout1_57) FROM=849.9n TO=850.1n

.meas tran Vdout1_58ck64 AVG v(dout1_58) FROM=849.9n TO=850.1n

.meas tran Vdout1_59ck64 AVG v(dout1_59) FROM=849.9n TO=850.1n

.meas tran Vdout1_60ck64 AVG v(dout1_60) FROM=849.9n TO=850.1n

.meas tran Vdout1_61ck64 AVG v(dout1_61) FROM=849.9n TO=850.1n

.meas tran Vdout1_62ck64 AVG v(dout1_62) FROM=849.9n TO=850.1n

.meas tran Vdout1_63ck64 AVG v(dout1_63) FROM=849.9n TO=850.1n

.meas tran Vdout1_64ck64 AVG v(dout1_64) FROM=849.9n TO=850.1n

.meas tran Vdout1_65ck64 AVG v(dout1_65) FROM=849.9n TO=850.1n

.meas tran Vdout1_66ck64 AVG v(dout1_66) FROM=849.9n TO=850.1n

.meas tran Vdout1_67ck64 AVG v(dout1_67) FROM=849.9n TO=850.1n

.meas tran Vdout1_68ck64 AVG v(dout1_68) FROM=849.9n TO=850.1n

.meas tran Vdout1_69ck64 AVG v(dout1_69) FROM=849.9n TO=850.1n

.meas tran Vdout1_70ck64 AVG v(dout1_70) FROM=849.9n TO=850.1n

.meas tran Vdout1_71ck64 AVG v(dout1_71) FROM=849.9n TO=850.1n

.meas tran Vdout1_72ck64 AVG v(dout1_72) FROM=849.9n TO=850.1n

.meas tran Vdout1_73ck64 AVG v(dout1_73) FROM=849.9n TO=850.1n

.meas tran Vdout1_74ck64 AVG v(dout1_74) FROM=849.9n TO=850.1n

.meas tran Vdout1_75ck64 AVG v(dout1_75) FROM=849.9n TO=850.1n

.meas tran Vdout1_76ck64 AVG v(dout1_76) FROM=849.9n TO=850.1n

.meas tran Vdout1_77ck64 AVG v(dout1_77) FROM=849.9n TO=850.1n

.meas tran Vdout1_78ck64 AVG v(dout1_78) FROM=849.9n TO=850.1n

.meas tran Vdout1_79ck64 AVG v(dout1_79) FROM=849.9n TO=850.1n

.meas tran Vdout1_0ck65 AVG v(dout1_0) FROM=859.9n TO=860.1n

.meas tran Vdout1_1ck65 AVG v(dout1_1) FROM=859.9n TO=860.1n

.meas tran Vdout1_2ck65 AVG v(dout1_2) FROM=859.9n TO=860.1n

.meas tran Vdout1_3ck65 AVG v(dout1_3) FROM=859.9n TO=860.1n

.meas tran Vdout1_4ck65 AVG v(dout1_4) FROM=859.9n TO=860.1n

.meas tran Vdout1_5ck65 AVG v(dout1_5) FROM=859.9n TO=860.1n

.meas tran Vdout1_6ck65 AVG v(dout1_6) FROM=859.9n TO=860.1n

.meas tran Vdout1_7ck65 AVG v(dout1_7) FROM=859.9n TO=860.1n

.meas tran Vdout1_8ck65 AVG v(dout1_8) FROM=859.9n TO=860.1n

.meas tran Vdout1_9ck65 AVG v(dout1_9) FROM=859.9n TO=860.1n

.meas tran Vdout1_10ck65 AVG v(dout1_10) FROM=859.9n TO=860.1n

.meas tran Vdout1_11ck65 AVG v(dout1_11) FROM=859.9n TO=860.1n

.meas tran Vdout1_12ck65 AVG v(dout1_12) FROM=859.9n TO=860.1n

.meas tran Vdout1_13ck65 AVG v(dout1_13) FROM=859.9n TO=860.1n

.meas tran Vdout1_14ck65 AVG v(dout1_14) FROM=859.9n TO=860.1n

.meas tran Vdout1_15ck65 AVG v(dout1_15) FROM=859.9n TO=860.1n

.meas tran Vdout1_16ck65 AVG v(dout1_16) FROM=859.9n TO=860.1n

.meas tran Vdout1_17ck65 AVG v(dout1_17) FROM=859.9n TO=860.1n

.meas tran Vdout1_18ck65 AVG v(dout1_18) FROM=859.9n TO=860.1n

.meas tran Vdout1_19ck65 AVG v(dout1_19) FROM=859.9n TO=860.1n

.meas tran Vdout1_20ck65 AVG v(dout1_20) FROM=859.9n TO=860.1n

.meas tran Vdout1_21ck65 AVG v(dout1_21) FROM=859.9n TO=860.1n

.meas tran Vdout1_22ck65 AVG v(dout1_22) FROM=859.9n TO=860.1n

.meas tran Vdout1_23ck65 AVG v(dout1_23) FROM=859.9n TO=860.1n

.meas tran Vdout1_24ck65 AVG v(dout1_24) FROM=859.9n TO=860.1n

.meas tran Vdout1_25ck65 AVG v(dout1_25) FROM=859.9n TO=860.1n

.meas tran Vdout1_26ck65 AVG v(dout1_26) FROM=859.9n TO=860.1n

.meas tran Vdout1_27ck65 AVG v(dout1_27) FROM=859.9n TO=860.1n

.meas tran Vdout1_28ck65 AVG v(dout1_28) FROM=859.9n TO=860.1n

.meas tran Vdout1_29ck65 AVG v(dout1_29) FROM=859.9n TO=860.1n

.meas tran Vdout1_30ck65 AVG v(dout1_30) FROM=859.9n TO=860.1n

.meas tran Vdout1_31ck65 AVG v(dout1_31) FROM=859.9n TO=860.1n

.meas tran Vdout1_32ck65 AVG v(dout1_32) FROM=859.9n TO=860.1n

.meas tran Vdout1_33ck65 AVG v(dout1_33) FROM=859.9n TO=860.1n

.meas tran Vdout1_34ck65 AVG v(dout1_34) FROM=859.9n TO=860.1n

.meas tran Vdout1_35ck65 AVG v(dout1_35) FROM=859.9n TO=860.1n

.meas tran Vdout1_36ck65 AVG v(dout1_36) FROM=859.9n TO=860.1n

.meas tran Vdout1_37ck65 AVG v(dout1_37) FROM=859.9n TO=860.1n

.meas tran Vdout1_38ck65 AVG v(dout1_38) FROM=859.9n TO=860.1n

.meas tran Vdout1_39ck65 AVG v(dout1_39) FROM=859.9n TO=860.1n

.meas tran Vdout1_40ck65 AVG v(dout1_40) FROM=859.9n TO=860.1n

.meas tran Vdout1_41ck65 AVG v(dout1_41) FROM=859.9n TO=860.1n

.meas tran Vdout1_42ck65 AVG v(dout1_42) FROM=859.9n TO=860.1n

.meas tran Vdout1_43ck65 AVG v(dout1_43) FROM=859.9n TO=860.1n

.meas tran Vdout1_44ck65 AVG v(dout1_44) FROM=859.9n TO=860.1n

.meas tran Vdout1_45ck65 AVG v(dout1_45) FROM=859.9n TO=860.1n

.meas tran Vdout1_46ck65 AVG v(dout1_46) FROM=859.9n TO=860.1n

.meas tran Vdout1_47ck65 AVG v(dout1_47) FROM=859.9n TO=860.1n

.meas tran Vdout1_48ck65 AVG v(dout1_48) FROM=859.9n TO=860.1n

.meas tran Vdout1_49ck65 AVG v(dout1_49) FROM=859.9n TO=860.1n

.meas tran Vdout1_50ck65 AVG v(dout1_50) FROM=859.9n TO=860.1n

.meas tran Vdout1_51ck65 AVG v(dout1_51) FROM=859.9n TO=860.1n

.meas tran Vdout1_52ck65 AVG v(dout1_52) FROM=859.9n TO=860.1n

.meas tran Vdout1_53ck65 AVG v(dout1_53) FROM=859.9n TO=860.1n

.meas tran Vdout1_54ck65 AVG v(dout1_54) FROM=859.9n TO=860.1n

.meas tran Vdout1_55ck65 AVG v(dout1_55) FROM=859.9n TO=860.1n

.meas tran Vdout1_56ck65 AVG v(dout1_56) FROM=859.9n TO=860.1n

.meas tran Vdout1_57ck65 AVG v(dout1_57) FROM=859.9n TO=860.1n

.meas tran Vdout1_58ck65 AVG v(dout1_58) FROM=859.9n TO=860.1n

.meas tran Vdout1_59ck65 AVG v(dout1_59) FROM=859.9n TO=860.1n

.meas tran Vdout1_60ck65 AVG v(dout1_60) FROM=859.9n TO=860.1n

.meas tran Vdout1_61ck65 AVG v(dout1_61) FROM=859.9n TO=860.1n

.meas tran Vdout1_62ck65 AVG v(dout1_62) FROM=859.9n TO=860.1n

.meas tran Vdout1_63ck65 AVG v(dout1_63) FROM=859.9n TO=860.1n

.meas tran Vdout1_64ck65 AVG v(dout1_64) FROM=859.9n TO=860.1n

.meas tran Vdout1_65ck65 AVG v(dout1_65) FROM=859.9n TO=860.1n

.meas tran Vdout1_66ck65 AVG v(dout1_66) FROM=859.9n TO=860.1n

.meas tran Vdout1_67ck65 AVG v(dout1_67) FROM=859.9n TO=860.1n

.meas tran Vdout1_68ck65 AVG v(dout1_68) FROM=859.9n TO=860.1n

.meas tran Vdout1_69ck65 AVG v(dout1_69) FROM=859.9n TO=860.1n

.meas tran Vdout1_70ck65 AVG v(dout1_70) FROM=859.9n TO=860.1n

.meas tran Vdout1_71ck65 AVG v(dout1_71) FROM=859.9n TO=860.1n

.meas tran Vdout1_72ck65 AVG v(dout1_72) FROM=859.9n TO=860.1n

.meas tran Vdout1_73ck65 AVG v(dout1_73) FROM=859.9n TO=860.1n

.meas tran Vdout1_74ck65 AVG v(dout1_74) FROM=859.9n TO=860.1n

.meas tran Vdout1_75ck65 AVG v(dout1_75) FROM=859.9n TO=860.1n

.meas tran Vdout1_76ck65 AVG v(dout1_76) FROM=859.9n TO=860.1n

.meas tran Vdout1_77ck65 AVG v(dout1_77) FROM=859.9n TO=860.1n

.meas tran Vdout1_78ck65 AVG v(dout1_78) FROM=859.9n TO=860.1n

.meas tran Vdout1_79ck65 AVG v(dout1_79) FROM=859.9n TO=860.1n

.meas tran Vdout0_0ck66 AVG v(dout0_0) FROM=879.9n TO=880.1n

.meas tran Vdout0_1ck66 AVG v(dout0_1) FROM=879.9n TO=880.1n

.meas tran Vdout0_2ck66 AVG v(dout0_2) FROM=879.9n TO=880.1n

.meas tran Vdout0_3ck66 AVG v(dout0_3) FROM=879.9n TO=880.1n

.meas tran Vdout0_4ck66 AVG v(dout0_4) FROM=879.9n TO=880.1n

.meas tran Vdout0_5ck66 AVG v(dout0_5) FROM=879.9n TO=880.1n

.meas tran Vdout0_6ck66 AVG v(dout0_6) FROM=879.9n TO=880.1n

.meas tran Vdout0_7ck66 AVG v(dout0_7) FROM=879.9n TO=880.1n

.meas tran Vdout0_8ck66 AVG v(dout0_8) FROM=879.9n TO=880.1n

.meas tran Vdout0_9ck66 AVG v(dout0_9) FROM=879.9n TO=880.1n

.meas tran Vdout0_10ck66 AVG v(dout0_10) FROM=879.9n TO=880.1n

.meas tran Vdout0_11ck66 AVG v(dout0_11) FROM=879.9n TO=880.1n

.meas tran Vdout0_12ck66 AVG v(dout0_12) FROM=879.9n TO=880.1n

.meas tran Vdout0_13ck66 AVG v(dout0_13) FROM=879.9n TO=880.1n

.meas tran Vdout0_14ck66 AVG v(dout0_14) FROM=879.9n TO=880.1n

.meas tran Vdout0_15ck66 AVG v(dout0_15) FROM=879.9n TO=880.1n

.meas tran Vdout0_16ck66 AVG v(dout0_16) FROM=879.9n TO=880.1n

.meas tran Vdout0_17ck66 AVG v(dout0_17) FROM=879.9n TO=880.1n

.meas tran Vdout0_18ck66 AVG v(dout0_18) FROM=879.9n TO=880.1n

.meas tran Vdout0_19ck66 AVG v(dout0_19) FROM=879.9n TO=880.1n

.meas tran Vdout0_20ck66 AVG v(dout0_20) FROM=879.9n TO=880.1n

.meas tran Vdout0_21ck66 AVG v(dout0_21) FROM=879.9n TO=880.1n

.meas tran Vdout0_22ck66 AVG v(dout0_22) FROM=879.9n TO=880.1n

.meas tran Vdout0_23ck66 AVG v(dout0_23) FROM=879.9n TO=880.1n

.meas tran Vdout0_24ck66 AVG v(dout0_24) FROM=879.9n TO=880.1n

.meas tran Vdout0_25ck66 AVG v(dout0_25) FROM=879.9n TO=880.1n

.meas tran Vdout0_26ck66 AVG v(dout0_26) FROM=879.9n TO=880.1n

.meas tran Vdout0_27ck66 AVG v(dout0_27) FROM=879.9n TO=880.1n

.meas tran Vdout0_28ck66 AVG v(dout0_28) FROM=879.9n TO=880.1n

.meas tran Vdout0_29ck66 AVG v(dout0_29) FROM=879.9n TO=880.1n

.meas tran Vdout0_30ck66 AVG v(dout0_30) FROM=879.9n TO=880.1n

.meas tran Vdout0_31ck66 AVG v(dout0_31) FROM=879.9n TO=880.1n

.meas tran Vdout0_32ck66 AVG v(dout0_32) FROM=879.9n TO=880.1n

.meas tran Vdout0_33ck66 AVG v(dout0_33) FROM=879.9n TO=880.1n

.meas tran Vdout0_34ck66 AVG v(dout0_34) FROM=879.9n TO=880.1n

.meas tran Vdout0_35ck66 AVG v(dout0_35) FROM=879.9n TO=880.1n

.meas tran Vdout0_36ck66 AVG v(dout0_36) FROM=879.9n TO=880.1n

.meas tran Vdout0_37ck66 AVG v(dout0_37) FROM=879.9n TO=880.1n

.meas tran Vdout0_38ck66 AVG v(dout0_38) FROM=879.9n TO=880.1n

.meas tran Vdout0_39ck66 AVG v(dout0_39) FROM=879.9n TO=880.1n

.meas tran Vdout0_40ck66 AVG v(dout0_40) FROM=879.9n TO=880.1n

.meas tran Vdout0_41ck66 AVG v(dout0_41) FROM=879.9n TO=880.1n

.meas tran Vdout0_42ck66 AVG v(dout0_42) FROM=879.9n TO=880.1n

.meas tran Vdout0_43ck66 AVG v(dout0_43) FROM=879.9n TO=880.1n

.meas tran Vdout0_44ck66 AVG v(dout0_44) FROM=879.9n TO=880.1n

.meas tran Vdout0_45ck66 AVG v(dout0_45) FROM=879.9n TO=880.1n

.meas tran Vdout0_46ck66 AVG v(dout0_46) FROM=879.9n TO=880.1n

.meas tran Vdout0_47ck66 AVG v(dout0_47) FROM=879.9n TO=880.1n

.meas tran Vdout0_48ck66 AVG v(dout0_48) FROM=879.9n TO=880.1n

.meas tran Vdout0_49ck66 AVG v(dout0_49) FROM=879.9n TO=880.1n

.meas tran Vdout0_50ck66 AVG v(dout0_50) FROM=879.9n TO=880.1n

.meas tran Vdout0_51ck66 AVG v(dout0_51) FROM=879.9n TO=880.1n

.meas tran Vdout0_52ck66 AVG v(dout0_52) FROM=879.9n TO=880.1n

.meas tran Vdout0_53ck66 AVG v(dout0_53) FROM=879.9n TO=880.1n

.meas tran Vdout0_54ck66 AVG v(dout0_54) FROM=879.9n TO=880.1n

.meas tran Vdout0_55ck66 AVG v(dout0_55) FROM=879.9n TO=880.1n

.meas tran Vdout0_56ck66 AVG v(dout0_56) FROM=879.9n TO=880.1n

.meas tran Vdout0_57ck66 AVG v(dout0_57) FROM=879.9n TO=880.1n

.meas tran Vdout0_58ck66 AVG v(dout0_58) FROM=879.9n TO=880.1n

.meas tran Vdout0_59ck66 AVG v(dout0_59) FROM=879.9n TO=880.1n

.meas tran Vdout0_60ck66 AVG v(dout0_60) FROM=879.9n TO=880.1n

.meas tran Vdout0_61ck66 AVG v(dout0_61) FROM=879.9n TO=880.1n

.meas tran Vdout0_62ck66 AVG v(dout0_62) FROM=879.9n TO=880.1n

.meas tran Vdout0_63ck66 AVG v(dout0_63) FROM=879.9n TO=880.1n

.meas tran Vdout0_64ck66 AVG v(dout0_64) FROM=879.9n TO=880.1n

.meas tran Vdout0_65ck66 AVG v(dout0_65) FROM=879.9n TO=880.1n

.meas tran Vdout0_66ck66 AVG v(dout0_66) FROM=879.9n TO=880.1n

.meas tran Vdout0_67ck66 AVG v(dout0_67) FROM=879.9n TO=880.1n

.meas tran Vdout0_68ck66 AVG v(dout0_68) FROM=879.9n TO=880.1n

.meas tran Vdout0_69ck66 AVG v(dout0_69) FROM=879.9n TO=880.1n

.meas tran Vdout0_70ck66 AVG v(dout0_70) FROM=879.9n TO=880.1n

.meas tran Vdout0_71ck66 AVG v(dout0_71) FROM=879.9n TO=880.1n

.meas tran Vdout0_72ck66 AVG v(dout0_72) FROM=879.9n TO=880.1n

.meas tran Vdout0_73ck66 AVG v(dout0_73) FROM=879.9n TO=880.1n

.meas tran Vdout0_74ck66 AVG v(dout0_74) FROM=879.9n TO=880.1n

.meas tran Vdout0_75ck66 AVG v(dout0_75) FROM=879.9n TO=880.1n

.meas tran Vdout0_76ck66 AVG v(dout0_76) FROM=879.9n TO=880.1n

.meas tran Vdout0_77ck66 AVG v(dout0_77) FROM=879.9n TO=880.1n

.meas tran Vdout0_78ck66 AVG v(dout0_78) FROM=879.9n TO=880.1n

.meas tran Vdout0_79ck66 AVG v(dout0_79) FROM=879.9n TO=880.1n

.meas tran Vdout1_0ck67 AVG v(dout1_0) FROM=879.9n TO=880.1n

.meas tran Vdout1_1ck67 AVG v(dout1_1) FROM=879.9n TO=880.1n

.meas tran Vdout1_2ck67 AVG v(dout1_2) FROM=879.9n TO=880.1n

.meas tran Vdout1_3ck67 AVG v(dout1_3) FROM=879.9n TO=880.1n

.meas tran Vdout1_4ck67 AVG v(dout1_4) FROM=879.9n TO=880.1n

.meas tran Vdout1_5ck67 AVG v(dout1_5) FROM=879.9n TO=880.1n

.meas tran Vdout1_6ck67 AVG v(dout1_6) FROM=879.9n TO=880.1n

.meas tran Vdout1_7ck67 AVG v(dout1_7) FROM=879.9n TO=880.1n

.meas tran Vdout1_8ck67 AVG v(dout1_8) FROM=879.9n TO=880.1n

.meas tran Vdout1_9ck67 AVG v(dout1_9) FROM=879.9n TO=880.1n

.meas tran Vdout1_10ck67 AVG v(dout1_10) FROM=879.9n TO=880.1n

.meas tran Vdout1_11ck67 AVG v(dout1_11) FROM=879.9n TO=880.1n

.meas tran Vdout1_12ck67 AVG v(dout1_12) FROM=879.9n TO=880.1n

.meas tran Vdout1_13ck67 AVG v(dout1_13) FROM=879.9n TO=880.1n

.meas tran Vdout1_14ck67 AVG v(dout1_14) FROM=879.9n TO=880.1n

.meas tran Vdout1_15ck67 AVG v(dout1_15) FROM=879.9n TO=880.1n

.meas tran Vdout1_16ck67 AVG v(dout1_16) FROM=879.9n TO=880.1n

.meas tran Vdout1_17ck67 AVG v(dout1_17) FROM=879.9n TO=880.1n

.meas tran Vdout1_18ck67 AVG v(dout1_18) FROM=879.9n TO=880.1n

.meas tran Vdout1_19ck67 AVG v(dout1_19) FROM=879.9n TO=880.1n

.meas tran Vdout1_20ck67 AVG v(dout1_20) FROM=879.9n TO=880.1n

.meas tran Vdout1_21ck67 AVG v(dout1_21) FROM=879.9n TO=880.1n

.meas tran Vdout1_22ck67 AVG v(dout1_22) FROM=879.9n TO=880.1n

.meas tran Vdout1_23ck67 AVG v(dout1_23) FROM=879.9n TO=880.1n

.meas tran Vdout1_24ck67 AVG v(dout1_24) FROM=879.9n TO=880.1n

.meas tran Vdout1_25ck67 AVG v(dout1_25) FROM=879.9n TO=880.1n

.meas tran Vdout1_26ck67 AVG v(dout1_26) FROM=879.9n TO=880.1n

.meas tran Vdout1_27ck67 AVG v(dout1_27) FROM=879.9n TO=880.1n

.meas tran Vdout1_28ck67 AVG v(dout1_28) FROM=879.9n TO=880.1n

.meas tran Vdout1_29ck67 AVG v(dout1_29) FROM=879.9n TO=880.1n

.meas tran Vdout1_30ck67 AVG v(dout1_30) FROM=879.9n TO=880.1n

.meas tran Vdout1_31ck67 AVG v(dout1_31) FROM=879.9n TO=880.1n

.meas tran Vdout1_32ck67 AVG v(dout1_32) FROM=879.9n TO=880.1n

.meas tran Vdout1_33ck67 AVG v(dout1_33) FROM=879.9n TO=880.1n

.meas tran Vdout1_34ck67 AVG v(dout1_34) FROM=879.9n TO=880.1n

.meas tran Vdout1_35ck67 AVG v(dout1_35) FROM=879.9n TO=880.1n

.meas tran Vdout1_36ck67 AVG v(dout1_36) FROM=879.9n TO=880.1n

.meas tran Vdout1_37ck67 AVG v(dout1_37) FROM=879.9n TO=880.1n

.meas tran Vdout1_38ck67 AVG v(dout1_38) FROM=879.9n TO=880.1n

.meas tran Vdout1_39ck67 AVG v(dout1_39) FROM=879.9n TO=880.1n

.meas tran Vdout1_40ck67 AVG v(dout1_40) FROM=879.9n TO=880.1n

.meas tran Vdout1_41ck67 AVG v(dout1_41) FROM=879.9n TO=880.1n

.meas tran Vdout1_42ck67 AVG v(dout1_42) FROM=879.9n TO=880.1n

.meas tran Vdout1_43ck67 AVG v(dout1_43) FROM=879.9n TO=880.1n

.meas tran Vdout1_44ck67 AVG v(dout1_44) FROM=879.9n TO=880.1n

.meas tran Vdout1_45ck67 AVG v(dout1_45) FROM=879.9n TO=880.1n

.meas tran Vdout1_46ck67 AVG v(dout1_46) FROM=879.9n TO=880.1n

.meas tran Vdout1_47ck67 AVG v(dout1_47) FROM=879.9n TO=880.1n

.meas tran Vdout1_48ck67 AVG v(dout1_48) FROM=879.9n TO=880.1n

.meas tran Vdout1_49ck67 AVG v(dout1_49) FROM=879.9n TO=880.1n

.meas tran Vdout1_50ck67 AVG v(dout1_50) FROM=879.9n TO=880.1n

.meas tran Vdout1_51ck67 AVG v(dout1_51) FROM=879.9n TO=880.1n

.meas tran Vdout1_52ck67 AVG v(dout1_52) FROM=879.9n TO=880.1n

.meas tran Vdout1_53ck67 AVG v(dout1_53) FROM=879.9n TO=880.1n

.meas tran Vdout1_54ck67 AVG v(dout1_54) FROM=879.9n TO=880.1n

.meas tran Vdout1_55ck67 AVG v(dout1_55) FROM=879.9n TO=880.1n

.meas tran Vdout1_56ck67 AVG v(dout1_56) FROM=879.9n TO=880.1n

.meas tran Vdout1_57ck67 AVG v(dout1_57) FROM=879.9n TO=880.1n

.meas tran Vdout1_58ck67 AVG v(dout1_58) FROM=879.9n TO=880.1n

.meas tran Vdout1_59ck67 AVG v(dout1_59) FROM=879.9n TO=880.1n

.meas tran Vdout1_60ck67 AVG v(dout1_60) FROM=879.9n TO=880.1n

.meas tran Vdout1_61ck67 AVG v(dout1_61) FROM=879.9n TO=880.1n

.meas tran Vdout1_62ck67 AVG v(dout1_62) FROM=879.9n TO=880.1n

.meas tran Vdout1_63ck67 AVG v(dout1_63) FROM=879.9n TO=880.1n

.meas tran Vdout1_64ck67 AVG v(dout1_64) FROM=879.9n TO=880.1n

.meas tran Vdout1_65ck67 AVG v(dout1_65) FROM=879.9n TO=880.1n

.meas tran Vdout1_66ck67 AVG v(dout1_66) FROM=879.9n TO=880.1n

.meas tran Vdout1_67ck67 AVG v(dout1_67) FROM=879.9n TO=880.1n

.meas tran Vdout1_68ck67 AVG v(dout1_68) FROM=879.9n TO=880.1n

.meas tran Vdout1_69ck67 AVG v(dout1_69) FROM=879.9n TO=880.1n

.meas tran Vdout1_70ck67 AVG v(dout1_70) FROM=879.9n TO=880.1n

.meas tran Vdout1_71ck67 AVG v(dout1_71) FROM=879.9n TO=880.1n

.meas tran Vdout1_72ck67 AVG v(dout1_72) FROM=879.9n TO=880.1n

.meas tran Vdout1_73ck67 AVG v(dout1_73) FROM=879.9n TO=880.1n

.meas tran Vdout1_74ck67 AVG v(dout1_74) FROM=879.9n TO=880.1n

.meas tran Vdout1_75ck67 AVG v(dout1_75) FROM=879.9n TO=880.1n

.meas tran Vdout1_76ck67 AVG v(dout1_76) FROM=879.9n TO=880.1n

.meas tran Vdout1_77ck67 AVG v(dout1_77) FROM=879.9n TO=880.1n

.meas tran Vdout1_78ck67 AVG v(dout1_78) FROM=879.9n TO=880.1n

.meas tran Vdout1_79ck67 AVG v(dout1_79) FROM=879.9n TO=880.1n

.meas tran Vdout0_0ck68 AVG v(dout0_0) FROM=889.9n TO=890.1n

.meas tran Vdout0_1ck68 AVG v(dout0_1) FROM=889.9n TO=890.1n

.meas tran Vdout0_2ck68 AVG v(dout0_2) FROM=889.9n TO=890.1n

.meas tran Vdout0_3ck68 AVG v(dout0_3) FROM=889.9n TO=890.1n

.meas tran Vdout0_4ck68 AVG v(dout0_4) FROM=889.9n TO=890.1n

.meas tran Vdout0_5ck68 AVG v(dout0_5) FROM=889.9n TO=890.1n

.meas tran Vdout0_6ck68 AVG v(dout0_6) FROM=889.9n TO=890.1n

.meas tran Vdout0_7ck68 AVG v(dout0_7) FROM=889.9n TO=890.1n

.meas tran Vdout0_8ck68 AVG v(dout0_8) FROM=889.9n TO=890.1n

.meas tran Vdout0_9ck68 AVG v(dout0_9) FROM=889.9n TO=890.1n

.meas tran Vdout0_10ck68 AVG v(dout0_10) FROM=889.9n TO=890.1n

.meas tran Vdout0_11ck68 AVG v(dout0_11) FROM=889.9n TO=890.1n

.meas tran Vdout0_12ck68 AVG v(dout0_12) FROM=889.9n TO=890.1n

.meas tran Vdout0_13ck68 AVG v(dout0_13) FROM=889.9n TO=890.1n

.meas tran Vdout0_14ck68 AVG v(dout0_14) FROM=889.9n TO=890.1n

.meas tran Vdout0_15ck68 AVG v(dout0_15) FROM=889.9n TO=890.1n

.meas tran Vdout0_16ck68 AVG v(dout0_16) FROM=889.9n TO=890.1n

.meas tran Vdout0_17ck68 AVG v(dout0_17) FROM=889.9n TO=890.1n

.meas tran Vdout0_18ck68 AVG v(dout0_18) FROM=889.9n TO=890.1n

.meas tran Vdout0_19ck68 AVG v(dout0_19) FROM=889.9n TO=890.1n

.meas tran Vdout0_20ck68 AVG v(dout0_20) FROM=889.9n TO=890.1n

.meas tran Vdout0_21ck68 AVG v(dout0_21) FROM=889.9n TO=890.1n

.meas tran Vdout0_22ck68 AVG v(dout0_22) FROM=889.9n TO=890.1n

.meas tran Vdout0_23ck68 AVG v(dout0_23) FROM=889.9n TO=890.1n

.meas tran Vdout0_24ck68 AVG v(dout0_24) FROM=889.9n TO=890.1n

.meas tran Vdout0_25ck68 AVG v(dout0_25) FROM=889.9n TO=890.1n

.meas tran Vdout0_26ck68 AVG v(dout0_26) FROM=889.9n TO=890.1n

.meas tran Vdout0_27ck68 AVG v(dout0_27) FROM=889.9n TO=890.1n

.meas tran Vdout0_28ck68 AVG v(dout0_28) FROM=889.9n TO=890.1n

.meas tran Vdout0_29ck68 AVG v(dout0_29) FROM=889.9n TO=890.1n

.meas tran Vdout0_30ck68 AVG v(dout0_30) FROM=889.9n TO=890.1n

.meas tran Vdout0_31ck68 AVG v(dout0_31) FROM=889.9n TO=890.1n

.meas tran Vdout0_32ck68 AVG v(dout0_32) FROM=889.9n TO=890.1n

.meas tran Vdout0_33ck68 AVG v(dout0_33) FROM=889.9n TO=890.1n

.meas tran Vdout0_34ck68 AVG v(dout0_34) FROM=889.9n TO=890.1n

.meas tran Vdout0_35ck68 AVG v(dout0_35) FROM=889.9n TO=890.1n

.meas tran Vdout0_36ck68 AVG v(dout0_36) FROM=889.9n TO=890.1n

.meas tran Vdout0_37ck68 AVG v(dout0_37) FROM=889.9n TO=890.1n

.meas tran Vdout0_38ck68 AVG v(dout0_38) FROM=889.9n TO=890.1n

.meas tran Vdout0_39ck68 AVG v(dout0_39) FROM=889.9n TO=890.1n

.meas tran Vdout0_40ck68 AVG v(dout0_40) FROM=889.9n TO=890.1n

.meas tran Vdout0_41ck68 AVG v(dout0_41) FROM=889.9n TO=890.1n

.meas tran Vdout0_42ck68 AVG v(dout0_42) FROM=889.9n TO=890.1n

.meas tran Vdout0_43ck68 AVG v(dout0_43) FROM=889.9n TO=890.1n

.meas tran Vdout0_44ck68 AVG v(dout0_44) FROM=889.9n TO=890.1n

.meas tran Vdout0_45ck68 AVG v(dout0_45) FROM=889.9n TO=890.1n

.meas tran Vdout0_46ck68 AVG v(dout0_46) FROM=889.9n TO=890.1n

.meas tran Vdout0_47ck68 AVG v(dout0_47) FROM=889.9n TO=890.1n

.meas tran Vdout0_48ck68 AVG v(dout0_48) FROM=889.9n TO=890.1n

.meas tran Vdout0_49ck68 AVG v(dout0_49) FROM=889.9n TO=890.1n

.meas tran Vdout0_50ck68 AVG v(dout0_50) FROM=889.9n TO=890.1n

.meas tran Vdout0_51ck68 AVG v(dout0_51) FROM=889.9n TO=890.1n

.meas tran Vdout0_52ck68 AVG v(dout0_52) FROM=889.9n TO=890.1n

.meas tran Vdout0_53ck68 AVG v(dout0_53) FROM=889.9n TO=890.1n

.meas tran Vdout0_54ck68 AVG v(dout0_54) FROM=889.9n TO=890.1n

.meas tran Vdout0_55ck68 AVG v(dout0_55) FROM=889.9n TO=890.1n

.meas tran Vdout0_56ck68 AVG v(dout0_56) FROM=889.9n TO=890.1n

.meas tran Vdout0_57ck68 AVG v(dout0_57) FROM=889.9n TO=890.1n

.meas tran Vdout0_58ck68 AVG v(dout0_58) FROM=889.9n TO=890.1n

.meas tran Vdout0_59ck68 AVG v(dout0_59) FROM=889.9n TO=890.1n

.meas tran Vdout0_60ck68 AVG v(dout0_60) FROM=889.9n TO=890.1n

.meas tran Vdout0_61ck68 AVG v(dout0_61) FROM=889.9n TO=890.1n

.meas tran Vdout0_62ck68 AVG v(dout0_62) FROM=889.9n TO=890.1n

.meas tran Vdout0_63ck68 AVG v(dout0_63) FROM=889.9n TO=890.1n

.meas tran Vdout0_64ck68 AVG v(dout0_64) FROM=889.9n TO=890.1n

.meas tran Vdout0_65ck68 AVG v(dout0_65) FROM=889.9n TO=890.1n

.meas tran Vdout0_66ck68 AVG v(dout0_66) FROM=889.9n TO=890.1n

.meas tran Vdout0_67ck68 AVG v(dout0_67) FROM=889.9n TO=890.1n

.meas tran Vdout0_68ck68 AVG v(dout0_68) FROM=889.9n TO=890.1n

.meas tran Vdout0_69ck68 AVG v(dout0_69) FROM=889.9n TO=890.1n

.meas tran Vdout0_70ck68 AVG v(dout0_70) FROM=889.9n TO=890.1n

.meas tran Vdout0_71ck68 AVG v(dout0_71) FROM=889.9n TO=890.1n

.meas tran Vdout0_72ck68 AVG v(dout0_72) FROM=889.9n TO=890.1n

.meas tran Vdout0_73ck68 AVG v(dout0_73) FROM=889.9n TO=890.1n

.meas tran Vdout0_74ck68 AVG v(dout0_74) FROM=889.9n TO=890.1n

.meas tran Vdout0_75ck68 AVG v(dout0_75) FROM=889.9n TO=890.1n

.meas tran Vdout0_76ck68 AVG v(dout0_76) FROM=889.9n TO=890.1n

.meas tran Vdout0_77ck68 AVG v(dout0_77) FROM=889.9n TO=890.1n

.meas tran Vdout0_78ck68 AVG v(dout0_78) FROM=889.9n TO=890.1n

.meas tran Vdout0_79ck68 AVG v(dout0_79) FROM=889.9n TO=890.1n

.meas tran Vdout0_0ck69 AVG v(dout0_0) FROM=909.9n TO=910.1n

.meas tran Vdout0_1ck69 AVG v(dout0_1) FROM=909.9n TO=910.1n

.meas tran Vdout0_2ck69 AVG v(dout0_2) FROM=909.9n TO=910.1n

.meas tran Vdout0_3ck69 AVG v(dout0_3) FROM=909.9n TO=910.1n

.meas tran Vdout0_4ck69 AVG v(dout0_4) FROM=909.9n TO=910.1n

.meas tran Vdout0_5ck69 AVG v(dout0_5) FROM=909.9n TO=910.1n

.meas tran Vdout0_6ck69 AVG v(dout0_6) FROM=909.9n TO=910.1n

.meas tran Vdout0_7ck69 AVG v(dout0_7) FROM=909.9n TO=910.1n

.meas tran Vdout0_8ck69 AVG v(dout0_8) FROM=909.9n TO=910.1n

.meas tran Vdout0_9ck69 AVG v(dout0_9) FROM=909.9n TO=910.1n

.meas tran Vdout0_10ck69 AVG v(dout0_10) FROM=909.9n TO=910.1n

.meas tran Vdout0_11ck69 AVG v(dout0_11) FROM=909.9n TO=910.1n

.meas tran Vdout0_12ck69 AVG v(dout0_12) FROM=909.9n TO=910.1n

.meas tran Vdout0_13ck69 AVG v(dout0_13) FROM=909.9n TO=910.1n

.meas tran Vdout0_14ck69 AVG v(dout0_14) FROM=909.9n TO=910.1n

.meas tran Vdout0_15ck69 AVG v(dout0_15) FROM=909.9n TO=910.1n

.meas tran Vdout0_16ck69 AVG v(dout0_16) FROM=909.9n TO=910.1n

.meas tran Vdout0_17ck69 AVG v(dout0_17) FROM=909.9n TO=910.1n

.meas tran Vdout0_18ck69 AVG v(dout0_18) FROM=909.9n TO=910.1n

.meas tran Vdout0_19ck69 AVG v(dout0_19) FROM=909.9n TO=910.1n

.meas tran Vdout0_20ck69 AVG v(dout0_20) FROM=909.9n TO=910.1n

.meas tran Vdout0_21ck69 AVG v(dout0_21) FROM=909.9n TO=910.1n

.meas tran Vdout0_22ck69 AVG v(dout0_22) FROM=909.9n TO=910.1n

.meas tran Vdout0_23ck69 AVG v(dout0_23) FROM=909.9n TO=910.1n

.meas tran Vdout0_24ck69 AVG v(dout0_24) FROM=909.9n TO=910.1n

.meas tran Vdout0_25ck69 AVG v(dout0_25) FROM=909.9n TO=910.1n

.meas tran Vdout0_26ck69 AVG v(dout0_26) FROM=909.9n TO=910.1n

.meas tran Vdout0_27ck69 AVG v(dout0_27) FROM=909.9n TO=910.1n

.meas tran Vdout0_28ck69 AVG v(dout0_28) FROM=909.9n TO=910.1n

.meas tran Vdout0_29ck69 AVG v(dout0_29) FROM=909.9n TO=910.1n

.meas tran Vdout0_30ck69 AVG v(dout0_30) FROM=909.9n TO=910.1n

.meas tran Vdout0_31ck69 AVG v(dout0_31) FROM=909.9n TO=910.1n

.meas tran Vdout0_32ck69 AVG v(dout0_32) FROM=909.9n TO=910.1n

.meas tran Vdout0_33ck69 AVG v(dout0_33) FROM=909.9n TO=910.1n

.meas tran Vdout0_34ck69 AVG v(dout0_34) FROM=909.9n TO=910.1n

.meas tran Vdout0_35ck69 AVG v(dout0_35) FROM=909.9n TO=910.1n

.meas tran Vdout0_36ck69 AVG v(dout0_36) FROM=909.9n TO=910.1n

.meas tran Vdout0_37ck69 AVG v(dout0_37) FROM=909.9n TO=910.1n

.meas tran Vdout0_38ck69 AVG v(dout0_38) FROM=909.9n TO=910.1n

.meas tran Vdout0_39ck69 AVG v(dout0_39) FROM=909.9n TO=910.1n

.meas tran Vdout0_40ck69 AVG v(dout0_40) FROM=909.9n TO=910.1n

.meas tran Vdout0_41ck69 AVG v(dout0_41) FROM=909.9n TO=910.1n

.meas tran Vdout0_42ck69 AVG v(dout0_42) FROM=909.9n TO=910.1n

.meas tran Vdout0_43ck69 AVG v(dout0_43) FROM=909.9n TO=910.1n

.meas tran Vdout0_44ck69 AVG v(dout0_44) FROM=909.9n TO=910.1n

.meas tran Vdout0_45ck69 AVG v(dout0_45) FROM=909.9n TO=910.1n

.meas tran Vdout0_46ck69 AVG v(dout0_46) FROM=909.9n TO=910.1n

.meas tran Vdout0_47ck69 AVG v(dout0_47) FROM=909.9n TO=910.1n

.meas tran Vdout0_48ck69 AVG v(dout0_48) FROM=909.9n TO=910.1n

.meas tran Vdout0_49ck69 AVG v(dout0_49) FROM=909.9n TO=910.1n

.meas tran Vdout0_50ck69 AVG v(dout0_50) FROM=909.9n TO=910.1n

.meas tran Vdout0_51ck69 AVG v(dout0_51) FROM=909.9n TO=910.1n

.meas tran Vdout0_52ck69 AVG v(dout0_52) FROM=909.9n TO=910.1n

.meas tran Vdout0_53ck69 AVG v(dout0_53) FROM=909.9n TO=910.1n

.meas tran Vdout0_54ck69 AVG v(dout0_54) FROM=909.9n TO=910.1n

.meas tran Vdout0_55ck69 AVG v(dout0_55) FROM=909.9n TO=910.1n

.meas tran Vdout0_56ck69 AVG v(dout0_56) FROM=909.9n TO=910.1n

.meas tran Vdout0_57ck69 AVG v(dout0_57) FROM=909.9n TO=910.1n

.meas tran Vdout0_58ck69 AVG v(dout0_58) FROM=909.9n TO=910.1n

.meas tran Vdout0_59ck69 AVG v(dout0_59) FROM=909.9n TO=910.1n

.meas tran Vdout0_60ck69 AVG v(dout0_60) FROM=909.9n TO=910.1n

.meas tran Vdout0_61ck69 AVG v(dout0_61) FROM=909.9n TO=910.1n

.meas tran Vdout0_62ck69 AVG v(dout0_62) FROM=909.9n TO=910.1n

.meas tran Vdout0_63ck69 AVG v(dout0_63) FROM=909.9n TO=910.1n

.meas tran Vdout0_64ck69 AVG v(dout0_64) FROM=909.9n TO=910.1n

.meas tran Vdout0_65ck69 AVG v(dout0_65) FROM=909.9n TO=910.1n

.meas tran Vdout0_66ck69 AVG v(dout0_66) FROM=909.9n TO=910.1n

.meas tran Vdout0_67ck69 AVG v(dout0_67) FROM=909.9n TO=910.1n

.meas tran Vdout0_68ck69 AVG v(dout0_68) FROM=909.9n TO=910.1n

.meas tran Vdout0_69ck69 AVG v(dout0_69) FROM=909.9n TO=910.1n

.meas tran Vdout0_70ck69 AVG v(dout0_70) FROM=909.9n TO=910.1n

.meas tran Vdout0_71ck69 AVG v(dout0_71) FROM=909.9n TO=910.1n

.meas tran Vdout0_72ck69 AVG v(dout0_72) FROM=909.9n TO=910.1n

.meas tran Vdout0_73ck69 AVG v(dout0_73) FROM=909.9n TO=910.1n

.meas tran Vdout0_74ck69 AVG v(dout0_74) FROM=909.9n TO=910.1n

.meas tran Vdout0_75ck69 AVG v(dout0_75) FROM=909.9n TO=910.1n

.meas tran Vdout0_76ck69 AVG v(dout0_76) FROM=909.9n TO=910.1n

.meas tran Vdout0_77ck69 AVG v(dout0_77) FROM=909.9n TO=910.1n

.meas tran Vdout0_78ck69 AVG v(dout0_78) FROM=909.9n TO=910.1n

.meas tran Vdout0_79ck69 AVG v(dout0_79) FROM=909.9n TO=910.1n

.meas tran Vdout1_0ck70 AVG v(dout1_0) FROM=919.9n TO=920.1n

.meas tran Vdout1_1ck70 AVG v(dout1_1) FROM=919.9n TO=920.1n

.meas tran Vdout1_2ck70 AVG v(dout1_2) FROM=919.9n TO=920.1n

.meas tran Vdout1_3ck70 AVG v(dout1_3) FROM=919.9n TO=920.1n

.meas tran Vdout1_4ck70 AVG v(dout1_4) FROM=919.9n TO=920.1n

.meas tran Vdout1_5ck70 AVG v(dout1_5) FROM=919.9n TO=920.1n

.meas tran Vdout1_6ck70 AVG v(dout1_6) FROM=919.9n TO=920.1n

.meas tran Vdout1_7ck70 AVG v(dout1_7) FROM=919.9n TO=920.1n

.meas tran Vdout1_8ck70 AVG v(dout1_8) FROM=919.9n TO=920.1n

.meas tran Vdout1_9ck70 AVG v(dout1_9) FROM=919.9n TO=920.1n

.meas tran Vdout1_10ck70 AVG v(dout1_10) FROM=919.9n TO=920.1n

.meas tran Vdout1_11ck70 AVG v(dout1_11) FROM=919.9n TO=920.1n

.meas tran Vdout1_12ck70 AVG v(dout1_12) FROM=919.9n TO=920.1n

.meas tran Vdout1_13ck70 AVG v(dout1_13) FROM=919.9n TO=920.1n

.meas tran Vdout1_14ck70 AVG v(dout1_14) FROM=919.9n TO=920.1n

.meas tran Vdout1_15ck70 AVG v(dout1_15) FROM=919.9n TO=920.1n

.meas tran Vdout1_16ck70 AVG v(dout1_16) FROM=919.9n TO=920.1n

.meas tran Vdout1_17ck70 AVG v(dout1_17) FROM=919.9n TO=920.1n

.meas tran Vdout1_18ck70 AVG v(dout1_18) FROM=919.9n TO=920.1n

.meas tran Vdout1_19ck70 AVG v(dout1_19) FROM=919.9n TO=920.1n

.meas tran Vdout1_20ck70 AVG v(dout1_20) FROM=919.9n TO=920.1n

.meas tran Vdout1_21ck70 AVG v(dout1_21) FROM=919.9n TO=920.1n

.meas tran Vdout1_22ck70 AVG v(dout1_22) FROM=919.9n TO=920.1n

.meas tran Vdout1_23ck70 AVG v(dout1_23) FROM=919.9n TO=920.1n

.meas tran Vdout1_24ck70 AVG v(dout1_24) FROM=919.9n TO=920.1n

.meas tran Vdout1_25ck70 AVG v(dout1_25) FROM=919.9n TO=920.1n

.meas tran Vdout1_26ck70 AVG v(dout1_26) FROM=919.9n TO=920.1n

.meas tran Vdout1_27ck70 AVG v(dout1_27) FROM=919.9n TO=920.1n

.meas tran Vdout1_28ck70 AVG v(dout1_28) FROM=919.9n TO=920.1n

.meas tran Vdout1_29ck70 AVG v(dout1_29) FROM=919.9n TO=920.1n

.meas tran Vdout1_30ck70 AVG v(dout1_30) FROM=919.9n TO=920.1n

.meas tran Vdout1_31ck70 AVG v(dout1_31) FROM=919.9n TO=920.1n

.meas tran Vdout1_32ck70 AVG v(dout1_32) FROM=919.9n TO=920.1n

.meas tran Vdout1_33ck70 AVG v(dout1_33) FROM=919.9n TO=920.1n

.meas tran Vdout1_34ck70 AVG v(dout1_34) FROM=919.9n TO=920.1n

.meas tran Vdout1_35ck70 AVG v(dout1_35) FROM=919.9n TO=920.1n

.meas tran Vdout1_36ck70 AVG v(dout1_36) FROM=919.9n TO=920.1n

.meas tran Vdout1_37ck70 AVG v(dout1_37) FROM=919.9n TO=920.1n

.meas tran Vdout1_38ck70 AVG v(dout1_38) FROM=919.9n TO=920.1n

.meas tran Vdout1_39ck70 AVG v(dout1_39) FROM=919.9n TO=920.1n

.meas tran Vdout1_40ck70 AVG v(dout1_40) FROM=919.9n TO=920.1n

.meas tran Vdout1_41ck70 AVG v(dout1_41) FROM=919.9n TO=920.1n

.meas tran Vdout1_42ck70 AVG v(dout1_42) FROM=919.9n TO=920.1n

.meas tran Vdout1_43ck70 AVG v(dout1_43) FROM=919.9n TO=920.1n

.meas tran Vdout1_44ck70 AVG v(dout1_44) FROM=919.9n TO=920.1n

.meas tran Vdout1_45ck70 AVG v(dout1_45) FROM=919.9n TO=920.1n

.meas tran Vdout1_46ck70 AVG v(dout1_46) FROM=919.9n TO=920.1n

.meas tran Vdout1_47ck70 AVG v(dout1_47) FROM=919.9n TO=920.1n

.meas tran Vdout1_48ck70 AVG v(dout1_48) FROM=919.9n TO=920.1n

.meas tran Vdout1_49ck70 AVG v(dout1_49) FROM=919.9n TO=920.1n

.meas tran Vdout1_50ck70 AVG v(dout1_50) FROM=919.9n TO=920.1n

.meas tran Vdout1_51ck70 AVG v(dout1_51) FROM=919.9n TO=920.1n

.meas tran Vdout1_52ck70 AVG v(dout1_52) FROM=919.9n TO=920.1n

.meas tran Vdout1_53ck70 AVG v(dout1_53) FROM=919.9n TO=920.1n

.meas tran Vdout1_54ck70 AVG v(dout1_54) FROM=919.9n TO=920.1n

.meas tran Vdout1_55ck70 AVG v(dout1_55) FROM=919.9n TO=920.1n

.meas tran Vdout1_56ck70 AVG v(dout1_56) FROM=919.9n TO=920.1n

.meas tran Vdout1_57ck70 AVG v(dout1_57) FROM=919.9n TO=920.1n

.meas tran Vdout1_58ck70 AVG v(dout1_58) FROM=919.9n TO=920.1n

.meas tran Vdout1_59ck70 AVG v(dout1_59) FROM=919.9n TO=920.1n

.meas tran Vdout1_60ck70 AVG v(dout1_60) FROM=919.9n TO=920.1n

.meas tran Vdout1_61ck70 AVG v(dout1_61) FROM=919.9n TO=920.1n

.meas tran Vdout1_62ck70 AVG v(dout1_62) FROM=919.9n TO=920.1n

.meas tran Vdout1_63ck70 AVG v(dout1_63) FROM=919.9n TO=920.1n

.meas tran Vdout1_64ck70 AVG v(dout1_64) FROM=919.9n TO=920.1n

.meas tran Vdout1_65ck70 AVG v(dout1_65) FROM=919.9n TO=920.1n

.meas tran Vdout1_66ck70 AVG v(dout1_66) FROM=919.9n TO=920.1n

.meas tran Vdout1_67ck70 AVG v(dout1_67) FROM=919.9n TO=920.1n

.meas tran Vdout1_68ck70 AVG v(dout1_68) FROM=919.9n TO=920.1n

.meas tran Vdout1_69ck70 AVG v(dout1_69) FROM=919.9n TO=920.1n

.meas tran Vdout1_70ck70 AVG v(dout1_70) FROM=919.9n TO=920.1n

.meas tran Vdout1_71ck70 AVG v(dout1_71) FROM=919.9n TO=920.1n

.meas tran Vdout1_72ck70 AVG v(dout1_72) FROM=919.9n TO=920.1n

.meas tran Vdout1_73ck70 AVG v(dout1_73) FROM=919.9n TO=920.1n

.meas tran Vdout1_74ck70 AVG v(dout1_74) FROM=919.9n TO=920.1n

.meas tran Vdout1_75ck70 AVG v(dout1_75) FROM=919.9n TO=920.1n

.meas tran Vdout1_76ck70 AVG v(dout1_76) FROM=919.9n TO=920.1n

.meas tran Vdout1_77ck70 AVG v(dout1_77) FROM=919.9n TO=920.1n

.meas tran Vdout1_78ck70 AVG v(dout1_78) FROM=919.9n TO=920.1n

.meas tran Vdout1_79ck70 AVG v(dout1_79) FROM=919.9n TO=920.1n

.meas tran Vdout0_0ck71 AVG v(dout0_0) FROM=929.9n TO=930.1n

.meas tran Vdout0_1ck71 AVG v(dout0_1) FROM=929.9n TO=930.1n

.meas tran Vdout0_2ck71 AVG v(dout0_2) FROM=929.9n TO=930.1n

.meas tran Vdout0_3ck71 AVG v(dout0_3) FROM=929.9n TO=930.1n

.meas tran Vdout0_4ck71 AVG v(dout0_4) FROM=929.9n TO=930.1n

.meas tran Vdout0_5ck71 AVG v(dout0_5) FROM=929.9n TO=930.1n

.meas tran Vdout0_6ck71 AVG v(dout0_6) FROM=929.9n TO=930.1n

.meas tran Vdout0_7ck71 AVG v(dout0_7) FROM=929.9n TO=930.1n

.meas tran Vdout0_8ck71 AVG v(dout0_8) FROM=929.9n TO=930.1n

.meas tran Vdout0_9ck71 AVG v(dout0_9) FROM=929.9n TO=930.1n

.meas tran Vdout0_10ck71 AVG v(dout0_10) FROM=929.9n TO=930.1n

.meas tran Vdout0_11ck71 AVG v(dout0_11) FROM=929.9n TO=930.1n

.meas tran Vdout0_12ck71 AVG v(dout0_12) FROM=929.9n TO=930.1n

.meas tran Vdout0_13ck71 AVG v(dout0_13) FROM=929.9n TO=930.1n

.meas tran Vdout0_14ck71 AVG v(dout0_14) FROM=929.9n TO=930.1n

.meas tran Vdout0_15ck71 AVG v(dout0_15) FROM=929.9n TO=930.1n

.meas tran Vdout0_16ck71 AVG v(dout0_16) FROM=929.9n TO=930.1n

.meas tran Vdout0_17ck71 AVG v(dout0_17) FROM=929.9n TO=930.1n

.meas tran Vdout0_18ck71 AVG v(dout0_18) FROM=929.9n TO=930.1n

.meas tran Vdout0_19ck71 AVG v(dout0_19) FROM=929.9n TO=930.1n

.meas tran Vdout0_20ck71 AVG v(dout0_20) FROM=929.9n TO=930.1n

.meas tran Vdout0_21ck71 AVG v(dout0_21) FROM=929.9n TO=930.1n

.meas tran Vdout0_22ck71 AVG v(dout0_22) FROM=929.9n TO=930.1n

.meas tran Vdout0_23ck71 AVG v(dout0_23) FROM=929.9n TO=930.1n

.meas tran Vdout0_24ck71 AVG v(dout0_24) FROM=929.9n TO=930.1n

.meas tran Vdout0_25ck71 AVG v(dout0_25) FROM=929.9n TO=930.1n

.meas tran Vdout0_26ck71 AVG v(dout0_26) FROM=929.9n TO=930.1n

.meas tran Vdout0_27ck71 AVG v(dout0_27) FROM=929.9n TO=930.1n

.meas tran Vdout0_28ck71 AVG v(dout0_28) FROM=929.9n TO=930.1n

.meas tran Vdout0_29ck71 AVG v(dout0_29) FROM=929.9n TO=930.1n

.meas tran Vdout0_30ck71 AVG v(dout0_30) FROM=929.9n TO=930.1n

.meas tran Vdout0_31ck71 AVG v(dout0_31) FROM=929.9n TO=930.1n

.meas tran Vdout0_32ck71 AVG v(dout0_32) FROM=929.9n TO=930.1n

.meas tran Vdout0_33ck71 AVG v(dout0_33) FROM=929.9n TO=930.1n

.meas tran Vdout0_34ck71 AVG v(dout0_34) FROM=929.9n TO=930.1n

.meas tran Vdout0_35ck71 AVG v(dout0_35) FROM=929.9n TO=930.1n

.meas tran Vdout0_36ck71 AVG v(dout0_36) FROM=929.9n TO=930.1n

.meas tran Vdout0_37ck71 AVG v(dout0_37) FROM=929.9n TO=930.1n

.meas tran Vdout0_38ck71 AVG v(dout0_38) FROM=929.9n TO=930.1n

.meas tran Vdout0_39ck71 AVG v(dout0_39) FROM=929.9n TO=930.1n

.meas tran Vdout0_40ck71 AVG v(dout0_40) FROM=929.9n TO=930.1n

.meas tran Vdout0_41ck71 AVG v(dout0_41) FROM=929.9n TO=930.1n

.meas tran Vdout0_42ck71 AVG v(dout0_42) FROM=929.9n TO=930.1n

.meas tran Vdout0_43ck71 AVG v(dout0_43) FROM=929.9n TO=930.1n

.meas tran Vdout0_44ck71 AVG v(dout0_44) FROM=929.9n TO=930.1n

.meas tran Vdout0_45ck71 AVG v(dout0_45) FROM=929.9n TO=930.1n

.meas tran Vdout0_46ck71 AVG v(dout0_46) FROM=929.9n TO=930.1n

.meas tran Vdout0_47ck71 AVG v(dout0_47) FROM=929.9n TO=930.1n

.meas tran Vdout0_48ck71 AVG v(dout0_48) FROM=929.9n TO=930.1n

.meas tran Vdout0_49ck71 AVG v(dout0_49) FROM=929.9n TO=930.1n

.meas tran Vdout0_50ck71 AVG v(dout0_50) FROM=929.9n TO=930.1n

.meas tran Vdout0_51ck71 AVG v(dout0_51) FROM=929.9n TO=930.1n

.meas tran Vdout0_52ck71 AVG v(dout0_52) FROM=929.9n TO=930.1n

.meas tran Vdout0_53ck71 AVG v(dout0_53) FROM=929.9n TO=930.1n

.meas tran Vdout0_54ck71 AVG v(dout0_54) FROM=929.9n TO=930.1n

.meas tran Vdout0_55ck71 AVG v(dout0_55) FROM=929.9n TO=930.1n

.meas tran Vdout0_56ck71 AVG v(dout0_56) FROM=929.9n TO=930.1n

.meas tran Vdout0_57ck71 AVG v(dout0_57) FROM=929.9n TO=930.1n

.meas tran Vdout0_58ck71 AVG v(dout0_58) FROM=929.9n TO=930.1n

.meas tran Vdout0_59ck71 AVG v(dout0_59) FROM=929.9n TO=930.1n

.meas tran Vdout0_60ck71 AVG v(dout0_60) FROM=929.9n TO=930.1n

.meas tran Vdout0_61ck71 AVG v(dout0_61) FROM=929.9n TO=930.1n

.meas tran Vdout0_62ck71 AVG v(dout0_62) FROM=929.9n TO=930.1n

.meas tran Vdout0_63ck71 AVG v(dout0_63) FROM=929.9n TO=930.1n

.meas tran Vdout0_64ck71 AVG v(dout0_64) FROM=929.9n TO=930.1n

.meas tran Vdout0_65ck71 AVG v(dout0_65) FROM=929.9n TO=930.1n

.meas tran Vdout0_66ck71 AVG v(dout0_66) FROM=929.9n TO=930.1n

.meas tran Vdout0_67ck71 AVG v(dout0_67) FROM=929.9n TO=930.1n

.meas tran Vdout0_68ck71 AVG v(dout0_68) FROM=929.9n TO=930.1n

.meas tran Vdout0_69ck71 AVG v(dout0_69) FROM=929.9n TO=930.1n

.meas tran Vdout0_70ck71 AVG v(dout0_70) FROM=929.9n TO=930.1n

.meas tran Vdout0_71ck71 AVG v(dout0_71) FROM=929.9n TO=930.1n

.meas tran Vdout0_72ck71 AVG v(dout0_72) FROM=929.9n TO=930.1n

.meas tran Vdout0_73ck71 AVG v(dout0_73) FROM=929.9n TO=930.1n

.meas tran Vdout0_74ck71 AVG v(dout0_74) FROM=929.9n TO=930.1n

.meas tran Vdout0_75ck71 AVG v(dout0_75) FROM=929.9n TO=930.1n

.meas tran Vdout0_76ck71 AVG v(dout0_76) FROM=929.9n TO=930.1n

.meas tran Vdout0_77ck71 AVG v(dout0_77) FROM=929.9n TO=930.1n

.meas tran Vdout0_78ck71 AVG v(dout0_78) FROM=929.9n TO=930.1n

.meas tran Vdout0_79ck71 AVG v(dout0_79) FROM=929.9n TO=930.1n

.meas tran Vdout1_0ck72 AVG v(dout1_0) FROM=929.9n TO=930.1n

.meas tran Vdout1_1ck72 AVG v(dout1_1) FROM=929.9n TO=930.1n

.meas tran Vdout1_2ck72 AVG v(dout1_2) FROM=929.9n TO=930.1n

.meas tran Vdout1_3ck72 AVG v(dout1_3) FROM=929.9n TO=930.1n

.meas tran Vdout1_4ck72 AVG v(dout1_4) FROM=929.9n TO=930.1n

.meas tran Vdout1_5ck72 AVG v(dout1_5) FROM=929.9n TO=930.1n

.meas tran Vdout1_6ck72 AVG v(dout1_6) FROM=929.9n TO=930.1n

.meas tran Vdout1_7ck72 AVG v(dout1_7) FROM=929.9n TO=930.1n

.meas tran Vdout1_8ck72 AVG v(dout1_8) FROM=929.9n TO=930.1n

.meas tran Vdout1_9ck72 AVG v(dout1_9) FROM=929.9n TO=930.1n

.meas tran Vdout1_10ck72 AVG v(dout1_10) FROM=929.9n TO=930.1n

.meas tran Vdout1_11ck72 AVG v(dout1_11) FROM=929.9n TO=930.1n

.meas tran Vdout1_12ck72 AVG v(dout1_12) FROM=929.9n TO=930.1n

.meas tran Vdout1_13ck72 AVG v(dout1_13) FROM=929.9n TO=930.1n

.meas tran Vdout1_14ck72 AVG v(dout1_14) FROM=929.9n TO=930.1n

.meas tran Vdout1_15ck72 AVG v(dout1_15) FROM=929.9n TO=930.1n

.meas tran Vdout1_16ck72 AVG v(dout1_16) FROM=929.9n TO=930.1n

.meas tran Vdout1_17ck72 AVG v(dout1_17) FROM=929.9n TO=930.1n

.meas tran Vdout1_18ck72 AVG v(dout1_18) FROM=929.9n TO=930.1n

.meas tran Vdout1_19ck72 AVG v(dout1_19) FROM=929.9n TO=930.1n

.meas tran Vdout1_20ck72 AVG v(dout1_20) FROM=929.9n TO=930.1n

.meas tran Vdout1_21ck72 AVG v(dout1_21) FROM=929.9n TO=930.1n

.meas tran Vdout1_22ck72 AVG v(dout1_22) FROM=929.9n TO=930.1n

.meas tran Vdout1_23ck72 AVG v(dout1_23) FROM=929.9n TO=930.1n

.meas tran Vdout1_24ck72 AVG v(dout1_24) FROM=929.9n TO=930.1n

.meas tran Vdout1_25ck72 AVG v(dout1_25) FROM=929.9n TO=930.1n

.meas tran Vdout1_26ck72 AVG v(dout1_26) FROM=929.9n TO=930.1n

.meas tran Vdout1_27ck72 AVG v(dout1_27) FROM=929.9n TO=930.1n

.meas tran Vdout1_28ck72 AVG v(dout1_28) FROM=929.9n TO=930.1n

.meas tran Vdout1_29ck72 AVG v(dout1_29) FROM=929.9n TO=930.1n

.meas tran Vdout1_30ck72 AVG v(dout1_30) FROM=929.9n TO=930.1n

.meas tran Vdout1_31ck72 AVG v(dout1_31) FROM=929.9n TO=930.1n

.meas tran Vdout1_32ck72 AVG v(dout1_32) FROM=929.9n TO=930.1n

.meas tran Vdout1_33ck72 AVG v(dout1_33) FROM=929.9n TO=930.1n

.meas tran Vdout1_34ck72 AVG v(dout1_34) FROM=929.9n TO=930.1n

.meas tran Vdout1_35ck72 AVG v(dout1_35) FROM=929.9n TO=930.1n

.meas tran Vdout1_36ck72 AVG v(dout1_36) FROM=929.9n TO=930.1n

.meas tran Vdout1_37ck72 AVG v(dout1_37) FROM=929.9n TO=930.1n

.meas tran Vdout1_38ck72 AVG v(dout1_38) FROM=929.9n TO=930.1n

.meas tran Vdout1_39ck72 AVG v(dout1_39) FROM=929.9n TO=930.1n

.meas tran Vdout1_40ck72 AVG v(dout1_40) FROM=929.9n TO=930.1n

.meas tran Vdout1_41ck72 AVG v(dout1_41) FROM=929.9n TO=930.1n

.meas tran Vdout1_42ck72 AVG v(dout1_42) FROM=929.9n TO=930.1n

.meas tran Vdout1_43ck72 AVG v(dout1_43) FROM=929.9n TO=930.1n

.meas tran Vdout1_44ck72 AVG v(dout1_44) FROM=929.9n TO=930.1n

.meas tran Vdout1_45ck72 AVG v(dout1_45) FROM=929.9n TO=930.1n

.meas tran Vdout1_46ck72 AVG v(dout1_46) FROM=929.9n TO=930.1n

.meas tran Vdout1_47ck72 AVG v(dout1_47) FROM=929.9n TO=930.1n

.meas tran Vdout1_48ck72 AVG v(dout1_48) FROM=929.9n TO=930.1n

.meas tran Vdout1_49ck72 AVG v(dout1_49) FROM=929.9n TO=930.1n

.meas tran Vdout1_50ck72 AVG v(dout1_50) FROM=929.9n TO=930.1n

.meas tran Vdout1_51ck72 AVG v(dout1_51) FROM=929.9n TO=930.1n

.meas tran Vdout1_52ck72 AVG v(dout1_52) FROM=929.9n TO=930.1n

.meas tran Vdout1_53ck72 AVG v(dout1_53) FROM=929.9n TO=930.1n

.meas tran Vdout1_54ck72 AVG v(dout1_54) FROM=929.9n TO=930.1n

.meas tran Vdout1_55ck72 AVG v(dout1_55) FROM=929.9n TO=930.1n

.meas tran Vdout1_56ck72 AVG v(dout1_56) FROM=929.9n TO=930.1n

.meas tran Vdout1_57ck72 AVG v(dout1_57) FROM=929.9n TO=930.1n

.meas tran Vdout1_58ck72 AVG v(dout1_58) FROM=929.9n TO=930.1n

.meas tran Vdout1_59ck72 AVG v(dout1_59) FROM=929.9n TO=930.1n

.meas tran Vdout1_60ck72 AVG v(dout1_60) FROM=929.9n TO=930.1n

.meas tran Vdout1_61ck72 AVG v(dout1_61) FROM=929.9n TO=930.1n

.meas tran Vdout1_62ck72 AVG v(dout1_62) FROM=929.9n TO=930.1n

.meas tran Vdout1_63ck72 AVG v(dout1_63) FROM=929.9n TO=930.1n

.meas tran Vdout1_64ck72 AVG v(dout1_64) FROM=929.9n TO=930.1n

.meas tran Vdout1_65ck72 AVG v(dout1_65) FROM=929.9n TO=930.1n

.meas tran Vdout1_66ck72 AVG v(dout1_66) FROM=929.9n TO=930.1n

.meas tran Vdout1_67ck72 AVG v(dout1_67) FROM=929.9n TO=930.1n

.meas tran Vdout1_68ck72 AVG v(dout1_68) FROM=929.9n TO=930.1n

.meas tran Vdout1_69ck72 AVG v(dout1_69) FROM=929.9n TO=930.1n

.meas tran Vdout1_70ck72 AVG v(dout1_70) FROM=929.9n TO=930.1n

.meas tran Vdout1_71ck72 AVG v(dout1_71) FROM=929.9n TO=930.1n

.meas tran Vdout1_72ck72 AVG v(dout1_72) FROM=929.9n TO=930.1n

.meas tran Vdout1_73ck72 AVG v(dout1_73) FROM=929.9n TO=930.1n

.meas tran Vdout1_74ck72 AVG v(dout1_74) FROM=929.9n TO=930.1n

.meas tran Vdout1_75ck72 AVG v(dout1_75) FROM=929.9n TO=930.1n

.meas tran Vdout1_76ck72 AVG v(dout1_76) FROM=929.9n TO=930.1n

.meas tran Vdout1_77ck72 AVG v(dout1_77) FROM=929.9n TO=930.1n

.meas tran Vdout1_78ck72 AVG v(dout1_78) FROM=929.9n TO=930.1n

.meas tran Vdout1_79ck72 AVG v(dout1_79) FROM=929.9n TO=930.1n

.meas tran Vdout1_0ck73 AVG v(dout1_0) FROM=939.9n TO=940.1n

.meas tran Vdout1_1ck73 AVG v(dout1_1) FROM=939.9n TO=940.1n

.meas tran Vdout1_2ck73 AVG v(dout1_2) FROM=939.9n TO=940.1n

.meas tran Vdout1_3ck73 AVG v(dout1_3) FROM=939.9n TO=940.1n

.meas tran Vdout1_4ck73 AVG v(dout1_4) FROM=939.9n TO=940.1n

.meas tran Vdout1_5ck73 AVG v(dout1_5) FROM=939.9n TO=940.1n

.meas tran Vdout1_6ck73 AVG v(dout1_6) FROM=939.9n TO=940.1n

.meas tran Vdout1_7ck73 AVG v(dout1_7) FROM=939.9n TO=940.1n

.meas tran Vdout1_8ck73 AVG v(dout1_8) FROM=939.9n TO=940.1n

.meas tran Vdout1_9ck73 AVG v(dout1_9) FROM=939.9n TO=940.1n

.meas tran Vdout1_10ck73 AVG v(dout1_10) FROM=939.9n TO=940.1n

.meas tran Vdout1_11ck73 AVG v(dout1_11) FROM=939.9n TO=940.1n

.meas tran Vdout1_12ck73 AVG v(dout1_12) FROM=939.9n TO=940.1n

.meas tran Vdout1_13ck73 AVG v(dout1_13) FROM=939.9n TO=940.1n

.meas tran Vdout1_14ck73 AVG v(dout1_14) FROM=939.9n TO=940.1n

.meas tran Vdout1_15ck73 AVG v(dout1_15) FROM=939.9n TO=940.1n

.meas tran Vdout1_16ck73 AVG v(dout1_16) FROM=939.9n TO=940.1n

.meas tran Vdout1_17ck73 AVG v(dout1_17) FROM=939.9n TO=940.1n

.meas tran Vdout1_18ck73 AVG v(dout1_18) FROM=939.9n TO=940.1n

.meas tran Vdout1_19ck73 AVG v(dout1_19) FROM=939.9n TO=940.1n

.meas tran Vdout1_20ck73 AVG v(dout1_20) FROM=939.9n TO=940.1n

.meas tran Vdout1_21ck73 AVG v(dout1_21) FROM=939.9n TO=940.1n

.meas tran Vdout1_22ck73 AVG v(dout1_22) FROM=939.9n TO=940.1n

.meas tran Vdout1_23ck73 AVG v(dout1_23) FROM=939.9n TO=940.1n

.meas tran Vdout1_24ck73 AVG v(dout1_24) FROM=939.9n TO=940.1n

.meas tran Vdout1_25ck73 AVG v(dout1_25) FROM=939.9n TO=940.1n

.meas tran Vdout1_26ck73 AVG v(dout1_26) FROM=939.9n TO=940.1n

.meas tran Vdout1_27ck73 AVG v(dout1_27) FROM=939.9n TO=940.1n

.meas tran Vdout1_28ck73 AVG v(dout1_28) FROM=939.9n TO=940.1n

.meas tran Vdout1_29ck73 AVG v(dout1_29) FROM=939.9n TO=940.1n

.meas tran Vdout1_30ck73 AVG v(dout1_30) FROM=939.9n TO=940.1n

.meas tran Vdout1_31ck73 AVG v(dout1_31) FROM=939.9n TO=940.1n

.meas tran Vdout1_32ck73 AVG v(dout1_32) FROM=939.9n TO=940.1n

.meas tran Vdout1_33ck73 AVG v(dout1_33) FROM=939.9n TO=940.1n

.meas tran Vdout1_34ck73 AVG v(dout1_34) FROM=939.9n TO=940.1n

.meas tran Vdout1_35ck73 AVG v(dout1_35) FROM=939.9n TO=940.1n

.meas tran Vdout1_36ck73 AVG v(dout1_36) FROM=939.9n TO=940.1n

.meas tran Vdout1_37ck73 AVG v(dout1_37) FROM=939.9n TO=940.1n

.meas tran Vdout1_38ck73 AVG v(dout1_38) FROM=939.9n TO=940.1n

.meas tran Vdout1_39ck73 AVG v(dout1_39) FROM=939.9n TO=940.1n

.meas tran Vdout1_40ck73 AVG v(dout1_40) FROM=939.9n TO=940.1n

.meas tran Vdout1_41ck73 AVG v(dout1_41) FROM=939.9n TO=940.1n

.meas tran Vdout1_42ck73 AVG v(dout1_42) FROM=939.9n TO=940.1n

.meas tran Vdout1_43ck73 AVG v(dout1_43) FROM=939.9n TO=940.1n

.meas tran Vdout1_44ck73 AVG v(dout1_44) FROM=939.9n TO=940.1n

.meas tran Vdout1_45ck73 AVG v(dout1_45) FROM=939.9n TO=940.1n

.meas tran Vdout1_46ck73 AVG v(dout1_46) FROM=939.9n TO=940.1n

.meas tran Vdout1_47ck73 AVG v(dout1_47) FROM=939.9n TO=940.1n

.meas tran Vdout1_48ck73 AVG v(dout1_48) FROM=939.9n TO=940.1n

.meas tran Vdout1_49ck73 AVG v(dout1_49) FROM=939.9n TO=940.1n

.meas tran Vdout1_50ck73 AVG v(dout1_50) FROM=939.9n TO=940.1n

.meas tran Vdout1_51ck73 AVG v(dout1_51) FROM=939.9n TO=940.1n

.meas tran Vdout1_52ck73 AVG v(dout1_52) FROM=939.9n TO=940.1n

.meas tran Vdout1_53ck73 AVG v(dout1_53) FROM=939.9n TO=940.1n

.meas tran Vdout1_54ck73 AVG v(dout1_54) FROM=939.9n TO=940.1n

.meas tran Vdout1_55ck73 AVG v(dout1_55) FROM=939.9n TO=940.1n

.meas tran Vdout1_56ck73 AVG v(dout1_56) FROM=939.9n TO=940.1n

.meas tran Vdout1_57ck73 AVG v(dout1_57) FROM=939.9n TO=940.1n

.meas tran Vdout1_58ck73 AVG v(dout1_58) FROM=939.9n TO=940.1n

.meas tran Vdout1_59ck73 AVG v(dout1_59) FROM=939.9n TO=940.1n

.meas tran Vdout1_60ck73 AVG v(dout1_60) FROM=939.9n TO=940.1n

.meas tran Vdout1_61ck73 AVG v(dout1_61) FROM=939.9n TO=940.1n

.meas tran Vdout1_62ck73 AVG v(dout1_62) FROM=939.9n TO=940.1n

.meas tran Vdout1_63ck73 AVG v(dout1_63) FROM=939.9n TO=940.1n

.meas tran Vdout1_64ck73 AVG v(dout1_64) FROM=939.9n TO=940.1n

.meas tran Vdout1_65ck73 AVG v(dout1_65) FROM=939.9n TO=940.1n

.meas tran Vdout1_66ck73 AVG v(dout1_66) FROM=939.9n TO=940.1n

.meas tran Vdout1_67ck73 AVG v(dout1_67) FROM=939.9n TO=940.1n

.meas tran Vdout1_68ck73 AVG v(dout1_68) FROM=939.9n TO=940.1n

.meas tran Vdout1_69ck73 AVG v(dout1_69) FROM=939.9n TO=940.1n

.meas tran Vdout1_70ck73 AVG v(dout1_70) FROM=939.9n TO=940.1n

.meas tran Vdout1_71ck73 AVG v(dout1_71) FROM=939.9n TO=940.1n

.meas tran Vdout1_72ck73 AVG v(dout1_72) FROM=939.9n TO=940.1n

.meas tran Vdout1_73ck73 AVG v(dout1_73) FROM=939.9n TO=940.1n

.meas tran Vdout1_74ck73 AVG v(dout1_74) FROM=939.9n TO=940.1n

.meas tran Vdout1_75ck73 AVG v(dout1_75) FROM=939.9n TO=940.1n

.meas tran Vdout1_76ck73 AVG v(dout1_76) FROM=939.9n TO=940.1n

.meas tran Vdout1_77ck73 AVG v(dout1_77) FROM=939.9n TO=940.1n

.meas tran Vdout1_78ck73 AVG v(dout1_78) FROM=939.9n TO=940.1n

.meas tran Vdout1_79ck73 AVG v(dout1_79) FROM=939.9n TO=940.1n

.meas tran Vdout0_0ck74 AVG v(dout0_0) FROM=979.9n TO=980.1n

.meas tran Vdout0_1ck74 AVG v(dout0_1) FROM=979.9n TO=980.1n

.meas tran Vdout0_2ck74 AVG v(dout0_2) FROM=979.9n TO=980.1n

.meas tran Vdout0_3ck74 AVG v(dout0_3) FROM=979.9n TO=980.1n

.meas tran Vdout0_4ck74 AVG v(dout0_4) FROM=979.9n TO=980.1n

.meas tran Vdout0_5ck74 AVG v(dout0_5) FROM=979.9n TO=980.1n

.meas tran Vdout0_6ck74 AVG v(dout0_6) FROM=979.9n TO=980.1n

.meas tran Vdout0_7ck74 AVG v(dout0_7) FROM=979.9n TO=980.1n

.meas tran Vdout0_8ck74 AVG v(dout0_8) FROM=979.9n TO=980.1n

.meas tran Vdout0_9ck74 AVG v(dout0_9) FROM=979.9n TO=980.1n

.meas tran Vdout0_10ck74 AVG v(dout0_10) FROM=979.9n TO=980.1n

.meas tran Vdout0_11ck74 AVG v(dout0_11) FROM=979.9n TO=980.1n

.meas tran Vdout0_12ck74 AVG v(dout0_12) FROM=979.9n TO=980.1n

.meas tran Vdout0_13ck74 AVG v(dout0_13) FROM=979.9n TO=980.1n

.meas tran Vdout0_14ck74 AVG v(dout0_14) FROM=979.9n TO=980.1n

.meas tran Vdout0_15ck74 AVG v(dout0_15) FROM=979.9n TO=980.1n

.meas tran Vdout0_16ck74 AVG v(dout0_16) FROM=979.9n TO=980.1n

.meas tran Vdout0_17ck74 AVG v(dout0_17) FROM=979.9n TO=980.1n

.meas tran Vdout0_18ck74 AVG v(dout0_18) FROM=979.9n TO=980.1n

.meas tran Vdout0_19ck74 AVG v(dout0_19) FROM=979.9n TO=980.1n

.meas tran Vdout0_20ck74 AVG v(dout0_20) FROM=979.9n TO=980.1n

.meas tran Vdout0_21ck74 AVG v(dout0_21) FROM=979.9n TO=980.1n

.meas tran Vdout0_22ck74 AVG v(dout0_22) FROM=979.9n TO=980.1n

.meas tran Vdout0_23ck74 AVG v(dout0_23) FROM=979.9n TO=980.1n

.meas tran Vdout0_24ck74 AVG v(dout0_24) FROM=979.9n TO=980.1n

.meas tran Vdout0_25ck74 AVG v(dout0_25) FROM=979.9n TO=980.1n

.meas tran Vdout0_26ck74 AVG v(dout0_26) FROM=979.9n TO=980.1n

.meas tran Vdout0_27ck74 AVG v(dout0_27) FROM=979.9n TO=980.1n

.meas tran Vdout0_28ck74 AVG v(dout0_28) FROM=979.9n TO=980.1n

.meas tran Vdout0_29ck74 AVG v(dout0_29) FROM=979.9n TO=980.1n

.meas tran Vdout0_30ck74 AVG v(dout0_30) FROM=979.9n TO=980.1n

.meas tran Vdout0_31ck74 AVG v(dout0_31) FROM=979.9n TO=980.1n

.meas tran Vdout0_32ck74 AVG v(dout0_32) FROM=979.9n TO=980.1n

.meas tran Vdout0_33ck74 AVG v(dout0_33) FROM=979.9n TO=980.1n

.meas tran Vdout0_34ck74 AVG v(dout0_34) FROM=979.9n TO=980.1n

.meas tran Vdout0_35ck74 AVG v(dout0_35) FROM=979.9n TO=980.1n

.meas tran Vdout0_36ck74 AVG v(dout0_36) FROM=979.9n TO=980.1n

.meas tran Vdout0_37ck74 AVG v(dout0_37) FROM=979.9n TO=980.1n

.meas tran Vdout0_38ck74 AVG v(dout0_38) FROM=979.9n TO=980.1n

.meas tran Vdout0_39ck74 AVG v(dout0_39) FROM=979.9n TO=980.1n

.meas tran Vdout0_40ck74 AVG v(dout0_40) FROM=979.9n TO=980.1n

.meas tran Vdout0_41ck74 AVG v(dout0_41) FROM=979.9n TO=980.1n

.meas tran Vdout0_42ck74 AVG v(dout0_42) FROM=979.9n TO=980.1n

.meas tran Vdout0_43ck74 AVG v(dout0_43) FROM=979.9n TO=980.1n

.meas tran Vdout0_44ck74 AVG v(dout0_44) FROM=979.9n TO=980.1n

.meas tran Vdout0_45ck74 AVG v(dout0_45) FROM=979.9n TO=980.1n

.meas tran Vdout0_46ck74 AVG v(dout0_46) FROM=979.9n TO=980.1n

.meas tran Vdout0_47ck74 AVG v(dout0_47) FROM=979.9n TO=980.1n

.meas tran Vdout0_48ck74 AVG v(dout0_48) FROM=979.9n TO=980.1n

.meas tran Vdout0_49ck74 AVG v(dout0_49) FROM=979.9n TO=980.1n

.meas tran Vdout0_50ck74 AVG v(dout0_50) FROM=979.9n TO=980.1n

.meas tran Vdout0_51ck74 AVG v(dout0_51) FROM=979.9n TO=980.1n

.meas tran Vdout0_52ck74 AVG v(dout0_52) FROM=979.9n TO=980.1n

.meas tran Vdout0_53ck74 AVG v(dout0_53) FROM=979.9n TO=980.1n

.meas tran Vdout0_54ck74 AVG v(dout0_54) FROM=979.9n TO=980.1n

.meas tran Vdout0_55ck74 AVG v(dout0_55) FROM=979.9n TO=980.1n

.meas tran Vdout0_56ck74 AVG v(dout0_56) FROM=979.9n TO=980.1n

.meas tran Vdout0_57ck74 AVG v(dout0_57) FROM=979.9n TO=980.1n

.meas tran Vdout0_58ck74 AVG v(dout0_58) FROM=979.9n TO=980.1n

.meas tran Vdout0_59ck74 AVG v(dout0_59) FROM=979.9n TO=980.1n

.meas tran Vdout0_60ck74 AVG v(dout0_60) FROM=979.9n TO=980.1n

.meas tran Vdout0_61ck74 AVG v(dout0_61) FROM=979.9n TO=980.1n

.meas tran Vdout0_62ck74 AVG v(dout0_62) FROM=979.9n TO=980.1n

.meas tran Vdout0_63ck74 AVG v(dout0_63) FROM=979.9n TO=980.1n

.meas tran Vdout0_64ck74 AVG v(dout0_64) FROM=979.9n TO=980.1n

.meas tran Vdout0_65ck74 AVG v(dout0_65) FROM=979.9n TO=980.1n

.meas tran Vdout0_66ck74 AVG v(dout0_66) FROM=979.9n TO=980.1n

.meas tran Vdout0_67ck74 AVG v(dout0_67) FROM=979.9n TO=980.1n

.meas tran Vdout0_68ck74 AVG v(dout0_68) FROM=979.9n TO=980.1n

.meas tran Vdout0_69ck74 AVG v(dout0_69) FROM=979.9n TO=980.1n

.meas tran Vdout0_70ck74 AVG v(dout0_70) FROM=979.9n TO=980.1n

.meas tran Vdout0_71ck74 AVG v(dout0_71) FROM=979.9n TO=980.1n

.meas tran Vdout0_72ck74 AVG v(dout0_72) FROM=979.9n TO=980.1n

.meas tran Vdout0_73ck74 AVG v(dout0_73) FROM=979.9n TO=980.1n

.meas tran Vdout0_74ck74 AVG v(dout0_74) FROM=979.9n TO=980.1n

.meas tran Vdout0_75ck74 AVG v(dout0_75) FROM=979.9n TO=980.1n

.meas tran Vdout0_76ck74 AVG v(dout0_76) FROM=979.9n TO=980.1n

.meas tran Vdout0_77ck74 AVG v(dout0_77) FROM=979.9n TO=980.1n

.meas tran Vdout0_78ck74 AVG v(dout0_78) FROM=979.9n TO=980.1n

.meas tran Vdout0_79ck74 AVG v(dout0_79) FROM=979.9n TO=980.1n

.meas tran Vdout1_0ck75 AVG v(dout1_0) FROM=979.9n TO=980.1n

.meas tran Vdout1_1ck75 AVG v(dout1_1) FROM=979.9n TO=980.1n

.meas tran Vdout1_2ck75 AVG v(dout1_2) FROM=979.9n TO=980.1n

.meas tran Vdout1_3ck75 AVG v(dout1_3) FROM=979.9n TO=980.1n

.meas tran Vdout1_4ck75 AVG v(dout1_4) FROM=979.9n TO=980.1n

.meas tran Vdout1_5ck75 AVG v(dout1_5) FROM=979.9n TO=980.1n

.meas tran Vdout1_6ck75 AVG v(dout1_6) FROM=979.9n TO=980.1n

.meas tran Vdout1_7ck75 AVG v(dout1_7) FROM=979.9n TO=980.1n

.meas tran Vdout1_8ck75 AVG v(dout1_8) FROM=979.9n TO=980.1n

.meas tran Vdout1_9ck75 AVG v(dout1_9) FROM=979.9n TO=980.1n

.meas tran Vdout1_10ck75 AVG v(dout1_10) FROM=979.9n TO=980.1n

.meas tran Vdout1_11ck75 AVG v(dout1_11) FROM=979.9n TO=980.1n

.meas tran Vdout1_12ck75 AVG v(dout1_12) FROM=979.9n TO=980.1n

.meas tran Vdout1_13ck75 AVG v(dout1_13) FROM=979.9n TO=980.1n

.meas tran Vdout1_14ck75 AVG v(dout1_14) FROM=979.9n TO=980.1n

.meas tran Vdout1_15ck75 AVG v(dout1_15) FROM=979.9n TO=980.1n

.meas tran Vdout1_16ck75 AVG v(dout1_16) FROM=979.9n TO=980.1n

.meas tran Vdout1_17ck75 AVG v(dout1_17) FROM=979.9n TO=980.1n

.meas tran Vdout1_18ck75 AVG v(dout1_18) FROM=979.9n TO=980.1n

.meas tran Vdout1_19ck75 AVG v(dout1_19) FROM=979.9n TO=980.1n

.meas tran Vdout1_20ck75 AVG v(dout1_20) FROM=979.9n TO=980.1n

.meas tran Vdout1_21ck75 AVG v(dout1_21) FROM=979.9n TO=980.1n

.meas tran Vdout1_22ck75 AVG v(dout1_22) FROM=979.9n TO=980.1n

.meas tran Vdout1_23ck75 AVG v(dout1_23) FROM=979.9n TO=980.1n

.meas tran Vdout1_24ck75 AVG v(dout1_24) FROM=979.9n TO=980.1n

.meas tran Vdout1_25ck75 AVG v(dout1_25) FROM=979.9n TO=980.1n

.meas tran Vdout1_26ck75 AVG v(dout1_26) FROM=979.9n TO=980.1n

.meas tran Vdout1_27ck75 AVG v(dout1_27) FROM=979.9n TO=980.1n

.meas tran Vdout1_28ck75 AVG v(dout1_28) FROM=979.9n TO=980.1n

.meas tran Vdout1_29ck75 AVG v(dout1_29) FROM=979.9n TO=980.1n

.meas tran Vdout1_30ck75 AVG v(dout1_30) FROM=979.9n TO=980.1n

.meas tran Vdout1_31ck75 AVG v(dout1_31) FROM=979.9n TO=980.1n

.meas tran Vdout1_32ck75 AVG v(dout1_32) FROM=979.9n TO=980.1n

.meas tran Vdout1_33ck75 AVG v(dout1_33) FROM=979.9n TO=980.1n

.meas tran Vdout1_34ck75 AVG v(dout1_34) FROM=979.9n TO=980.1n

.meas tran Vdout1_35ck75 AVG v(dout1_35) FROM=979.9n TO=980.1n

.meas tran Vdout1_36ck75 AVG v(dout1_36) FROM=979.9n TO=980.1n

.meas tran Vdout1_37ck75 AVG v(dout1_37) FROM=979.9n TO=980.1n

.meas tran Vdout1_38ck75 AVG v(dout1_38) FROM=979.9n TO=980.1n

.meas tran Vdout1_39ck75 AVG v(dout1_39) FROM=979.9n TO=980.1n

.meas tran Vdout1_40ck75 AVG v(dout1_40) FROM=979.9n TO=980.1n

.meas tran Vdout1_41ck75 AVG v(dout1_41) FROM=979.9n TO=980.1n

.meas tran Vdout1_42ck75 AVG v(dout1_42) FROM=979.9n TO=980.1n

.meas tran Vdout1_43ck75 AVG v(dout1_43) FROM=979.9n TO=980.1n

.meas tran Vdout1_44ck75 AVG v(dout1_44) FROM=979.9n TO=980.1n

.meas tran Vdout1_45ck75 AVG v(dout1_45) FROM=979.9n TO=980.1n

.meas tran Vdout1_46ck75 AVG v(dout1_46) FROM=979.9n TO=980.1n

.meas tran Vdout1_47ck75 AVG v(dout1_47) FROM=979.9n TO=980.1n

.meas tran Vdout1_48ck75 AVG v(dout1_48) FROM=979.9n TO=980.1n

.meas tran Vdout1_49ck75 AVG v(dout1_49) FROM=979.9n TO=980.1n

.meas tran Vdout1_50ck75 AVG v(dout1_50) FROM=979.9n TO=980.1n

.meas tran Vdout1_51ck75 AVG v(dout1_51) FROM=979.9n TO=980.1n

.meas tran Vdout1_52ck75 AVG v(dout1_52) FROM=979.9n TO=980.1n

.meas tran Vdout1_53ck75 AVG v(dout1_53) FROM=979.9n TO=980.1n

.meas tran Vdout1_54ck75 AVG v(dout1_54) FROM=979.9n TO=980.1n

.meas tran Vdout1_55ck75 AVG v(dout1_55) FROM=979.9n TO=980.1n

.meas tran Vdout1_56ck75 AVG v(dout1_56) FROM=979.9n TO=980.1n

.meas tran Vdout1_57ck75 AVG v(dout1_57) FROM=979.9n TO=980.1n

.meas tran Vdout1_58ck75 AVG v(dout1_58) FROM=979.9n TO=980.1n

.meas tran Vdout1_59ck75 AVG v(dout1_59) FROM=979.9n TO=980.1n

.meas tran Vdout1_60ck75 AVG v(dout1_60) FROM=979.9n TO=980.1n

.meas tran Vdout1_61ck75 AVG v(dout1_61) FROM=979.9n TO=980.1n

.meas tran Vdout1_62ck75 AVG v(dout1_62) FROM=979.9n TO=980.1n

.meas tran Vdout1_63ck75 AVG v(dout1_63) FROM=979.9n TO=980.1n

.meas tran Vdout1_64ck75 AVG v(dout1_64) FROM=979.9n TO=980.1n

.meas tran Vdout1_65ck75 AVG v(dout1_65) FROM=979.9n TO=980.1n

.meas tran Vdout1_66ck75 AVG v(dout1_66) FROM=979.9n TO=980.1n

.meas tran Vdout1_67ck75 AVG v(dout1_67) FROM=979.9n TO=980.1n

.meas tran Vdout1_68ck75 AVG v(dout1_68) FROM=979.9n TO=980.1n

.meas tran Vdout1_69ck75 AVG v(dout1_69) FROM=979.9n TO=980.1n

.meas tran Vdout1_70ck75 AVG v(dout1_70) FROM=979.9n TO=980.1n

.meas tran Vdout1_71ck75 AVG v(dout1_71) FROM=979.9n TO=980.1n

.meas tran Vdout1_72ck75 AVG v(dout1_72) FROM=979.9n TO=980.1n

.meas tran Vdout1_73ck75 AVG v(dout1_73) FROM=979.9n TO=980.1n

.meas tran Vdout1_74ck75 AVG v(dout1_74) FROM=979.9n TO=980.1n

.meas tran Vdout1_75ck75 AVG v(dout1_75) FROM=979.9n TO=980.1n

.meas tran Vdout1_76ck75 AVG v(dout1_76) FROM=979.9n TO=980.1n

.meas tran Vdout1_77ck75 AVG v(dout1_77) FROM=979.9n TO=980.1n

.meas tran Vdout1_78ck75 AVG v(dout1_78) FROM=979.9n TO=980.1n

.meas tran Vdout1_79ck75 AVG v(dout1_79) FROM=979.9n TO=980.1n

.meas tran Vdout1_0ck76 AVG v(dout1_0) FROM=989.9n TO=990.1n

.meas tran Vdout1_1ck76 AVG v(dout1_1) FROM=989.9n TO=990.1n

.meas tran Vdout1_2ck76 AVG v(dout1_2) FROM=989.9n TO=990.1n

.meas tran Vdout1_3ck76 AVG v(dout1_3) FROM=989.9n TO=990.1n

.meas tran Vdout1_4ck76 AVG v(dout1_4) FROM=989.9n TO=990.1n

.meas tran Vdout1_5ck76 AVG v(dout1_5) FROM=989.9n TO=990.1n

.meas tran Vdout1_6ck76 AVG v(dout1_6) FROM=989.9n TO=990.1n

.meas tran Vdout1_7ck76 AVG v(dout1_7) FROM=989.9n TO=990.1n

.meas tran Vdout1_8ck76 AVG v(dout1_8) FROM=989.9n TO=990.1n

.meas tran Vdout1_9ck76 AVG v(dout1_9) FROM=989.9n TO=990.1n

.meas tran Vdout1_10ck76 AVG v(dout1_10) FROM=989.9n TO=990.1n

.meas tran Vdout1_11ck76 AVG v(dout1_11) FROM=989.9n TO=990.1n

.meas tran Vdout1_12ck76 AVG v(dout1_12) FROM=989.9n TO=990.1n

.meas tran Vdout1_13ck76 AVG v(dout1_13) FROM=989.9n TO=990.1n

.meas tran Vdout1_14ck76 AVG v(dout1_14) FROM=989.9n TO=990.1n

.meas tran Vdout1_15ck76 AVG v(dout1_15) FROM=989.9n TO=990.1n

.meas tran Vdout1_16ck76 AVG v(dout1_16) FROM=989.9n TO=990.1n

.meas tran Vdout1_17ck76 AVG v(dout1_17) FROM=989.9n TO=990.1n

.meas tran Vdout1_18ck76 AVG v(dout1_18) FROM=989.9n TO=990.1n

.meas tran Vdout1_19ck76 AVG v(dout1_19) FROM=989.9n TO=990.1n

.meas tran Vdout1_20ck76 AVG v(dout1_20) FROM=989.9n TO=990.1n

.meas tran Vdout1_21ck76 AVG v(dout1_21) FROM=989.9n TO=990.1n

.meas tran Vdout1_22ck76 AVG v(dout1_22) FROM=989.9n TO=990.1n

.meas tran Vdout1_23ck76 AVG v(dout1_23) FROM=989.9n TO=990.1n

.meas tran Vdout1_24ck76 AVG v(dout1_24) FROM=989.9n TO=990.1n

.meas tran Vdout1_25ck76 AVG v(dout1_25) FROM=989.9n TO=990.1n

.meas tran Vdout1_26ck76 AVG v(dout1_26) FROM=989.9n TO=990.1n

.meas tran Vdout1_27ck76 AVG v(dout1_27) FROM=989.9n TO=990.1n

.meas tran Vdout1_28ck76 AVG v(dout1_28) FROM=989.9n TO=990.1n

.meas tran Vdout1_29ck76 AVG v(dout1_29) FROM=989.9n TO=990.1n

.meas tran Vdout1_30ck76 AVG v(dout1_30) FROM=989.9n TO=990.1n

.meas tran Vdout1_31ck76 AVG v(dout1_31) FROM=989.9n TO=990.1n

.meas tran Vdout1_32ck76 AVG v(dout1_32) FROM=989.9n TO=990.1n

.meas tran Vdout1_33ck76 AVG v(dout1_33) FROM=989.9n TO=990.1n

.meas tran Vdout1_34ck76 AVG v(dout1_34) FROM=989.9n TO=990.1n

.meas tran Vdout1_35ck76 AVG v(dout1_35) FROM=989.9n TO=990.1n

.meas tran Vdout1_36ck76 AVG v(dout1_36) FROM=989.9n TO=990.1n

.meas tran Vdout1_37ck76 AVG v(dout1_37) FROM=989.9n TO=990.1n

.meas tran Vdout1_38ck76 AVG v(dout1_38) FROM=989.9n TO=990.1n

.meas tran Vdout1_39ck76 AVG v(dout1_39) FROM=989.9n TO=990.1n

.meas tran Vdout1_40ck76 AVG v(dout1_40) FROM=989.9n TO=990.1n

.meas tran Vdout1_41ck76 AVG v(dout1_41) FROM=989.9n TO=990.1n

.meas tran Vdout1_42ck76 AVG v(dout1_42) FROM=989.9n TO=990.1n

.meas tran Vdout1_43ck76 AVG v(dout1_43) FROM=989.9n TO=990.1n

.meas tran Vdout1_44ck76 AVG v(dout1_44) FROM=989.9n TO=990.1n

.meas tran Vdout1_45ck76 AVG v(dout1_45) FROM=989.9n TO=990.1n

.meas tran Vdout1_46ck76 AVG v(dout1_46) FROM=989.9n TO=990.1n

.meas tran Vdout1_47ck76 AVG v(dout1_47) FROM=989.9n TO=990.1n

.meas tran Vdout1_48ck76 AVG v(dout1_48) FROM=989.9n TO=990.1n

.meas tran Vdout1_49ck76 AVG v(dout1_49) FROM=989.9n TO=990.1n

.meas tran Vdout1_50ck76 AVG v(dout1_50) FROM=989.9n TO=990.1n

.meas tran Vdout1_51ck76 AVG v(dout1_51) FROM=989.9n TO=990.1n

.meas tran Vdout1_52ck76 AVG v(dout1_52) FROM=989.9n TO=990.1n

.meas tran Vdout1_53ck76 AVG v(dout1_53) FROM=989.9n TO=990.1n

.meas tran Vdout1_54ck76 AVG v(dout1_54) FROM=989.9n TO=990.1n

.meas tran Vdout1_55ck76 AVG v(dout1_55) FROM=989.9n TO=990.1n

.meas tran Vdout1_56ck76 AVG v(dout1_56) FROM=989.9n TO=990.1n

.meas tran Vdout1_57ck76 AVG v(dout1_57) FROM=989.9n TO=990.1n

.meas tran Vdout1_58ck76 AVG v(dout1_58) FROM=989.9n TO=990.1n

.meas tran Vdout1_59ck76 AVG v(dout1_59) FROM=989.9n TO=990.1n

.meas tran Vdout1_60ck76 AVG v(dout1_60) FROM=989.9n TO=990.1n

.meas tran Vdout1_61ck76 AVG v(dout1_61) FROM=989.9n TO=990.1n

.meas tran Vdout1_62ck76 AVG v(dout1_62) FROM=989.9n TO=990.1n

.meas tran Vdout1_63ck76 AVG v(dout1_63) FROM=989.9n TO=990.1n

.meas tran Vdout1_64ck76 AVG v(dout1_64) FROM=989.9n TO=990.1n

.meas tran Vdout1_65ck76 AVG v(dout1_65) FROM=989.9n TO=990.1n

.meas tran Vdout1_66ck76 AVG v(dout1_66) FROM=989.9n TO=990.1n

.meas tran Vdout1_67ck76 AVG v(dout1_67) FROM=989.9n TO=990.1n

.meas tran Vdout1_68ck76 AVG v(dout1_68) FROM=989.9n TO=990.1n

.meas tran Vdout1_69ck76 AVG v(dout1_69) FROM=989.9n TO=990.1n

.meas tran Vdout1_70ck76 AVG v(dout1_70) FROM=989.9n TO=990.1n

.meas tran Vdout1_71ck76 AVG v(dout1_71) FROM=989.9n TO=990.1n

.meas tran Vdout1_72ck76 AVG v(dout1_72) FROM=989.9n TO=990.1n

.meas tran Vdout1_73ck76 AVG v(dout1_73) FROM=989.9n TO=990.1n

.meas tran Vdout1_74ck76 AVG v(dout1_74) FROM=989.9n TO=990.1n

.meas tran Vdout1_75ck76 AVG v(dout1_75) FROM=989.9n TO=990.1n

.meas tran Vdout1_76ck76 AVG v(dout1_76) FROM=989.9n TO=990.1n

.meas tran Vdout1_77ck76 AVG v(dout1_77) FROM=989.9n TO=990.1n

.meas tran Vdout1_78ck76 AVG v(dout1_78) FROM=989.9n TO=990.1n

.meas tran Vdout1_79ck76 AVG v(dout1_79) FROM=989.9n TO=990.1n

.meas tran Vdout1_0ck77 AVG v(dout1_0) FROM=999.9n TO=1000.1n

.meas tran Vdout1_1ck77 AVG v(dout1_1) FROM=999.9n TO=1000.1n

.meas tran Vdout1_2ck77 AVG v(dout1_2) FROM=999.9n TO=1000.1n

.meas tran Vdout1_3ck77 AVG v(dout1_3) FROM=999.9n TO=1000.1n

.meas tran Vdout1_4ck77 AVG v(dout1_4) FROM=999.9n TO=1000.1n

.meas tran Vdout1_5ck77 AVG v(dout1_5) FROM=999.9n TO=1000.1n

.meas tran Vdout1_6ck77 AVG v(dout1_6) FROM=999.9n TO=1000.1n

.meas tran Vdout1_7ck77 AVG v(dout1_7) FROM=999.9n TO=1000.1n

.meas tran Vdout1_8ck77 AVG v(dout1_8) FROM=999.9n TO=1000.1n

.meas tran Vdout1_9ck77 AVG v(dout1_9) FROM=999.9n TO=1000.1n

.meas tran Vdout1_10ck77 AVG v(dout1_10) FROM=999.9n TO=1000.1n

.meas tran Vdout1_11ck77 AVG v(dout1_11) FROM=999.9n TO=1000.1n

.meas tran Vdout1_12ck77 AVG v(dout1_12) FROM=999.9n TO=1000.1n

.meas tran Vdout1_13ck77 AVG v(dout1_13) FROM=999.9n TO=1000.1n

.meas tran Vdout1_14ck77 AVG v(dout1_14) FROM=999.9n TO=1000.1n

.meas tran Vdout1_15ck77 AVG v(dout1_15) FROM=999.9n TO=1000.1n

.meas tran Vdout1_16ck77 AVG v(dout1_16) FROM=999.9n TO=1000.1n

.meas tran Vdout1_17ck77 AVG v(dout1_17) FROM=999.9n TO=1000.1n

.meas tran Vdout1_18ck77 AVG v(dout1_18) FROM=999.9n TO=1000.1n

.meas tran Vdout1_19ck77 AVG v(dout1_19) FROM=999.9n TO=1000.1n

.meas tran Vdout1_20ck77 AVG v(dout1_20) FROM=999.9n TO=1000.1n

.meas tran Vdout1_21ck77 AVG v(dout1_21) FROM=999.9n TO=1000.1n

.meas tran Vdout1_22ck77 AVG v(dout1_22) FROM=999.9n TO=1000.1n

.meas tran Vdout1_23ck77 AVG v(dout1_23) FROM=999.9n TO=1000.1n

.meas tran Vdout1_24ck77 AVG v(dout1_24) FROM=999.9n TO=1000.1n

.meas tran Vdout1_25ck77 AVG v(dout1_25) FROM=999.9n TO=1000.1n

.meas tran Vdout1_26ck77 AVG v(dout1_26) FROM=999.9n TO=1000.1n

.meas tran Vdout1_27ck77 AVG v(dout1_27) FROM=999.9n TO=1000.1n

.meas tran Vdout1_28ck77 AVG v(dout1_28) FROM=999.9n TO=1000.1n

.meas tran Vdout1_29ck77 AVG v(dout1_29) FROM=999.9n TO=1000.1n

.meas tran Vdout1_30ck77 AVG v(dout1_30) FROM=999.9n TO=1000.1n

.meas tran Vdout1_31ck77 AVG v(dout1_31) FROM=999.9n TO=1000.1n

.meas tran Vdout1_32ck77 AVG v(dout1_32) FROM=999.9n TO=1000.1n

.meas tran Vdout1_33ck77 AVG v(dout1_33) FROM=999.9n TO=1000.1n

.meas tran Vdout1_34ck77 AVG v(dout1_34) FROM=999.9n TO=1000.1n

.meas tran Vdout1_35ck77 AVG v(dout1_35) FROM=999.9n TO=1000.1n

.meas tran Vdout1_36ck77 AVG v(dout1_36) FROM=999.9n TO=1000.1n

.meas tran Vdout1_37ck77 AVG v(dout1_37) FROM=999.9n TO=1000.1n

.meas tran Vdout1_38ck77 AVG v(dout1_38) FROM=999.9n TO=1000.1n

.meas tran Vdout1_39ck77 AVG v(dout1_39) FROM=999.9n TO=1000.1n

.meas tran Vdout1_40ck77 AVG v(dout1_40) FROM=999.9n TO=1000.1n

.meas tran Vdout1_41ck77 AVG v(dout1_41) FROM=999.9n TO=1000.1n

.meas tran Vdout1_42ck77 AVG v(dout1_42) FROM=999.9n TO=1000.1n

.meas tran Vdout1_43ck77 AVG v(dout1_43) FROM=999.9n TO=1000.1n

.meas tran Vdout1_44ck77 AVG v(dout1_44) FROM=999.9n TO=1000.1n

.meas tran Vdout1_45ck77 AVG v(dout1_45) FROM=999.9n TO=1000.1n

.meas tran Vdout1_46ck77 AVG v(dout1_46) FROM=999.9n TO=1000.1n

.meas tran Vdout1_47ck77 AVG v(dout1_47) FROM=999.9n TO=1000.1n

.meas tran Vdout1_48ck77 AVG v(dout1_48) FROM=999.9n TO=1000.1n

.meas tran Vdout1_49ck77 AVG v(dout1_49) FROM=999.9n TO=1000.1n

.meas tran Vdout1_50ck77 AVG v(dout1_50) FROM=999.9n TO=1000.1n

.meas tran Vdout1_51ck77 AVG v(dout1_51) FROM=999.9n TO=1000.1n

.meas tran Vdout1_52ck77 AVG v(dout1_52) FROM=999.9n TO=1000.1n

.meas tran Vdout1_53ck77 AVG v(dout1_53) FROM=999.9n TO=1000.1n

.meas tran Vdout1_54ck77 AVG v(dout1_54) FROM=999.9n TO=1000.1n

.meas tran Vdout1_55ck77 AVG v(dout1_55) FROM=999.9n TO=1000.1n

.meas tran Vdout1_56ck77 AVG v(dout1_56) FROM=999.9n TO=1000.1n

.meas tran Vdout1_57ck77 AVG v(dout1_57) FROM=999.9n TO=1000.1n

.meas tran Vdout1_58ck77 AVG v(dout1_58) FROM=999.9n TO=1000.1n

.meas tran Vdout1_59ck77 AVG v(dout1_59) FROM=999.9n TO=1000.1n

.meas tran Vdout1_60ck77 AVG v(dout1_60) FROM=999.9n TO=1000.1n

.meas tran Vdout1_61ck77 AVG v(dout1_61) FROM=999.9n TO=1000.1n

.meas tran Vdout1_62ck77 AVG v(dout1_62) FROM=999.9n TO=1000.1n

.meas tran Vdout1_63ck77 AVG v(dout1_63) FROM=999.9n TO=1000.1n

.meas tran Vdout1_64ck77 AVG v(dout1_64) FROM=999.9n TO=1000.1n

.meas tran Vdout1_65ck77 AVG v(dout1_65) FROM=999.9n TO=1000.1n

.meas tran Vdout1_66ck77 AVG v(dout1_66) FROM=999.9n TO=1000.1n

.meas tran Vdout1_67ck77 AVG v(dout1_67) FROM=999.9n TO=1000.1n

.meas tran Vdout1_68ck77 AVG v(dout1_68) FROM=999.9n TO=1000.1n

.meas tran Vdout1_69ck77 AVG v(dout1_69) FROM=999.9n TO=1000.1n

.meas tran Vdout1_70ck77 AVG v(dout1_70) FROM=999.9n TO=1000.1n

.meas tran Vdout1_71ck77 AVG v(dout1_71) FROM=999.9n TO=1000.1n

.meas tran Vdout1_72ck77 AVG v(dout1_72) FROM=999.9n TO=1000.1n

.meas tran Vdout1_73ck77 AVG v(dout1_73) FROM=999.9n TO=1000.1n

.meas tran Vdout1_74ck77 AVG v(dout1_74) FROM=999.9n TO=1000.1n

.meas tran Vdout1_75ck77 AVG v(dout1_75) FROM=999.9n TO=1000.1n

.meas tran Vdout1_76ck77 AVG v(dout1_76) FROM=999.9n TO=1000.1n

.meas tran Vdout1_77ck77 AVG v(dout1_77) FROM=999.9n TO=1000.1n

.meas tran Vdout1_78ck77 AVG v(dout1_78) FROM=999.9n TO=1000.1n

.meas tran Vdout1_79ck77 AVG v(dout1_79) FROM=999.9n TO=1000.1n

.meas tran Vdout1_0ck78 AVG v(dout1_0) FROM=1019.9n TO=1020.1n

.meas tran Vdout1_1ck78 AVG v(dout1_1) FROM=1019.9n TO=1020.1n

.meas tran Vdout1_2ck78 AVG v(dout1_2) FROM=1019.9n TO=1020.1n

.meas tran Vdout1_3ck78 AVG v(dout1_3) FROM=1019.9n TO=1020.1n

.meas tran Vdout1_4ck78 AVG v(dout1_4) FROM=1019.9n TO=1020.1n

.meas tran Vdout1_5ck78 AVG v(dout1_5) FROM=1019.9n TO=1020.1n

.meas tran Vdout1_6ck78 AVG v(dout1_6) FROM=1019.9n TO=1020.1n

.meas tran Vdout1_7ck78 AVG v(dout1_7) FROM=1019.9n TO=1020.1n

.meas tran Vdout1_8ck78 AVG v(dout1_8) FROM=1019.9n TO=1020.1n

.meas tran Vdout1_9ck78 AVG v(dout1_9) FROM=1019.9n TO=1020.1n

.meas tran Vdout1_10ck78 AVG v(dout1_10) FROM=1019.9n TO=1020.1n

.meas tran Vdout1_11ck78 AVG v(dout1_11) FROM=1019.9n TO=1020.1n

.meas tran Vdout1_12ck78 AVG v(dout1_12) FROM=1019.9n TO=1020.1n

.meas tran Vdout1_13ck78 AVG v(dout1_13) FROM=1019.9n TO=1020.1n

.meas tran Vdout1_14ck78 AVG v(dout1_14) FROM=1019.9n TO=1020.1n

.meas tran Vdout1_15ck78 AVG v(dout1_15) FROM=1019.9n TO=1020.1n

.meas tran Vdout1_16ck78 AVG v(dout1_16) FROM=1019.9n TO=1020.1n

.meas tran Vdout1_17ck78 AVG v(dout1_17) FROM=1019.9n TO=1020.1n

.meas tran Vdout1_18ck78 AVG v(dout1_18) FROM=1019.9n TO=1020.1n

.meas tran Vdout1_19ck78 AVG v(dout1_19) FROM=1019.9n TO=1020.1n

.meas tran Vdout1_20ck78 AVG v(dout1_20) FROM=1019.9n TO=1020.1n

.meas tran Vdout1_21ck78 AVG v(dout1_21) FROM=1019.9n TO=1020.1n

.meas tran Vdout1_22ck78 AVG v(dout1_22) FROM=1019.9n TO=1020.1n

.meas tran Vdout1_23ck78 AVG v(dout1_23) FROM=1019.9n TO=1020.1n

.meas tran Vdout1_24ck78 AVG v(dout1_24) FROM=1019.9n TO=1020.1n

.meas tran Vdout1_25ck78 AVG v(dout1_25) FROM=1019.9n TO=1020.1n

.meas tran Vdout1_26ck78 AVG v(dout1_26) FROM=1019.9n TO=1020.1n

.meas tran Vdout1_27ck78 AVG v(dout1_27) FROM=1019.9n TO=1020.1n

.meas tran Vdout1_28ck78 AVG v(dout1_28) FROM=1019.9n TO=1020.1n

.meas tran Vdout1_29ck78 AVG v(dout1_29) FROM=1019.9n TO=1020.1n

.meas tran Vdout1_30ck78 AVG v(dout1_30) FROM=1019.9n TO=1020.1n

.meas tran Vdout1_31ck78 AVG v(dout1_31) FROM=1019.9n TO=1020.1n

.meas tran Vdout1_32ck78 AVG v(dout1_32) FROM=1019.9n TO=1020.1n

.meas tran Vdout1_33ck78 AVG v(dout1_33) FROM=1019.9n TO=1020.1n

.meas tran Vdout1_34ck78 AVG v(dout1_34) FROM=1019.9n TO=1020.1n

.meas tran Vdout1_35ck78 AVG v(dout1_35) FROM=1019.9n TO=1020.1n

.meas tran Vdout1_36ck78 AVG v(dout1_36) FROM=1019.9n TO=1020.1n

.meas tran Vdout1_37ck78 AVG v(dout1_37) FROM=1019.9n TO=1020.1n

.meas tran Vdout1_38ck78 AVG v(dout1_38) FROM=1019.9n TO=1020.1n

.meas tran Vdout1_39ck78 AVG v(dout1_39) FROM=1019.9n TO=1020.1n

.meas tran Vdout1_40ck78 AVG v(dout1_40) FROM=1019.9n TO=1020.1n

.meas tran Vdout1_41ck78 AVG v(dout1_41) FROM=1019.9n TO=1020.1n

.meas tran Vdout1_42ck78 AVG v(dout1_42) FROM=1019.9n TO=1020.1n

.meas tran Vdout1_43ck78 AVG v(dout1_43) FROM=1019.9n TO=1020.1n

.meas tran Vdout1_44ck78 AVG v(dout1_44) FROM=1019.9n TO=1020.1n

.meas tran Vdout1_45ck78 AVG v(dout1_45) FROM=1019.9n TO=1020.1n

.meas tran Vdout1_46ck78 AVG v(dout1_46) FROM=1019.9n TO=1020.1n

.meas tran Vdout1_47ck78 AVG v(dout1_47) FROM=1019.9n TO=1020.1n

.meas tran Vdout1_48ck78 AVG v(dout1_48) FROM=1019.9n TO=1020.1n

.meas tran Vdout1_49ck78 AVG v(dout1_49) FROM=1019.9n TO=1020.1n

.meas tran Vdout1_50ck78 AVG v(dout1_50) FROM=1019.9n TO=1020.1n

.meas tran Vdout1_51ck78 AVG v(dout1_51) FROM=1019.9n TO=1020.1n

.meas tran Vdout1_52ck78 AVG v(dout1_52) FROM=1019.9n TO=1020.1n

.meas tran Vdout1_53ck78 AVG v(dout1_53) FROM=1019.9n TO=1020.1n

.meas tran Vdout1_54ck78 AVG v(dout1_54) FROM=1019.9n TO=1020.1n

.meas tran Vdout1_55ck78 AVG v(dout1_55) FROM=1019.9n TO=1020.1n

.meas tran Vdout1_56ck78 AVG v(dout1_56) FROM=1019.9n TO=1020.1n

.meas tran Vdout1_57ck78 AVG v(dout1_57) FROM=1019.9n TO=1020.1n

.meas tran Vdout1_58ck78 AVG v(dout1_58) FROM=1019.9n TO=1020.1n

.meas tran Vdout1_59ck78 AVG v(dout1_59) FROM=1019.9n TO=1020.1n

.meas tran Vdout1_60ck78 AVG v(dout1_60) FROM=1019.9n TO=1020.1n

.meas tran Vdout1_61ck78 AVG v(dout1_61) FROM=1019.9n TO=1020.1n

.meas tran Vdout1_62ck78 AVG v(dout1_62) FROM=1019.9n TO=1020.1n

.meas tran Vdout1_63ck78 AVG v(dout1_63) FROM=1019.9n TO=1020.1n

.meas tran Vdout1_64ck78 AVG v(dout1_64) FROM=1019.9n TO=1020.1n

.meas tran Vdout1_65ck78 AVG v(dout1_65) FROM=1019.9n TO=1020.1n

.meas tran Vdout1_66ck78 AVG v(dout1_66) FROM=1019.9n TO=1020.1n

.meas tran Vdout1_67ck78 AVG v(dout1_67) FROM=1019.9n TO=1020.1n

.meas tran Vdout1_68ck78 AVG v(dout1_68) FROM=1019.9n TO=1020.1n

.meas tran Vdout1_69ck78 AVG v(dout1_69) FROM=1019.9n TO=1020.1n

.meas tran Vdout1_70ck78 AVG v(dout1_70) FROM=1019.9n TO=1020.1n

.meas tran Vdout1_71ck78 AVG v(dout1_71) FROM=1019.9n TO=1020.1n

.meas tran Vdout1_72ck78 AVG v(dout1_72) FROM=1019.9n TO=1020.1n

.meas tran Vdout1_73ck78 AVG v(dout1_73) FROM=1019.9n TO=1020.1n

.meas tran Vdout1_74ck78 AVG v(dout1_74) FROM=1019.9n TO=1020.1n

.meas tran Vdout1_75ck78 AVG v(dout1_75) FROM=1019.9n TO=1020.1n

.meas tran Vdout1_76ck78 AVG v(dout1_76) FROM=1019.9n TO=1020.1n

.meas tran Vdout1_77ck78 AVG v(dout1_77) FROM=1019.9n TO=1020.1n

.meas tran Vdout1_78ck78 AVG v(dout1_78) FROM=1019.9n TO=1020.1n

.meas tran Vdout1_79ck78 AVG v(dout1_79) FROM=1019.9n TO=1020.1n

.meas tran Vdout1_0ck79 AVG v(dout1_0) FROM=1029.9n TO=1030.1n

.meas tran Vdout1_1ck79 AVG v(dout1_1) FROM=1029.9n TO=1030.1n

.meas tran Vdout1_2ck79 AVG v(dout1_2) FROM=1029.9n TO=1030.1n

.meas tran Vdout1_3ck79 AVG v(dout1_3) FROM=1029.9n TO=1030.1n

.meas tran Vdout1_4ck79 AVG v(dout1_4) FROM=1029.9n TO=1030.1n

.meas tran Vdout1_5ck79 AVG v(dout1_5) FROM=1029.9n TO=1030.1n

.meas tran Vdout1_6ck79 AVG v(dout1_6) FROM=1029.9n TO=1030.1n

.meas tran Vdout1_7ck79 AVG v(dout1_7) FROM=1029.9n TO=1030.1n

.meas tran Vdout1_8ck79 AVG v(dout1_8) FROM=1029.9n TO=1030.1n

.meas tran Vdout1_9ck79 AVG v(dout1_9) FROM=1029.9n TO=1030.1n

.meas tran Vdout1_10ck79 AVG v(dout1_10) FROM=1029.9n TO=1030.1n

.meas tran Vdout1_11ck79 AVG v(dout1_11) FROM=1029.9n TO=1030.1n

.meas tran Vdout1_12ck79 AVG v(dout1_12) FROM=1029.9n TO=1030.1n

.meas tran Vdout1_13ck79 AVG v(dout1_13) FROM=1029.9n TO=1030.1n

.meas tran Vdout1_14ck79 AVG v(dout1_14) FROM=1029.9n TO=1030.1n

.meas tran Vdout1_15ck79 AVG v(dout1_15) FROM=1029.9n TO=1030.1n

.meas tran Vdout1_16ck79 AVG v(dout1_16) FROM=1029.9n TO=1030.1n

.meas tran Vdout1_17ck79 AVG v(dout1_17) FROM=1029.9n TO=1030.1n

.meas tran Vdout1_18ck79 AVG v(dout1_18) FROM=1029.9n TO=1030.1n

.meas tran Vdout1_19ck79 AVG v(dout1_19) FROM=1029.9n TO=1030.1n

.meas tran Vdout1_20ck79 AVG v(dout1_20) FROM=1029.9n TO=1030.1n

.meas tran Vdout1_21ck79 AVG v(dout1_21) FROM=1029.9n TO=1030.1n

.meas tran Vdout1_22ck79 AVG v(dout1_22) FROM=1029.9n TO=1030.1n

.meas tran Vdout1_23ck79 AVG v(dout1_23) FROM=1029.9n TO=1030.1n

.meas tran Vdout1_24ck79 AVG v(dout1_24) FROM=1029.9n TO=1030.1n

.meas tran Vdout1_25ck79 AVG v(dout1_25) FROM=1029.9n TO=1030.1n

.meas tran Vdout1_26ck79 AVG v(dout1_26) FROM=1029.9n TO=1030.1n

.meas tran Vdout1_27ck79 AVG v(dout1_27) FROM=1029.9n TO=1030.1n

.meas tran Vdout1_28ck79 AVG v(dout1_28) FROM=1029.9n TO=1030.1n

.meas tran Vdout1_29ck79 AVG v(dout1_29) FROM=1029.9n TO=1030.1n

.meas tran Vdout1_30ck79 AVG v(dout1_30) FROM=1029.9n TO=1030.1n

.meas tran Vdout1_31ck79 AVG v(dout1_31) FROM=1029.9n TO=1030.1n

.meas tran Vdout1_32ck79 AVG v(dout1_32) FROM=1029.9n TO=1030.1n

.meas tran Vdout1_33ck79 AVG v(dout1_33) FROM=1029.9n TO=1030.1n

.meas tran Vdout1_34ck79 AVG v(dout1_34) FROM=1029.9n TO=1030.1n

.meas tran Vdout1_35ck79 AVG v(dout1_35) FROM=1029.9n TO=1030.1n

.meas tran Vdout1_36ck79 AVG v(dout1_36) FROM=1029.9n TO=1030.1n

.meas tran Vdout1_37ck79 AVG v(dout1_37) FROM=1029.9n TO=1030.1n

.meas tran Vdout1_38ck79 AVG v(dout1_38) FROM=1029.9n TO=1030.1n

.meas tran Vdout1_39ck79 AVG v(dout1_39) FROM=1029.9n TO=1030.1n

.meas tran Vdout1_40ck79 AVG v(dout1_40) FROM=1029.9n TO=1030.1n

.meas tran Vdout1_41ck79 AVG v(dout1_41) FROM=1029.9n TO=1030.1n

.meas tran Vdout1_42ck79 AVG v(dout1_42) FROM=1029.9n TO=1030.1n

.meas tran Vdout1_43ck79 AVG v(dout1_43) FROM=1029.9n TO=1030.1n

.meas tran Vdout1_44ck79 AVG v(dout1_44) FROM=1029.9n TO=1030.1n

.meas tran Vdout1_45ck79 AVG v(dout1_45) FROM=1029.9n TO=1030.1n

.meas tran Vdout1_46ck79 AVG v(dout1_46) FROM=1029.9n TO=1030.1n

.meas tran Vdout1_47ck79 AVG v(dout1_47) FROM=1029.9n TO=1030.1n

.meas tran Vdout1_48ck79 AVG v(dout1_48) FROM=1029.9n TO=1030.1n

.meas tran Vdout1_49ck79 AVG v(dout1_49) FROM=1029.9n TO=1030.1n

.meas tran Vdout1_50ck79 AVG v(dout1_50) FROM=1029.9n TO=1030.1n

.meas tran Vdout1_51ck79 AVG v(dout1_51) FROM=1029.9n TO=1030.1n

.meas tran Vdout1_52ck79 AVG v(dout1_52) FROM=1029.9n TO=1030.1n

.meas tran Vdout1_53ck79 AVG v(dout1_53) FROM=1029.9n TO=1030.1n

.meas tran Vdout1_54ck79 AVG v(dout1_54) FROM=1029.9n TO=1030.1n

.meas tran Vdout1_55ck79 AVG v(dout1_55) FROM=1029.9n TO=1030.1n

.meas tran Vdout1_56ck79 AVG v(dout1_56) FROM=1029.9n TO=1030.1n

.meas tran Vdout1_57ck79 AVG v(dout1_57) FROM=1029.9n TO=1030.1n

.meas tran Vdout1_58ck79 AVG v(dout1_58) FROM=1029.9n TO=1030.1n

.meas tran Vdout1_59ck79 AVG v(dout1_59) FROM=1029.9n TO=1030.1n

.meas tran Vdout1_60ck79 AVG v(dout1_60) FROM=1029.9n TO=1030.1n

.meas tran Vdout1_61ck79 AVG v(dout1_61) FROM=1029.9n TO=1030.1n

.meas tran Vdout1_62ck79 AVG v(dout1_62) FROM=1029.9n TO=1030.1n

.meas tran Vdout1_63ck79 AVG v(dout1_63) FROM=1029.9n TO=1030.1n

.meas tran Vdout1_64ck79 AVG v(dout1_64) FROM=1029.9n TO=1030.1n

.meas tran Vdout1_65ck79 AVG v(dout1_65) FROM=1029.9n TO=1030.1n

.meas tran Vdout1_66ck79 AVG v(dout1_66) FROM=1029.9n TO=1030.1n

.meas tran Vdout1_67ck79 AVG v(dout1_67) FROM=1029.9n TO=1030.1n

.meas tran Vdout1_68ck79 AVG v(dout1_68) FROM=1029.9n TO=1030.1n

.meas tran Vdout1_69ck79 AVG v(dout1_69) FROM=1029.9n TO=1030.1n

.meas tran Vdout1_70ck79 AVG v(dout1_70) FROM=1029.9n TO=1030.1n

.meas tran Vdout1_71ck79 AVG v(dout1_71) FROM=1029.9n TO=1030.1n

.meas tran Vdout1_72ck79 AVG v(dout1_72) FROM=1029.9n TO=1030.1n

.meas tran Vdout1_73ck79 AVG v(dout1_73) FROM=1029.9n TO=1030.1n

.meas tran Vdout1_74ck79 AVG v(dout1_74) FROM=1029.9n TO=1030.1n

.meas tran Vdout1_75ck79 AVG v(dout1_75) FROM=1029.9n TO=1030.1n

.meas tran Vdout1_76ck79 AVG v(dout1_76) FROM=1029.9n TO=1030.1n

.meas tran Vdout1_77ck79 AVG v(dout1_77) FROM=1029.9n TO=1030.1n

.meas tran Vdout1_78ck79 AVG v(dout1_78) FROM=1029.9n TO=1030.1n

.meas tran Vdout1_79ck79 AVG v(dout1_79) FROM=1029.9n TO=1030.1n

.meas tran Vdout1_0ck80 AVG v(dout1_0) FROM=1039.9n TO=1040.1n

.meas tran Vdout1_1ck80 AVG v(dout1_1) FROM=1039.9n TO=1040.1n

.meas tran Vdout1_2ck80 AVG v(dout1_2) FROM=1039.9n TO=1040.1n

.meas tran Vdout1_3ck80 AVG v(dout1_3) FROM=1039.9n TO=1040.1n

.meas tran Vdout1_4ck80 AVG v(dout1_4) FROM=1039.9n TO=1040.1n

.meas tran Vdout1_5ck80 AVG v(dout1_5) FROM=1039.9n TO=1040.1n

.meas tran Vdout1_6ck80 AVG v(dout1_6) FROM=1039.9n TO=1040.1n

.meas tran Vdout1_7ck80 AVG v(dout1_7) FROM=1039.9n TO=1040.1n

.meas tran Vdout1_8ck80 AVG v(dout1_8) FROM=1039.9n TO=1040.1n

.meas tran Vdout1_9ck80 AVG v(dout1_9) FROM=1039.9n TO=1040.1n

.meas tran Vdout1_10ck80 AVG v(dout1_10) FROM=1039.9n TO=1040.1n

.meas tran Vdout1_11ck80 AVG v(dout1_11) FROM=1039.9n TO=1040.1n

.meas tran Vdout1_12ck80 AVG v(dout1_12) FROM=1039.9n TO=1040.1n

.meas tran Vdout1_13ck80 AVG v(dout1_13) FROM=1039.9n TO=1040.1n

.meas tran Vdout1_14ck80 AVG v(dout1_14) FROM=1039.9n TO=1040.1n

.meas tran Vdout1_15ck80 AVG v(dout1_15) FROM=1039.9n TO=1040.1n

.meas tran Vdout1_16ck80 AVG v(dout1_16) FROM=1039.9n TO=1040.1n

.meas tran Vdout1_17ck80 AVG v(dout1_17) FROM=1039.9n TO=1040.1n

.meas tran Vdout1_18ck80 AVG v(dout1_18) FROM=1039.9n TO=1040.1n

.meas tran Vdout1_19ck80 AVG v(dout1_19) FROM=1039.9n TO=1040.1n

.meas tran Vdout1_20ck80 AVG v(dout1_20) FROM=1039.9n TO=1040.1n

.meas tran Vdout1_21ck80 AVG v(dout1_21) FROM=1039.9n TO=1040.1n

.meas tran Vdout1_22ck80 AVG v(dout1_22) FROM=1039.9n TO=1040.1n

.meas tran Vdout1_23ck80 AVG v(dout1_23) FROM=1039.9n TO=1040.1n

.meas tran Vdout1_24ck80 AVG v(dout1_24) FROM=1039.9n TO=1040.1n

.meas tran Vdout1_25ck80 AVG v(dout1_25) FROM=1039.9n TO=1040.1n

.meas tran Vdout1_26ck80 AVG v(dout1_26) FROM=1039.9n TO=1040.1n

.meas tran Vdout1_27ck80 AVG v(dout1_27) FROM=1039.9n TO=1040.1n

.meas tran Vdout1_28ck80 AVG v(dout1_28) FROM=1039.9n TO=1040.1n

.meas tran Vdout1_29ck80 AVG v(dout1_29) FROM=1039.9n TO=1040.1n

.meas tran Vdout1_30ck80 AVG v(dout1_30) FROM=1039.9n TO=1040.1n

.meas tran Vdout1_31ck80 AVG v(dout1_31) FROM=1039.9n TO=1040.1n

.meas tran Vdout1_32ck80 AVG v(dout1_32) FROM=1039.9n TO=1040.1n

.meas tran Vdout1_33ck80 AVG v(dout1_33) FROM=1039.9n TO=1040.1n

.meas tran Vdout1_34ck80 AVG v(dout1_34) FROM=1039.9n TO=1040.1n

.meas tran Vdout1_35ck80 AVG v(dout1_35) FROM=1039.9n TO=1040.1n

.meas tran Vdout1_36ck80 AVG v(dout1_36) FROM=1039.9n TO=1040.1n

.meas tran Vdout1_37ck80 AVG v(dout1_37) FROM=1039.9n TO=1040.1n

.meas tran Vdout1_38ck80 AVG v(dout1_38) FROM=1039.9n TO=1040.1n

.meas tran Vdout1_39ck80 AVG v(dout1_39) FROM=1039.9n TO=1040.1n

.meas tran Vdout1_40ck80 AVG v(dout1_40) FROM=1039.9n TO=1040.1n

.meas tran Vdout1_41ck80 AVG v(dout1_41) FROM=1039.9n TO=1040.1n

.meas tran Vdout1_42ck80 AVG v(dout1_42) FROM=1039.9n TO=1040.1n

.meas tran Vdout1_43ck80 AVG v(dout1_43) FROM=1039.9n TO=1040.1n

.meas tran Vdout1_44ck80 AVG v(dout1_44) FROM=1039.9n TO=1040.1n

.meas tran Vdout1_45ck80 AVG v(dout1_45) FROM=1039.9n TO=1040.1n

.meas tran Vdout1_46ck80 AVG v(dout1_46) FROM=1039.9n TO=1040.1n

.meas tran Vdout1_47ck80 AVG v(dout1_47) FROM=1039.9n TO=1040.1n

.meas tran Vdout1_48ck80 AVG v(dout1_48) FROM=1039.9n TO=1040.1n

.meas tran Vdout1_49ck80 AVG v(dout1_49) FROM=1039.9n TO=1040.1n

.meas tran Vdout1_50ck80 AVG v(dout1_50) FROM=1039.9n TO=1040.1n

.meas tran Vdout1_51ck80 AVG v(dout1_51) FROM=1039.9n TO=1040.1n

.meas tran Vdout1_52ck80 AVG v(dout1_52) FROM=1039.9n TO=1040.1n

.meas tran Vdout1_53ck80 AVG v(dout1_53) FROM=1039.9n TO=1040.1n

.meas tran Vdout1_54ck80 AVG v(dout1_54) FROM=1039.9n TO=1040.1n

.meas tran Vdout1_55ck80 AVG v(dout1_55) FROM=1039.9n TO=1040.1n

.meas tran Vdout1_56ck80 AVG v(dout1_56) FROM=1039.9n TO=1040.1n

.meas tran Vdout1_57ck80 AVG v(dout1_57) FROM=1039.9n TO=1040.1n

.meas tran Vdout1_58ck80 AVG v(dout1_58) FROM=1039.9n TO=1040.1n

.meas tran Vdout1_59ck80 AVG v(dout1_59) FROM=1039.9n TO=1040.1n

.meas tran Vdout1_60ck80 AVG v(dout1_60) FROM=1039.9n TO=1040.1n

.meas tran Vdout1_61ck80 AVG v(dout1_61) FROM=1039.9n TO=1040.1n

.meas tran Vdout1_62ck80 AVG v(dout1_62) FROM=1039.9n TO=1040.1n

.meas tran Vdout1_63ck80 AVG v(dout1_63) FROM=1039.9n TO=1040.1n

.meas tran Vdout1_64ck80 AVG v(dout1_64) FROM=1039.9n TO=1040.1n

.meas tran Vdout1_65ck80 AVG v(dout1_65) FROM=1039.9n TO=1040.1n

.meas tran Vdout1_66ck80 AVG v(dout1_66) FROM=1039.9n TO=1040.1n

.meas tran Vdout1_67ck80 AVG v(dout1_67) FROM=1039.9n TO=1040.1n

.meas tran Vdout1_68ck80 AVG v(dout1_68) FROM=1039.9n TO=1040.1n

.meas tran Vdout1_69ck80 AVG v(dout1_69) FROM=1039.9n TO=1040.1n

.meas tran Vdout1_70ck80 AVG v(dout1_70) FROM=1039.9n TO=1040.1n

.meas tran Vdout1_71ck80 AVG v(dout1_71) FROM=1039.9n TO=1040.1n

.meas tran Vdout1_72ck80 AVG v(dout1_72) FROM=1039.9n TO=1040.1n

.meas tran Vdout1_73ck80 AVG v(dout1_73) FROM=1039.9n TO=1040.1n

.meas tran Vdout1_74ck80 AVG v(dout1_74) FROM=1039.9n TO=1040.1n

.meas tran Vdout1_75ck80 AVG v(dout1_75) FROM=1039.9n TO=1040.1n

.meas tran Vdout1_76ck80 AVG v(dout1_76) FROM=1039.9n TO=1040.1n

.meas tran Vdout1_77ck80 AVG v(dout1_77) FROM=1039.9n TO=1040.1n

.meas tran Vdout1_78ck80 AVG v(dout1_78) FROM=1039.9n TO=1040.1n

.meas tran Vdout1_79ck80 AVG v(dout1_79) FROM=1039.9n TO=1040.1n

.meas tran Vdout0_0ck81 AVG v(dout0_0) FROM=1049.9n TO=1050.1n

.meas tran Vdout0_1ck81 AVG v(dout0_1) FROM=1049.9n TO=1050.1n

.meas tran Vdout0_2ck81 AVG v(dout0_2) FROM=1049.9n TO=1050.1n

.meas tran Vdout0_3ck81 AVG v(dout0_3) FROM=1049.9n TO=1050.1n

.meas tran Vdout0_4ck81 AVG v(dout0_4) FROM=1049.9n TO=1050.1n

.meas tran Vdout0_5ck81 AVG v(dout0_5) FROM=1049.9n TO=1050.1n

.meas tran Vdout0_6ck81 AVG v(dout0_6) FROM=1049.9n TO=1050.1n

.meas tran Vdout0_7ck81 AVG v(dout0_7) FROM=1049.9n TO=1050.1n

.meas tran Vdout0_8ck81 AVG v(dout0_8) FROM=1049.9n TO=1050.1n

.meas tran Vdout0_9ck81 AVG v(dout0_9) FROM=1049.9n TO=1050.1n

.meas tran Vdout0_10ck81 AVG v(dout0_10) FROM=1049.9n TO=1050.1n

.meas tran Vdout0_11ck81 AVG v(dout0_11) FROM=1049.9n TO=1050.1n

.meas tran Vdout0_12ck81 AVG v(dout0_12) FROM=1049.9n TO=1050.1n

.meas tran Vdout0_13ck81 AVG v(dout0_13) FROM=1049.9n TO=1050.1n

.meas tran Vdout0_14ck81 AVG v(dout0_14) FROM=1049.9n TO=1050.1n

.meas tran Vdout0_15ck81 AVG v(dout0_15) FROM=1049.9n TO=1050.1n

.meas tran Vdout0_16ck81 AVG v(dout0_16) FROM=1049.9n TO=1050.1n

.meas tran Vdout0_17ck81 AVG v(dout0_17) FROM=1049.9n TO=1050.1n

.meas tran Vdout0_18ck81 AVG v(dout0_18) FROM=1049.9n TO=1050.1n

.meas tran Vdout0_19ck81 AVG v(dout0_19) FROM=1049.9n TO=1050.1n

.meas tran Vdout0_20ck81 AVG v(dout0_20) FROM=1049.9n TO=1050.1n

.meas tran Vdout0_21ck81 AVG v(dout0_21) FROM=1049.9n TO=1050.1n

.meas tran Vdout0_22ck81 AVG v(dout0_22) FROM=1049.9n TO=1050.1n

.meas tran Vdout0_23ck81 AVG v(dout0_23) FROM=1049.9n TO=1050.1n

.meas tran Vdout0_24ck81 AVG v(dout0_24) FROM=1049.9n TO=1050.1n

.meas tran Vdout0_25ck81 AVG v(dout0_25) FROM=1049.9n TO=1050.1n

.meas tran Vdout0_26ck81 AVG v(dout0_26) FROM=1049.9n TO=1050.1n

.meas tran Vdout0_27ck81 AVG v(dout0_27) FROM=1049.9n TO=1050.1n

.meas tran Vdout0_28ck81 AVG v(dout0_28) FROM=1049.9n TO=1050.1n

.meas tran Vdout0_29ck81 AVG v(dout0_29) FROM=1049.9n TO=1050.1n

.meas tran Vdout0_30ck81 AVG v(dout0_30) FROM=1049.9n TO=1050.1n

.meas tran Vdout0_31ck81 AVG v(dout0_31) FROM=1049.9n TO=1050.1n

.meas tran Vdout0_32ck81 AVG v(dout0_32) FROM=1049.9n TO=1050.1n

.meas tran Vdout0_33ck81 AVG v(dout0_33) FROM=1049.9n TO=1050.1n

.meas tran Vdout0_34ck81 AVG v(dout0_34) FROM=1049.9n TO=1050.1n

.meas tran Vdout0_35ck81 AVG v(dout0_35) FROM=1049.9n TO=1050.1n

.meas tran Vdout0_36ck81 AVG v(dout0_36) FROM=1049.9n TO=1050.1n

.meas tran Vdout0_37ck81 AVG v(dout0_37) FROM=1049.9n TO=1050.1n

.meas tran Vdout0_38ck81 AVG v(dout0_38) FROM=1049.9n TO=1050.1n

.meas tran Vdout0_39ck81 AVG v(dout0_39) FROM=1049.9n TO=1050.1n

.meas tran Vdout0_40ck81 AVG v(dout0_40) FROM=1049.9n TO=1050.1n

.meas tran Vdout0_41ck81 AVG v(dout0_41) FROM=1049.9n TO=1050.1n

.meas tran Vdout0_42ck81 AVG v(dout0_42) FROM=1049.9n TO=1050.1n

.meas tran Vdout0_43ck81 AVG v(dout0_43) FROM=1049.9n TO=1050.1n

.meas tran Vdout0_44ck81 AVG v(dout0_44) FROM=1049.9n TO=1050.1n

.meas tran Vdout0_45ck81 AVG v(dout0_45) FROM=1049.9n TO=1050.1n

.meas tran Vdout0_46ck81 AVG v(dout0_46) FROM=1049.9n TO=1050.1n

.meas tran Vdout0_47ck81 AVG v(dout0_47) FROM=1049.9n TO=1050.1n

.meas tran Vdout0_48ck81 AVG v(dout0_48) FROM=1049.9n TO=1050.1n

.meas tran Vdout0_49ck81 AVG v(dout0_49) FROM=1049.9n TO=1050.1n

.meas tran Vdout0_50ck81 AVG v(dout0_50) FROM=1049.9n TO=1050.1n

.meas tran Vdout0_51ck81 AVG v(dout0_51) FROM=1049.9n TO=1050.1n

.meas tran Vdout0_52ck81 AVG v(dout0_52) FROM=1049.9n TO=1050.1n

.meas tran Vdout0_53ck81 AVG v(dout0_53) FROM=1049.9n TO=1050.1n

.meas tran Vdout0_54ck81 AVG v(dout0_54) FROM=1049.9n TO=1050.1n

.meas tran Vdout0_55ck81 AVG v(dout0_55) FROM=1049.9n TO=1050.1n

.meas tran Vdout0_56ck81 AVG v(dout0_56) FROM=1049.9n TO=1050.1n

.meas tran Vdout0_57ck81 AVG v(dout0_57) FROM=1049.9n TO=1050.1n

.meas tran Vdout0_58ck81 AVG v(dout0_58) FROM=1049.9n TO=1050.1n

.meas tran Vdout0_59ck81 AVG v(dout0_59) FROM=1049.9n TO=1050.1n

.meas tran Vdout0_60ck81 AVG v(dout0_60) FROM=1049.9n TO=1050.1n

.meas tran Vdout0_61ck81 AVG v(dout0_61) FROM=1049.9n TO=1050.1n

.meas tran Vdout0_62ck81 AVG v(dout0_62) FROM=1049.9n TO=1050.1n

.meas tran Vdout0_63ck81 AVG v(dout0_63) FROM=1049.9n TO=1050.1n

.meas tran Vdout0_64ck81 AVG v(dout0_64) FROM=1049.9n TO=1050.1n

.meas tran Vdout0_65ck81 AVG v(dout0_65) FROM=1049.9n TO=1050.1n

.meas tran Vdout0_66ck81 AVG v(dout0_66) FROM=1049.9n TO=1050.1n

.meas tran Vdout0_67ck81 AVG v(dout0_67) FROM=1049.9n TO=1050.1n

.meas tran Vdout0_68ck81 AVG v(dout0_68) FROM=1049.9n TO=1050.1n

.meas tran Vdout0_69ck81 AVG v(dout0_69) FROM=1049.9n TO=1050.1n

.meas tran Vdout0_70ck81 AVG v(dout0_70) FROM=1049.9n TO=1050.1n

.meas tran Vdout0_71ck81 AVG v(dout0_71) FROM=1049.9n TO=1050.1n

.meas tran Vdout0_72ck81 AVG v(dout0_72) FROM=1049.9n TO=1050.1n

.meas tran Vdout0_73ck81 AVG v(dout0_73) FROM=1049.9n TO=1050.1n

.meas tran Vdout0_74ck81 AVG v(dout0_74) FROM=1049.9n TO=1050.1n

.meas tran Vdout0_75ck81 AVG v(dout0_75) FROM=1049.9n TO=1050.1n

.meas tran Vdout0_76ck81 AVG v(dout0_76) FROM=1049.9n TO=1050.1n

.meas tran Vdout0_77ck81 AVG v(dout0_77) FROM=1049.9n TO=1050.1n

.meas tran Vdout0_78ck81 AVG v(dout0_78) FROM=1049.9n TO=1050.1n

.meas tran Vdout0_79ck81 AVG v(dout0_79) FROM=1049.9n TO=1050.1n

.meas tran Vdout1_0ck82 AVG v(dout1_0) FROM=1049.9n TO=1050.1n

.meas tran Vdout1_1ck82 AVG v(dout1_1) FROM=1049.9n TO=1050.1n

.meas tran Vdout1_2ck82 AVG v(dout1_2) FROM=1049.9n TO=1050.1n

.meas tran Vdout1_3ck82 AVG v(dout1_3) FROM=1049.9n TO=1050.1n

.meas tran Vdout1_4ck82 AVG v(dout1_4) FROM=1049.9n TO=1050.1n

.meas tran Vdout1_5ck82 AVG v(dout1_5) FROM=1049.9n TO=1050.1n

.meas tran Vdout1_6ck82 AVG v(dout1_6) FROM=1049.9n TO=1050.1n

.meas tran Vdout1_7ck82 AVG v(dout1_7) FROM=1049.9n TO=1050.1n

.meas tran Vdout1_8ck82 AVG v(dout1_8) FROM=1049.9n TO=1050.1n

.meas tran Vdout1_9ck82 AVG v(dout1_9) FROM=1049.9n TO=1050.1n

.meas tran Vdout1_10ck82 AVG v(dout1_10) FROM=1049.9n TO=1050.1n

.meas tran Vdout1_11ck82 AVG v(dout1_11) FROM=1049.9n TO=1050.1n

.meas tran Vdout1_12ck82 AVG v(dout1_12) FROM=1049.9n TO=1050.1n

.meas tran Vdout1_13ck82 AVG v(dout1_13) FROM=1049.9n TO=1050.1n

.meas tran Vdout1_14ck82 AVG v(dout1_14) FROM=1049.9n TO=1050.1n

.meas tran Vdout1_15ck82 AVG v(dout1_15) FROM=1049.9n TO=1050.1n

.meas tran Vdout1_16ck82 AVG v(dout1_16) FROM=1049.9n TO=1050.1n

.meas tran Vdout1_17ck82 AVG v(dout1_17) FROM=1049.9n TO=1050.1n

.meas tran Vdout1_18ck82 AVG v(dout1_18) FROM=1049.9n TO=1050.1n

.meas tran Vdout1_19ck82 AVG v(dout1_19) FROM=1049.9n TO=1050.1n

.meas tran Vdout1_20ck82 AVG v(dout1_20) FROM=1049.9n TO=1050.1n

.meas tran Vdout1_21ck82 AVG v(dout1_21) FROM=1049.9n TO=1050.1n

.meas tran Vdout1_22ck82 AVG v(dout1_22) FROM=1049.9n TO=1050.1n

.meas tran Vdout1_23ck82 AVG v(dout1_23) FROM=1049.9n TO=1050.1n

.meas tran Vdout1_24ck82 AVG v(dout1_24) FROM=1049.9n TO=1050.1n

.meas tran Vdout1_25ck82 AVG v(dout1_25) FROM=1049.9n TO=1050.1n

.meas tran Vdout1_26ck82 AVG v(dout1_26) FROM=1049.9n TO=1050.1n

.meas tran Vdout1_27ck82 AVG v(dout1_27) FROM=1049.9n TO=1050.1n

.meas tran Vdout1_28ck82 AVG v(dout1_28) FROM=1049.9n TO=1050.1n

.meas tran Vdout1_29ck82 AVG v(dout1_29) FROM=1049.9n TO=1050.1n

.meas tran Vdout1_30ck82 AVG v(dout1_30) FROM=1049.9n TO=1050.1n

.meas tran Vdout1_31ck82 AVG v(dout1_31) FROM=1049.9n TO=1050.1n

.meas tran Vdout1_32ck82 AVG v(dout1_32) FROM=1049.9n TO=1050.1n

.meas tran Vdout1_33ck82 AVG v(dout1_33) FROM=1049.9n TO=1050.1n

.meas tran Vdout1_34ck82 AVG v(dout1_34) FROM=1049.9n TO=1050.1n

.meas tran Vdout1_35ck82 AVG v(dout1_35) FROM=1049.9n TO=1050.1n

.meas tran Vdout1_36ck82 AVG v(dout1_36) FROM=1049.9n TO=1050.1n

.meas tran Vdout1_37ck82 AVG v(dout1_37) FROM=1049.9n TO=1050.1n

.meas tran Vdout1_38ck82 AVG v(dout1_38) FROM=1049.9n TO=1050.1n

.meas tran Vdout1_39ck82 AVG v(dout1_39) FROM=1049.9n TO=1050.1n

.meas tran Vdout1_40ck82 AVG v(dout1_40) FROM=1049.9n TO=1050.1n

.meas tran Vdout1_41ck82 AVG v(dout1_41) FROM=1049.9n TO=1050.1n

.meas tran Vdout1_42ck82 AVG v(dout1_42) FROM=1049.9n TO=1050.1n

.meas tran Vdout1_43ck82 AVG v(dout1_43) FROM=1049.9n TO=1050.1n

.meas tran Vdout1_44ck82 AVG v(dout1_44) FROM=1049.9n TO=1050.1n

.meas tran Vdout1_45ck82 AVG v(dout1_45) FROM=1049.9n TO=1050.1n

.meas tran Vdout1_46ck82 AVG v(dout1_46) FROM=1049.9n TO=1050.1n

.meas tran Vdout1_47ck82 AVG v(dout1_47) FROM=1049.9n TO=1050.1n

.meas tran Vdout1_48ck82 AVG v(dout1_48) FROM=1049.9n TO=1050.1n

.meas tran Vdout1_49ck82 AVG v(dout1_49) FROM=1049.9n TO=1050.1n

.meas tran Vdout1_50ck82 AVG v(dout1_50) FROM=1049.9n TO=1050.1n

.meas tran Vdout1_51ck82 AVG v(dout1_51) FROM=1049.9n TO=1050.1n

.meas tran Vdout1_52ck82 AVG v(dout1_52) FROM=1049.9n TO=1050.1n

.meas tran Vdout1_53ck82 AVG v(dout1_53) FROM=1049.9n TO=1050.1n

.meas tran Vdout1_54ck82 AVG v(dout1_54) FROM=1049.9n TO=1050.1n

.meas tran Vdout1_55ck82 AVG v(dout1_55) FROM=1049.9n TO=1050.1n

.meas tran Vdout1_56ck82 AVG v(dout1_56) FROM=1049.9n TO=1050.1n

.meas tran Vdout1_57ck82 AVG v(dout1_57) FROM=1049.9n TO=1050.1n

.meas tran Vdout1_58ck82 AVG v(dout1_58) FROM=1049.9n TO=1050.1n

.meas tran Vdout1_59ck82 AVG v(dout1_59) FROM=1049.9n TO=1050.1n

.meas tran Vdout1_60ck82 AVG v(dout1_60) FROM=1049.9n TO=1050.1n

.meas tran Vdout1_61ck82 AVG v(dout1_61) FROM=1049.9n TO=1050.1n

.meas tran Vdout1_62ck82 AVG v(dout1_62) FROM=1049.9n TO=1050.1n

.meas tran Vdout1_63ck82 AVG v(dout1_63) FROM=1049.9n TO=1050.1n

.meas tran Vdout1_64ck82 AVG v(dout1_64) FROM=1049.9n TO=1050.1n

.meas tran Vdout1_65ck82 AVG v(dout1_65) FROM=1049.9n TO=1050.1n

.meas tran Vdout1_66ck82 AVG v(dout1_66) FROM=1049.9n TO=1050.1n

.meas tran Vdout1_67ck82 AVG v(dout1_67) FROM=1049.9n TO=1050.1n

.meas tran Vdout1_68ck82 AVG v(dout1_68) FROM=1049.9n TO=1050.1n

.meas tran Vdout1_69ck82 AVG v(dout1_69) FROM=1049.9n TO=1050.1n

.meas tran Vdout1_70ck82 AVG v(dout1_70) FROM=1049.9n TO=1050.1n

.meas tran Vdout1_71ck82 AVG v(dout1_71) FROM=1049.9n TO=1050.1n

.meas tran Vdout1_72ck82 AVG v(dout1_72) FROM=1049.9n TO=1050.1n

.meas tran Vdout1_73ck82 AVG v(dout1_73) FROM=1049.9n TO=1050.1n

.meas tran Vdout1_74ck82 AVG v(dout1_74) FROM=1049.9n TO=1050.1n

.meas tran Vdout1_75ck82 AVG v(dout1_75) FROM=1049.9n TO=1050.1n

.meas tran Vdout1_76ck82 AVG v(dout1_76) FROM=1049.9n TO=1050.1n

.meas tran Vdout1_77ck82 AVG v(dout1_77) FROM=1049.9n TO=1050.1n

.meas tran Vdout1_78ck82 AVG v(dout1_78) FROM=1049.9n TO=1050.1n

.meas tran Vdout1_79ck82 AVG v(dout1_79) FROM=1049.9n TO=1050.1n

.meas tran Vdout1_0ck83 AVG v(dout1_0) FROM=1059.9n TO=1060.1n

.meas tran Vdout1_1ck83 AVG v(dout1_1) FROM=1059.9n TO=1060.1n

.meas tran Vdout1_2ck83 AVG v(dout1_2) FROM=1059.9n TO=1060.1n

.meas tran Vdout1_3ck83 AVG v(dout1_3) FROM=1059.9n TO=1060.1n

.meas tran Vdout1_4ck83 AVG v(dout1_4) FROM=1059.9n TO=1060.1n

.meas tran Vdout1_5ck83 AVG v(dout1_5) FROM=1059.9n TO=1060.1n

.meas tran Vdout1_6ck83 AVG v(dout1_6) FROM=1059.9n TO=1060.1n

.meas tran Vdout1_7ck83 AVG v(dout1_7) FROM=1059.9n TO=1060.1n

.meas tran Vdout1_8ck83 AVG v(dout1_8) FROM=1059.9n TO=1060.1n

.meas tran Vdout1_9ck83 AVG v(dout1_9) FROM=1059.9n TO=1060.1n

.meas tran Vdout1_10ck83 AVG v(dout1_10) FROM=1059.9n TO=1060.1n

.meas tran Vdout1_11ck83 AVG v(dout1_11) FROM=1059.9n TO=1060.1n

.meas tran Vdout1_12ck83 AVG v(dout1_12) FROM=1059.9n TO=1060.1n

.meas tran Vdout1_13ck83 AVG v(dout1_13) FROM=1059.9n TO=1060.1n

.meas tran Vdout1_14ck83 AVG v(dout1_14) FROM=1059.9n TO=1060.1n

.meas tran Vdout1_15ck83 AVG v(dout1_15) FROM=1059.9n TO=1060.1n

.meas tran Vdout1_16ck83 AVG v(dout1_16) FROM=1059.9n TO=1060.1n

.meas tran Vdout1_17ck83 AVG v(dout1_17) FROM=1059.9n TO=1060.1n

.meas tran Vdout1_18ck83 AVG v(dout1_18) FROM=1059.9n TO=1060.1n

.meas tran Vdout1_19ck83 AVG v(dout1_19) FROM=1059.9n TO=1060.1n

.meas tran Vdout1_20ck83 AVG v(dout1_20) FROM=1059.9n TO=1060.1n

.meas tran Vdout1_21ck83 AVG v(dout1_21) FROM=1059.9n TO=1060.1n

.meas tran Vdout1_22ck83 AVG v(dout1_22) FROM=1059.9n TO=1060.1n

.meas tran Vdout1_23ck83 AVG v(dout1_23) FROM=1059.9n TO=1060.1n

.meas tran Vdout1_24ck83 AVG v(dout1_24) FROM=1059.9n TO=1060.1n

.meas tran Vdout1_25ck83 AVG v(dout1_25) FROM=1059.9n TO=1060.1n

.meas tran Vdout1_26ck83 AVG v(dout1_26) FROM=1059.9n TO=1060.1n

.meas tran Vdout1_27ck83 AVG v(dout1_27) FROM=1059.9n TO=1060.1n

.meas tran Vdout1_28ck83 AVG v(dout1_28) FROM=1059.9n TO=1060.1n

.meas tran Vdout1_29ck83 AVG v(dout1_29) FROM=1059.9n TO=1060.1n

.meas tran Vdout1_30ck83 AVG v(dout1_30) FROM=1059.9n TO=1060.1n

.meas tran Vdout1_31ck83 AVG v(dout1_31) FROM=1059.9n TO=1060.1n

.meas tran Vdout1_32ck83 AVG v(dout1_32) FROM=1059.9n TO=1060.1n

.meas tran Vdout1_33ck83 AVG v(dout1_33) FROM=1059.9n TO=1060.1n

.meas tran Vdout1_34ck83 AVG v(dout1_34) FROM=1059.9n TO=1060.1n

.meas tran Vdout1_35ck83 AVG v(dout1_35) FROM=1059.9n TO=1060.1n

.meas tran Vdout1_36ck83 AVG v(dout1_36) FROM=1059.9n TO=1060.1n

.meas tran Vdout1_37ck83 AVG v(dout1_37) FROM=1059.9n TO=1060.1n

.meas tran Vdout1_38ck83 AVG v(dout1_38) FROM=1059.9n TO=1060.1n

.meas tran Vdout1_39ck83 AVG v(dout1_39) FROM=1059.9n TO=1060.1n

.meas tran Vdout1_40ck83 AVG v(dout1_40) FROM=1059.9n TO=1060.1n

.meas tran Vdout1_41ck83 AVG v(dout1_41) FROM=1059.9n TO=1060.1n

.meas tran Vdout1_42ck83 AVG v(dout1_42) FROM=1059.9n TO=1060.1n

.meas tran Vdout1_43ck83 AVG v(dout1_43) FROM=1059.9n TO=1060.1n

.meas tran Vdout1_44ck83 AVG v(dout1_44) FROM=1059.9n TO=1060.1n

.meas tran Vdout1_45ck83 AVG v(dout1_45) FROM=1059.9n TO=1060.1n

.meas tran Vdout1_46ck83 AVG v(dout1_46) FROM=1059.9n TO=1060.1n

.meas tran Vdout1_47ck83 AVG v(dout1_47) FROM=1059.9n TO=1060.1n

.meas tran Vdout1_48ck83 AVG v(dout1_48) FROM=1059.9n TO=1060.1n

.meas tran Vdout1_49ck83 AVG v(dout1_49) FROM=1059.9n TO=1060.1n

.meas tran Vdout1_50ck83 AVG v(dout1_50) FROM=1059.9n TO=1060.1n

.meas tran Vdout1_51ck83 AVG v(dout1_51) FROM=1059.9n TO=1060.1n

.meas tran Vdout1_52ck83 AVG v(dout1_52) FROM=1059.9n TO=1060.1n

.meas tran Vdout1_53ck83 AVG v(dout1_53) FROM=1059.9n TO=1060.1n

.meas tran Vdout1_54ck83 AVG v(dout1_54) FROM=1059.9n TO=1060.1n

.meas tran Vdout1_55ck83 AVG v(dout1_55) FROM=1059.9n TO=1060.1n

.meas tran Vdout1_56ck83 AVG v(dout1_56) FROM=1059.9n TO=1060.1n

.meas tran Vdout1_57ck83 AVG v(dout1_57) FROM=1059.9n TO=1060.1n

.meas tran Vdout1_58ck83 AVG v(dout1_58) FROM=1059.9n TO=1060.1n

.meas tran Vdout1_59ck83 AVG v(dout1_59) FROM=1059.9n TO=1060.1n

.meas tran Vdout1_60ck83 AVG v(dout1_60) FROM=1059.9n TO=1060.1n

.meas tran Vdout1_61ck83 AVG v(dout1_61) FROM=1059.9n TO=1060.1n

.meas tran Vdout1_62ck83 AVG v(dout1_62) FROM=1059.9n TO=1060.1n

.meas tran Vdout1_63ck83 AVG v(dout1_63) FROM=1059.9n TO=1060.1n

.meas tran Vdout1_64ck83 AVG v(dout1_64) FROM=1059.9n TO=1060.1n

.meas tran Vdout1_65ck83 AVG v(dout1_65) FROM=1059.9n TO=1060.1n

.meas tran Vdout1_66ck83 AVG v(dout1_66) FROM=1059.9n TO=1060.1n

.meas tran Vdout1_67ck83 AVG v(dout1_67) FROM=1059.9n TO=1060.1n

.meas tran Vdout1_68ck83 AVG v(dout1_68) FROM=1059.9n TO=1060.1n

.meas tran Vdout1_69ck83 AVG v(dout1_69) FROM=1059.9n TO=1060.1n

.meas tran Vdout1_70ck83 AVG v(dout1_70) FROM=1059.9n TO=1060.1n

.meas tran Vdout1_71ck83 AVG v(dout1_71) FROM=1059.9n TO=1060.1n

.meas tran Vdout1_72ck83 AVG v(dout1_72) FROM=1059.9n TO=1060.1n

.meas tran Vdout1_73ck83 AVG v(dout1_73) FROM=1059.9n TO=1060.1n

.meas tran Vdout1_74ck83 AVG v(dout1_74) FROM=1059.9n TO=1060.1n

.meas tran Vdout1_75ck83 AVG v(dout1_75) FROM=1059.9n TO=1060.1n

.meas tran Vdout1_76ck83 AVG v(dout1_76) FROM=1059.9n TO=1060.1n

.meas tran Vdout1_77ck83 AVG v(dout1_77) FROM=1059.9n TO=1060.1n

.meas tran Vdout1_78ck83 AVG v(dout1_78) FROM=1059.9n TO=1060.1n

.meas tran Vdout1_79ck83 AVG v(dout1_79) FROM=1059.9n TO=1060.1n

.meas tran Vdout1_0ck84 AVG v(dout1_0) FROM=1069.9n TO=1070.1n

.meas tran Vdout1_1ck84 AVG v(dout1_1) FROM=1069.9n TO=1070.1n

.meas tran Vdout1_2ck84 AVG v(dout1_2) FROM=1069.9n TO=1070.1n

.meas tran Vdout1_3ck84 AVG v(dout1_3) FROM=1069.9n TO=1070.1n

.meas tran Vdout1_4ck84 AVG v(dout1_4) FROM=1069.9n TO=1070.1n

.meas tran Vdout1_5ck84 AVG v(dout1_5) FROM=1069.9n TO=1070.1n

.meas tran Vdout1_6ck84 AVG v(dout1_6) FROM=1069.9n TO=1070.1n

.meas tran Vdout1_7ck84 AVG v(dout1_7) FROM=1069.9n TO=1070.1n

.meas tran Vdout1_8ck84 AVG v(dout1_8) FROM=1069.9n TO=1070.1n

.meas tran Vdout1_9ck84 AVG v(dout1_9) FROM=1069.9n TO=1070.1n

.meas tran Vdout1_10ck84 AVG v(dout1_10) FROM=1069.9n TO=1070.1n

.meas tran Vdout1_11ck84 AVG v(dout1_11) FROM=1069.9n TO=1070.1n

.meas tran Vdout1_12ck84 AVG v(dout1_12) FROM=1069.9n TO=1070.1n

.meas tran Vdout1_13ck84 AVG v(dout1_13) FROM=1069.9n TO=1070.1n

.meas tran Vdout1_14ck84 AVG v(dout1_14) FROM=1069.9n TO=1070.1n

.meas tran Vdout1_15ck84 AVG v(dout1_15) FROM=1069.9n TO=1070.1n

.meas tran Vdout1_16ck84 AVG v(dout1_16) FROM=1069.9n TO=1070.1n

.meas tran Vdout1_17ck84 AVG v(dout1_17) FROM=1069.9n TO=1070.1n

.meas tran Vdout1_18ck84 AVG v(dout1_18) FROM=1069.9n TO=1070.1n

.meas tran Vdout1_19ck84 AVG v(dout1_19) FROM=1069.9n TO=1070.1n

.meas tran Vdout1_20ck84 AVG v(dout1_20) FROM=1069.9n TO=1070.1n

.meas tran Vdout1_21ck84 AVG v(dout1_21) FROM=1069.9n TO=1070.1n

.meas tran Vdout1_22ck84 AVG v(dout1_22) FROM=1069.9n TO=1070.1n

.meas tran Vdout1_23ck84 AVG v(dout1_23) FROM=1069.9n TO=1070.1n

.meas tran Vdout1_24ck84 AVG v(dout1_24) FROM=1069.9n TO=1070.1n

.meas tran Vdout1_25ck84 AVG v(dout1_25) FROM=1069.9n TO=1070.1n

.meas tran Vdout1_26ck84 AVG v(dout1_26) FROM=1069.9n TO=1070.1n

.meas tran Vdout1_27ck84 AVG v(dout1_27) FROM=1069.9n TO=1070.1n

.meas tran Vdout1_28ck84 AVG v(dout1_28) FROM=1069.9n TO=1070.1n

.meas tran Vdout1_29ck84 AVG v(dout1_29) FROM=1069.9n TO=1070.1n

.meas tran Vdout1_30ck84 AVG v(dout1_30) FROM=1069.9n TO=1070.1n

.meas tran Vdout1_31ck84 AVG v(dout1_31) FROM=1069.9n TO=1070.1n

.meas tran Vdout1_32ck84 AVG v(dout1_32) FROM=1069.9n TO=1070.1n

.meas tran Vdout1_33ck84 AVG v(dout1_33) FROM=1069.9n TO=1070.1n

.meas tran Vdout1_34ck84 AVG v(dout1_34) FROM=1069.9n TO=1070.1n

.meas tran Vdout1_35ck84 AVG v(dout1_35) FROM=1069.9n TO=1070.1n

.meas tran Vdout1_36ck84 AVG v(dout1_36) FROM=1069.9n TO=1070.1n

.meas tran Vdout1_37ck84 AVG v(dout1_37) FROM=1069.9n TO=1070.1n

.meas tran Vdout1_38ck84 AVG v(dout1_38) FROM=1069.9n TO=1070.1n

.meas tran Vdout1_39ck84 AVG v(dout1_39) FROM=1069.9n TO=1070.1n

.meas tran Vdout1_40ck84 AVG v(dout1_40) FROM=1069.9n TO=1070.1n

.meas tran Vdout1_41ck84 AVG v(dout1_41) FROM=1069.9n TO=1070.1n

.meas tran Vdout1_42ck84 AVG v(dout1_42) FROM=1069.9n TO=1070.1n

.meas tran Vdout1_43ck84 AVG v(dout1_43) FROM=1069.9n TO=1070.1n

.meas tran Vdout1_44ck84 AVG v(dout1_44) FROM=1069.9n TO=1070.1n

.meas tran Vdout1_45ck84 AVG v(dout1_45) FROM=1069.9n TO=1070.1n

.meas tran Vdout1_46ck84 AVG v(dout1_46) FROM=1069.9n TO=1070.1n

.meas tran Vdout1_47ck84 AVG v(dout1_47) FROM=1069.9n TO=1070.1n

.meas tran Vdout1_48ck84 AVG v(dout1_48) FROM=1069.9n TO=1070.1n

.meas tran Vdout1_49ck84 AVG v(dout1_49) FROM=1069.9n TO=1070.1n

.meas tran Vdout1_50ck84 AVG v(dout1_50) FROM=1069.9n TO=1070.1n

.meas tran Vdout1_51ck84 AVG v(dout1_51) FROM=1069.9n TO=1070.1n

.meas tran Vdout1_52ck84 AVG v(dout1_52) FROM=1069.9n TO=1070.1n

.meas tran Vdout1_53ck84 AVG v(dout1_53) FROM=1069.9n TO=1070.1n

.meas tran Vdout1_54ck84 AVG v(dout1_54) FROM=1069.9n TO=1070.1n

.meas tran Vdout1_55ck84 AVG v(dout1_55) FROM=1069.9n TO=1070.1n

.meas tran Vdout1_56ck84 AVG v(dout1_56) FROM=1069.9n TO=1070.1n

.meas tran Vdout1_57ck84 AVG v(dout1_57) FROM=1069.9n TO=1070.1n

.meas tran Vdout1_58ck84 AVG v(dout1_58) FROM=1069.9n TO=1070.1n

.meas tran Vdout1_59ck84 AVG v(dout1_59) FROM=1069.9n TO=1070.1n

.meas tran Vdout1_60ck84 AVG v(dout1_60) FROM=1069.9n TO=1070.1n

.meas tran Vdout1_61ck84 AVG v(dout1_61) FROM=1069.9n TO=1070.1n

.meas tran Vdout1_62ck84 AVG v(dout1_62) FROM=1069.9n TO=1070.1n

.meas tran Vdout1_63ck84 AVG v(dout1_63) FROM=1069.9n TO=1070.1n

.meas tran Vdout1_64ck84 AVG v(dout1_64) FROM=1069.9n TO=1070.1n

.meas tran Vdout1_65ck84 AVG v(dout1_65) FROM=1069.9n TO=1070.1n

.meas tran Vdout1_66ck84 AVG v(dout1_66) FROM=1069.9n TO=1070.1n

.meas tran Vdout1_67ck84 AVG v(dout1_67) FROM=1069.9n TO=1070.1n

.meas tran Vdout1_68ck84 AVG v(dout1_68) FROM=1069.9n TO=1070.1n

.meas tran Vdout1_69ck84 AVG v(dout1_69) FROM=1069.9n TO=1070.1n

.meas tran Vdout1_70ck84 AVG v(dout1_70) FROM=1069.9n TO=1070.1n

.meas tran Vdout1_71ck84 AVG v(dout1_71) FROM=1069.9n TO=1070.1n

.meas tran Vdout1_72ck84 AVG v(dout1_72) FROM=1069.9n TO=1070.1n

.meas tran Vdout1_73ck84 AVG v(dout1_73) FROM=1069.9n TO=1070.1n

.meas tran Vdout1_74ck84 AVG v(dout1_74) FROM=1069.9n TO=1070.1n

.meas tran Vdout1_75ck84 AVG v(dout1_75) FROM=1069.9n TO=1070.1n

.meas tran Vdout1_76ck84 AVG v(dout1_76) FROM=1069.9n TO=1070.1n

.meas tran Vdout1_77ck84 AVG v(dout1_77) FROM=1069.9n TO=1070.1n

.meas tran Vdout1_78ck84 AVG v(dout1_78) FROM=1069.9n TO=1070.1n

.meas tran Vdout1_79ck84 AVG v(dout1_79) FROM=1069.9n TO=1070.1n

.meas tran Vdout0_0ck85 AVG v(dout0_0) FROM=1079.9n TO=1080.1n

.meas tran Vdout0_1ck85 AVG v(dout0_1) FROM=1079.9n TO=1080.1n

.meas tran Vdout0_2ck85 AVG v(dout0_2) FROM=1079.9n TO=1080.1n

.meas tran Vdout0_3ck85 AVG v(dout0_3) FROM=1079.9n TO=1080.1n

.meas tran Vdout0_4ck85 AVG v(dout0_4) FROM=1079.9n TO=1080.1n

.meas tran Vdout0_5ck85 AVG v(dout0_5) FROM=1079.9n TO=1080.1n

.meas tran Vdout0_6ck85 AVG v(dout0_6) FROM=1079.9n TO=1080.1n

.meas tran Vdout0_7ck85 AVG v(dout0_7) FROM=1079.9n TO=1080.1n

.meas tran Vdout0_8ck85 AVG v(dout0_8) FROM=1079.9n TO=1080.1n

.meas tran Vdout0_9ck85 AVG v(dout0_9) FROM=1079.9n TO=1080.1n

.meas tran Vdout0_10ck85 AVG v(dout0_10) FROM=1079.9n TO=1080.1n

.meas tran Vdout0_11ck85 AVG v(dout0_11) FROM=1079.9n TO=1080.1n

.meas tran Vdout0_12ck85 AVG v(dout0_12) FROM=1079.9n TO=1080.1n

.meas tran Vdout0_13ck85 AVG v(dout0_13) FROM=1079.9n TO=1080.1n

.meas tran Vdout0_14ck85 AVG v(dout0_14) FROM=1079.9n TO=1080.1n

.meas tran Vdout0_15ck85 AVG v(dout0_15) FROM=1079.9n TO=1080.1n

.meas tran Vdout0_16ck85 AVG v(dout0_16) FROM=1079.9n TO=1080.1n

.meas tran Vdout0_17ck85 AVG v(dout0_17) FROM=1079.9n TO=1080.1n

.meas tran Vdout0_18ck85 AVG v(dout0_18) FROM=1079.9n TO=1080.1n

.meas tran Vdout0_19ck85 AVG v(dout0_19) FROM=1079.9n TO=1080.1n

.meas tran Vdout0_20ck85 AVG v(dout0_20) FROM=1079.9n TO=1080.1n

.meas tran Vdout0_21ck85 AVG v(dout0_21) FROM=1079.9n TO=1080.1n

.meas tran Vdout0_22ck85 AVG v(dout0_22) FROM=1079.9n TO=1080.1n

.meas tran Vdout0_23ck85 AVG v(dout0_23) FROM=1079.9n TO=1080.1n

.meas tran Vdout0_24ck85 AVG v(dout0_24) FROM=1079.9n TO=1080.1n

.meas tran Vdout0_25ck85 AVG v(dout0_25) FROM=1079.9n TO=1080.1n

.meas tran Vdout0_26ck85 AVG v(dout0_26) FROM=1079.9n TO=1080.1n

.meas tran Vdout0_27ck85 AVG v(dout0_27) FROM=1079.9n TO=1080.1n

.meas tran Vdout0_28ck85 AVG v(dout0_28) FROM=1079.9n TO=1080.1n

.meas tran Vdout0_29ck85 AVG v(dout0_29) FROM=1079.9n TO=1080.1n

.meas tran Vdout0_30ck85 AVG v(dout0_30) FROM=1079.9n TO=1080.1n

.meas tran Vdout0_31ck85 AVG v(dout0_31) FROM=1079.9n TO=1080.1n

.meas tran Vdout0_32ck85 AVG v(dout0_32) FROM=1079.9n TO=1080.1n

.meas tran Vdout0_33ck85 AVG v(dout0_33) FROM=1079.9n TO=1080.1n

.meas tran Vdout0_34ck85 AVG v(dout0_34) FROM=1079.9n TO=1080.1n

.meas tran Vdout0_35ck85 AVG v(dout0_35) FROM=1079.9n TO=1080.1n

.meas tran Vdout0_36ck85 AVG v(dout0_36) FROM=1079.9n TO=1080.1n

.meas tran Vdout0_37ck85 AVG v(dout0_37) FROM=1079.9n TO=1080.1n

.meas tran Vdout0_38ck85 AVG v(dout0_38) FROM=1079.9n TO=1080.1n

.meas tran Vdout0_39ck85 AVG v(dout0_39) FROM=1079.9n TO=1080.1n

.meas tran Vdout0_40ck85 AVG v(dout0_40) FROM=1079.9n TO=1080.1n

.meas tran Vdout0_41ck85 AVG v(dout0_41) FROM=1079.9n TO=1080.1n

.meas tran Vdout0_42ck85 AVG v(dout0_42) FROM=1079.9n TO=1080.1n

.meas tran Vdout0_43ck85 AVG v(dout0_43) FROM=1079.9n TO=1080.1n

.meas tran Vdout0_44ck85 AVG v(dout0_44) FROM=1079.9n TO=1080.1n

.meas tran Vdout0_45ck85 AVG v(dout0_45) FROM=1079.9n TO=1080.1n

.meas tran Vdout0_46ck85 AVG v(dout0_46) FROM=1079.9n TO=1080.1n

.meas tran Vdout0_47ck85 AVG v(dout0_47) FROM=1079.9n TO=1080.1n

.meas tran Vdout0_48ck85 AVG v(dout0_48) FROM=1079.9n TO=1080.1n

.meas tran Vdout0_49ck85 AVG v(dout0_49) FROM=1079.9n TO=1080.1n

.meas tran Vdout0_50ck85 AVG v(dout0_50) FROM=1079.9n TO=1080.1n

.meas tran Vdout0_51ck85 AVG v(dout0_51) FROM=1079.9n TO=1080.1n

.meas tran Vdout0_52ck85 AVG v(dout0_52) FROM=1079.9n TO=1080.1n

.meas tran Vdout0_53ck85 AVG v(dout0_53) FROM=1079.9n TO=1080.1n

.meas tran Vdout0_54ck85 AVG v(dout0_54) FROM=1079.9n TO=1080.1n

.meas tran Vdout0_55ck85 AVG v(dout0_55) FROM=1079.9n TO=1080.1n

.meas tran Vdout0_56ck85 AVG v(dout0_56) FROM=1079.9n TO=1080.1n

.meas tran Vdout0_57ck85 AVG v(dout0_57) FROM=1079.9n TO=1080.1n

.meas tran Vdout0_58ck85 AVG v(dout0_58) FROM=1079.9n TO=1080.1n

.meas tran Vdout0_59ck85 AVG v(dout0_59) FROM=1079.9n TO=1080.1n

.meas tran Vdout0_60ck85 AVG v(dout0_60) FROM=1079.9n TO=1080.1n

.meas tran Vdout0_61ck85 AVG v(dout0_61) FROM=1079.9n TO=1080.1n

.meas tran Vdout0_62ck85 AVG v(dout0_62) FROM=1079.9n TO=1080.1n

.meas tran Vdout0_63ck85 AVG v(dout0_63) FROM=1079.9n TO=1080.1n

.meas tran Vdout0_64ck85 AVG v(dout0_64) FROM=1079.9n TO=1080.1n

.meas tran Vdout0_65ck85 AVG v(dout0_65) FROM=1079.9n TO=1080.1n

.meas tran Vdout0_66ck85 AVG v(dout0_66) FROM=1079.9n TO=1080.1n

.meas tran Vdout0_67ck85 AVG v(dout0_67) FROM=1079.9n TO=1080.1n

.meas tran Vdout0_68ck85 AVG v(dout0_68) FROM=1079.9n TO=1080.1n

.meas tran Vdout0_69ck85 AVG v(dout0_69) FROM=1079.9n TO=1080.1n

.meas tran Vdout0_70ck85 AVG v(dout0_70) FROM=1079.9n TO=1080.1n

.meas tran Vdout0_71ck85 AVG v(dout0_71) FROM=1079.9n TO=1080.1n

.meas tran Vdout0_72ck85 AVG v(dout0_72) FROM=1079.9n TO=1080.1n

.meas tran Vdout0_73ck85 AVG v(dout0_73) FROM=1079.9n TO=1080.1n

.meas tran Vdout0_74ck85 AVG v(dout0_74) FROM=1079.9n TO=1080.1n

.meas tran Vdout0_75ck85 AVG v(dout0_75) FROM=1079.9n TO=1080.1n

.meas tran Vdout0_76ck85 AVG v(dout0_76) FROM=1079.9n TO=1080.1n

.meas tran Vdout0_77ck85 AVG v(dout0_77) FROM=1079.9n TO=1080.1n

.meas tran Vdout0_78ck85 AVG v(dout0_78) FROM=1079.9n TO=1080.1n

.meas tran Vdout0_79ck85 AVG v(dout0_79) FROM=1079.9n TO=1080.1n

.meas tran Vdout1_0ck86 AVG v(dout1_0) FROM=1089.9n TO=1090.1n

.meas tran Vdout1_1ck86 AVG v(dout1_1) FROM=1089.9n TO=1090.1n

.meas tran Vdout1_2ck86 AVG v(dout1_2) FROM=1089.9n TO=1090.1n

.meas tran Vdout1_3ck86 AVG v(dout1_3) FROM=1089.9n TO=1090.1n

.meas tran Vdout1_4ck86 AVG v(dout1_4) FROM=1089.9n TO=1090.1n

.meas tran Vdout1_5ck86 AVG v(dout1_5) FROM=1089.9n TO=1090.1n

.meas tran Vdout1_6ck86 AVG v(dout1_6) FROM=1089.9n TO=1090.1n

.meas tran Vdout1_7ck86 AVG v(dout1_7) FROM=1089.9n TO=1090.1n

.meas tran Vdout1_8ck86 AVG v(dout1_8) FROM=1089.9n TO=1090.1n

.meas tran Vdout1_9ck86 AVG v(dout1_9) FROM=1089.9n TO=1090.1n

.meas tran Vdout1_10ck86 AVG v(dout1_10) FROM=1089.9n TO=1090.1n

.meas tran Vdout1_11ck86 AVG v(dout1_11) FROM=1089.9n TO=1090.1n

.meas tran Vdout1_12ck86 AVG v(dout1_12) FROM=1089.9n TO=1090.1n

.meas tran Vdout1_13ck86 AVG v(dout1_13) FROM=1089.9n TO=1090.1n

.meas tran Vdout1_14ck86 AVG v(dout1_14) FROM=1089.9n TO=1090.1n

.meas tran Vdout1_15ck86 AVG v(dout1_15) FROM=1089.9n TO=1090.1n

.meas tran Vdout1_16ck86 AVG v(dout1_16) FROM=1089.9n TO=1090.1n

.meas tran Vdout1_17ck86 AVG v(dout1_17) FROM=1089.9n TO=1090.1n

.meas tran Vdout1_18ck86 AVG v(dout1_18) FROM=1089.9n TO=1090.1n

.meas tran Vdout1_19ck86 AVG v(dout1_19) FROM=1089.9n TO=1090.1n

.meas tran Vdout1_20ck86 AVG v(dout1_20) FROM=1089.9n TO=1090.1n

.meas tran Vdout1_21ck86 AVG v(dout1_21) FROM=1089.9n TO=1090.1n

.meas tran Vdout1_22ck86 AVG v(dout1_22) FROM=1089.9n TO=1090.1n

.meas tran Vdout1_23ck86 AVG v(dout1_23) FROM=1089.9n TO=1090.1n

.meas tran Vdout1_24ck86 AVG v(dout1_24) FROM=1089.9n TO=1090.1n

.meas tran Vdout1_25ck86 AVG v(dout1_25) FROM=1089.9n TO=1090.1n

.meas tran Vdout1_26ck86 AVG v(dout1_26) FROM=1089.9n TO=1090.1n

.meas tran Vdout1_27ck86 AVG v(dout1_27) FROM=1089.9n TO=1090.1n

.meas tran Vdout1_28ck86 AVG v(dout1_28) FROM=1089.9n TO=1090.1n

.meas tran Vdout1_29ck86 AVG v(dout1_29) FROM=1089.9n TO=1090.1n

.meas tran Vdout1_30ck86 AVG v(dout1_30) FROM=1089.9n TO=1090.1n

.meas tran Vdout1_31ck86 AVG v(dout1_31) FROM=1089.9n TO=1090.1n

.meas tran Vdout1_32ck86 AVG v(dout1_32) FROM=1089.9n TO=1090.1n

.meas tran Vdout1_33ck86 AVG v(dout1_33) FROM=1089.9n TO=1090.1n

.meas tran Vdout1_34ck86 AVG v(dout1_34) FROM=1089.9n TO=1090.1n

.meas tran Vdout1_35ck86 AVG v(dout1_35) FROM=1089.9n TO=1090.1n

.meas tran Vdout1_36ck86 AVG v(dout1_36) FROM=1089.9n TO=1090.1n

.meas tran Vdout1_37ck86 AVG v(dout1_37) FROM=1089.9n TO=1090.1n

.meas tran Vdout1_38ck86 AVG v(dout1_38) FROM=1089.9n TO=1090.1n

.meas tran Vdout1_39ck86 AVG v(dout1_39) FROM=1089.9n TO=1090.1n

.meas tran Vdout1_40ck86 AVG v(dout1_40) FROM=1089.9n TO=1090.1n

.meas tran Vdout1_41ck86 AVG v(dout1_41) FROM=1089.9n TO=1090.1n

.meas tran Vdout1_42ck86 AVG v(dout1_42) FROM=1089.9n TO=1090.1n

.meas tran Vdout1_43ck86 AVG v(dout1_43) FROM=1089.9n TO=1090.1n

.meas tran Vdout1_44ck86 AVG v(dout1_44) FROM=1089.9n TO=1090.1n

.meas tran Vdout1_45ck86 AVG v(dout1_45) FROM=1089.9n TO=1090.1n

.meas tran Vdout1_46ck86 AVG v(dout1_46) FROM=1089.9n TO=1090.1n

.meas tran Vdout1_47ck86 AVG v(dout1_47) FROM=1089.9n TO=1090.1n

.meas tran Vdout1_48ck86 AVG v(dout1_48) FROM=1089.9n TO=1090.1n

.meas tran Vdout1_49ck86 AVG v(dout1_49) FROM=1089.9n TO=1090.1n

.meas tran Vdout1_50ck86 AVG v(dout1_50) FROM=1089.9n TO=1090.1n

.meas tran Vdout1_51ck86 AVG v(dout1_51) FROM=1089.9n TO=1090.1n

.meas tran Vdout1_52ck86 AVG v(dout1_52) FROM=1089.9n TO=1090.1n

.meas tran Vdout1_53ck86 AVG v(dout1_53) FROM=1089.9n TO=1090.1n

.meas tran Vdout1_54ck86 AVG v(dout1_54) FROM=1089.9n TO=1090.1n

.meas tran Vdout1_55ck86 AVG v(dout1_55) FROM=1089.9n TO=1090.1n

.meas tran Vdout1_56ck86 AVG v(dout1_56) FROM=1089.9n TO=1090.1n

.meas tran Vdout1_57ck86 AVG v(dout1_57) FROM=1089.9n TO=1090.1n

.meas tran Vdout1_58ck86 AVG v(dout1_58) FROM=1089.9n TO=1090.1n

.meas tran Vdout1_59ck86 AVG v(dout1_59) FROM=1089.9n TO=1090.1n

.meas tran Vdout1_60ck86 AVG v(dout1_60) FROM=1089.9n TO=1090.1n

.meas tran Vdout1_61ck86 AVG v(dout1_61) FROM=1089.9n TO=1090.1n

.meas tran Vdout1_62ck86 AVG v(dout1_62) FROM=1089.9n TO=1090.1n

.meas tran Vdout1_63ck86 AVG v(dout1_63) FROM=1089.9n TO=1090.1n

.meas tran Vdout1_64ck86 AVG v(dout1_64) FROM=1089.9n TO=1090.1n

.meas tran Vdout1_65ck86 AVG v(dout1_65) FROM=1089.9n TO=1090.1n

.meas tran Vdout1_66ck86 AVG v(dout1_66) FROM=1089.9n TO=1090.1n

.meas tran Vdout1_67ck86 AVG v(dout1_67) FROM=1089.9n TO=1090.1n

.meas tran Vdout1_68ck86 AVG v(dout1_68) FROM=1089.9n TO=1090.1n

.meas tran Vdout1_69ck86 AVG v(dout1_69) FROM=1089.9n TO=1090.1n

.meas tran Vdout1_70ck86 AVG v(dout1_70) FROM=1089.9n TO=1090.1n

.meas tran Vdout1_71ck86 AVG v(dout1_71) FROM=1089.9n TO=1090.1n

.meas tran Vdout1_72ck86 AVG v(dout1_72) FROM=1089.9n TO=1090.1n

.meas tran Vdout1_73ck86 AVG v(dout1_73) FROM=1089.9n TO=1090.1n

.meas tran Vdout1_74ck86 AVG v(dout1_74) FROM=1089.9n TO=1090.1n

.meas tran Vdout1_75ck86 AVG v(dout1_75) FROM=1089.9n TO=1090.1n

.meas tran Vdout1_76ck86 AVG v(dout1_76) FROM=1089.9n TO=1090.1n

.meas tran Vdout1_77ck86 AVG v(dout1_77) FROM=1089.9n TO=1090.1n

.meas tran Vdout1_78ck86 AVG v(dout1_78) FROM=1089.9n TO=1090.1n

.meas tran Vdout1_79ck86 AVG v(dout1_79) FROM=1089.9n TO=1090.1n

.meas tran Vdout0_0ck87 AVG v(dout0_0) FROM=1119.9n TO=1120.1n

.meas tran Vdout0_1ck87 AVG v(dout0_1) FROM=1119.9n TO=1120.1n

.meas tran Vdout0_2ck87 AVG v(dout0_2) FROM=1119.9n TO=1120.1n

.meas tran Vdout0_3ck87 AVG v(dout0_3) FROM=1119.9n TO=1120.1n

.meas tran Vdout0_4ck87 AVG v(dout0_4) FROM=1119.9n TO=1120.1n

.meas tran Vdout0_5ck87 AVG v(dout0_5) FROM=1119.9n TO=1120.1n

.meas tran Vdout0_6ck87 AVG v(dout0_6) FROM=1119.9n TO=1120.1n

.meas tran Vdout0_7ck87 AVG v(dout0_7) FROM=1119.9n TO=1120.1n

.meas tran Vdout0_8ck87 AVG v(dout0_8) FROM=1119.9n TO=1120.1n

.meas tran Vdout0_9ck87 AVG v(dout0_9) FROM=1119.9n TO=1120.1n

.meas tran Vdout0_10ck87 AVG v(dout0_10) FROM=1119.9n TO=1120.1n

.meas tran Vdout0_11ck87 AVG v(dout0_11) FROM=1119.9n TO=1120.1n

.meas tran Vdout0_12ck87 AVG v(dout0_12) FROM=1119.9n TO=1120.1n

.meas tran Vdout0_13ck87 AVG v(dout0_13) FROM=1119.9n TO=1120.1n

.meas tran Vdout0_14ck87 AVG v(dout0_14) FROM=1119.9n TO=1120.1n

.meas tran Vdout0_15ck87 AVG v(dout0_15) FROM=1119.9n TO=1120.1n

.meas tran Vdout0_16ck87 AVG v(dout0_16) FROM=1119.9n TO=1120.1n

.meas tran Vdout0_17ck87 AVG v(dout0_17) FROM=1119.9n TO=1120.1n

.meas tran Vdout0_18ck87 AVG v(dout0_18) FROM=1119.9n TO=1120.1n

.meas tran Vdout0_19ck87 AVG v(dout0_19) FROM=1119.9n TO=1120.1n

.meas tran Vdout0_20ck87 AVG v(dout0_20) FROM=1119.9n TO=1120.1n

.meas tran Vdout0_21ck87 AVG v(dout0_21) FROM=1119.9n TO=1120.1n

.meas tran Vdout0_22ck87 AVG v(dout0_22) FROM=1119.9n TO=1120.1n

.meas tran Vdout0_23ck87 AVG v(dout0_23) FROM=1119.9n TO=1120.1n

.meas tran Vdout0_24ck87 AVG v(dout0_24) FROM=1119.9n TO=1120.1n

.meas tran Vdout0_25ck87 AVG v(dout0_25) FROM=1119.9n TO=1120.1n

.meas tran Vdout0_26ck87 AVG v(dout0_26) FROM=1119.9n TO=1120.1n

.meas tran Vdout0_27ck87 AVG v(dout0_27) FROM=1119.9n TO=1120.1n

.meas tran Vdout0_28ck87 AVG v(dout0_28) FROM=1119.9n TO=1120.1n

.meas tran Vdout0_29ck87 AVG v(dout0_29) FROM=1119.9n TO=1120.1n

.meas tran Vdout0_30ck87 AVG v(dout0_30) FROM=1119.9n TO=1120.1n

.meas tran Vdout0_31ck87 AVG v(dout0_31) FROM=1119.9n TO=1120.1n

.meas tran Vdout0_32ck87 AVG v(dout0_32) FROM=1119.9n TO=1120.1n

.meas tran Vdout0_33ck87 AVG v(dout0_33) FROM=1119.9n TO=1120.1n

.meas tran Vdout0_34ck87 AVG v(dout0_34) FROM=1119.9n TO=1120.1n

.meas tran Vdout0_35ck87 AVG v(dout0_35) FROM=1119.9n TO=1120.1n

.meas tran Vdout0_36ck87 AVG v(dout0_36) FROM=1119.9n TO=1120.1n

.meas tran Vdout0_37ck87 AVG v(dout0_37) FROM=1119.9n TO=1120.1n

.meas tran Vdout0_38ck87 AVG v(dout0_38) FROM=1119.9n TO=1120.1n

.meas tran Vdout0_39ck87 AVG v(dout0_39) FROM=1119.9n TO=1120.1n

.meas tran Vdout0_40ck87 AVG v(dout0_40) FROM=1119.9n TO=1120.1n

.meas tran Vdout0_41ck87 AVG v(dout0_41) FROM=1119.9n TO=1120.1n

.meas tran Vdout0_42ck87 AVG v(dout0_42) FROM=1119.9n TO=1120.1n

.meas tran Vdout0_43ck87 AVG v(dout0_43) FROM=1119.9n TO=1120.1n

.meas tran Vdout0_44ck87 AVG v(dout0_44) FROM=1119.9n TO=1120.1n

.meas tran Vdout0_45ck87 AVG v(dout0_45) FROM=1119.9n TO=1120.1n

.meas tran Vdout0_46ck87 AVG v(dout0_46) FROM=1119.9n TO=1120.1n

.meas tran Vdout0_47ck87 AVG v(dout0_47) FROM=1119.9n TO=1120.1n

.meas tran Vdout0_48ck87 AVG v(dout0_48) FROM=1119.9n TO=1120.1n

.meas tran Vdout0_49ck87 AVG v(dout0_49) FROM=1119.9n TO=1120.1n

.meas tran Vdout0_50ck87 AVG v(dout0_50) FROM=1119.9n TO=1120.1n

.meas tran Vdout0_51ck87 AVG v(dout0_51) FROM=1119.9n TO=1120.1n

.meas tran Vdout0_52ck87 AVG v(dout0_52) FROM=1119.9n TO=1120.1n

.meas tran Vdout0_53ck87 AVG v(dout0_53) FROM=1119.9n TO=1120.1n

.meas tran Vdout0_54ck87 AVG v(dout0_54) FROM=1119.9n TO=1120.1n

.meas tran Vdout0_55ck87 AVG v(dout0_55) FROM=1119.9n TO=1120.1n

.meas tran Vdout0_56ck87 AVG v(dout0_56) FROM=1119.9n TO=1120.1n

.meas tran Vdout0_57ck87 AVG v(dout0_57) FROM=1119.9n TO=1120.1n

.meas tran Vdout0_58ck87 AVG v(dout0_58) FROM=1119.9n TO=1120.1n

.meas tran Vdout0_59ck87 AVG v(dout0_59) FROM=1119.9n TO=1120.1n

.meas tran Vdout0_60ck87 AVG v(dout0_60) FROM=1119.9n TO=1120.1n

.meas tran Vdout0_61ck87 AVG v(dout0_61) FROM=1119.9n TO=1120.1n

.meas tran Vdout0_62ck87 AVG v(dout0_62) FROM=1119.9n TO=1120.1n

.meas tran Vdout0_63ck87 AVG v(dout0_63) FROM=1119.9n TO=1120.1n

.meas tran Vdout0_64ck87 AVG v(dout0_64) FROM=1119.9n TO=1120.1n

.meas tran Vdout0_65ck87 AVG v(dout0_65) FROM=1119.9n TO=1120.1n

.meas tran Vdout0_66ck87 AVG v(dout0_66) FROM=1119.9n TO=1120.1n

.meas tran Vdout0_67ck87 AVG v(dout0_67) FROM=1119.9n TO=1120.1n

.meas tran Vdout0_68ck87 AVG v(dout0_68) FROM=1119.9n TO=1120.1n

.meas tran Vdout0_69ck87 AVG v(dout0_69) FROM=1119.9n TO=1120.1n

.meas tran Vdout0_70ck87 AVG v(dout0_70) FROM=1119.9n TO=1120.1n

.meas tran Vdout0_71ck87 AVG v(dout0_71) FROM=1119.9n TO=1120.1n

.meas tran Vdout0_72ck87 AVG v(dout0_72) FROM=1119.9n TO=1120.1n

.meas tran Vdout0_73ck87 AVG v(dout0_73) FROM=1119.9n TO=1120.1n

.meas tran Vdout0_74ck87 AVG v(dout0_74) FROM=1119.9n TO=1120.1n

.meas tran Vdout0_75ck87 AVG v(dout0_75) FROM=1119.9n TO=1120.1n

.meas tran Vdout0_76ck87 AVG v(dout0_76) FROM=1119.9n TO=1120.1n

.meas tran Vdout0_77ck87 AVG v(dout0_77) FROM=1119.9n TO=1120.1n

.meas tran Vdout0_78ck87 AVG v(dout0_78) FROM=1119.9n TO=1120.1n

.meas tran Vdout0_79ck87 AVG v(dout0_79) FROM=1119.9n TO=1120.1n

.meas tran Vdout1_0ck88 AVG v(dout1_0) FROM=1119.9n TO=1120.1n

.meas tran Vdout1_1ck88 AVG v(dout1_1) FROM=1119.9n TO=1120.1n

.meas tran Vdout1_2ck88 AVG v(dout1_2) FROM=1119.9n TO=1120.1n

.meas tran Vdout1_3ck88 AVG v(dout1_3) FROM=1119.9n TO=1120.1n

.meas tran Vdout1_4ck88 AVG v(dout1_4) FROM=1119.9n TO=1120.1n

.meas tran Vdout1_5ck88 AVG v(dout1_5) FROM=1119.9n TO=1120.1n

.meas tran Vdout1_6ck88 AVG v(dout1_6) FROM=1119.9n TO=1120.1n

.meas tran Vdout1_7ck88 AVG v(dout1_7) FROM=1119.9n TO=1120.1n

.meas tran Vdout1_8ck88 AVG v(dout1_8) FROM=1119.9n TO=1120.1n

.meas tran Vdout1_9ck88 AVG v(dout1_9) FROM=1119.9n TO=1120.1n

.meas tran Vdout1_10ck88 AVG v(dout1_10) FROM=1119.9n TO=1120.1n

.meas tran Vdout1_11ck88 AVG v(dout1_11) FROM=1119.9n TO=1120.1n

.meas tran Vdout1_12ck88 AVG v(dout1_12) FROM=1119.9n TO=1120.1n

.meas tran Vdout1_13ck88 AVG v(dout1_13) FROM=1119.9n TO=1120.1n

.meas tran Vdout1_14ck88 AVG v(dout1_14) FROM=1119.9n TO=1120.1n

.meas tran Vdout1_15ck88 AVG v(dout1_15) FROM=1119.9n TO=1120.1n

.meas tran Vdout1_16ck88 AVG v(dout1_16) FROM=1119.9n TO=1120.1n

.meas tran Vdout1_17ck88 AVG v(dout1_17) FROM=1119.9n TO=1120.1n

.meas tran Vdout1_18ck88 AVG v(dout1_18) FROM=1119.9n TO=1120.1n

.meas tran Vdout1_19ck88 AVG v(dout1_19) FROM=1119.9n TO=1120.1n

.meas tran Vdout1_20ck88 AVG v(dout1_20) FROM=1119.9n TO=1120.1n

.meas tran Vdout1_21ck88 AVG v(dout1_21) FROM=1119.9n TO=1120.1n

.meas tran Vdout1_22ck88 AVG v(dout1_22) FROM=1119.9n TO=1120.1n

.meas tran Vdout1_23ck88 AVG v(dout1_23) FROM=1119.9n TO=1120.1n

.meas tran Vdout1_24ck88 AVG v(dout1_24) FROM=1119.9n TO=1120.1n

.meas tran Vdout1_25ck88 AVG v(dout1_25) FROM=1119.9n TO=1120.1n

.meas tran Vdout1_26ck88 AVG v(dout1_26) FROM=1119.9n TO=1120.1n

.meas tran Vdout1_27ck88 AVG v(dout1_27) FROM=1119.9n TO=1120.1n

.meas tran Vdout1_28ck88 AVG v(dout1_28) FROM=1119.9n TO=1120.1n

.meas tran Vdout1_29ck88 AVG v(dout1_29) FROM=1119.9n TO=1120.1n

.meas tran Vdout1_30ck88 AVG v(dout1_30) FROM=1119.9n TO=1120.1n

.meas tran Vdout1_31ck88 AVG v(dout1_31) FROM=1119.9n TO=1120.1n

.meas tran Vdout1_32ck88 AVG v(dout1_32) FROM=1119.9n TO=1120.1n

.meas tran Vdout1_33ck88 AVG v(dout1_33) FROM=1119.9n TO=1120.1n

.meas tran Vdout1_34ck88 AVG v(dout1_34) FROM=1119.9n TO=1120.1n

.meas tran Vdout1_35ck88 AVG v(dout1_35) FROM=1119.9n TO=1120.1n

.meas tran Vdout1_36ck88 AVG v(dout1_36) FROM=1119.9n TO=1120.1n

.meas tran Vdout1_37ck88 AVG v(dout1_37) FROM=1119.9n TO=1120.1n

.meas tran Vdout1_38ck88 AVG v(dout1_38) FROM=1119.9n TO=1120.1n

.meas tran Vdout1_39ck88 AVG v(dout1_39) FROM=1119.9n TO=1120.1n

.meas tran Vdout1_40ck88 AVG v(dout1_40) FROM=1119.9n TO=1120.1n

.meas tran Vdout1_41ck88 AVG v(dout1_41) FROM=1119.9n TO=1120.1n

.meas tran Vdout1_42ck88 AVG v(dout1_42) FROM=1119.9n TO=1120.1n

.meas tran Vdout1_43ck88 AVG v(dout1_43) FROM=1119.9n TO=1120.1n

.meas tran Vdout1_44ck88 AVG v(dout1_44) FROM=1119.9n TO=1120.1n

.meas tran Vdout1_45ck88 AVG v(dout1_45) FROM=1119.9n TO=1120.1n

.meas tran Vdout1_46ck88 AVG v(dout1_46) FROM=1119.9n TO=1120.1n

.meas tran Vdout1_47ck88 AVG v(dout1_47) FROM=1119.9n TO=1120.1n

.meas tran Vdout1_48ck88 AVG v(dout1_48) FROM=1119.9n TO=1120.1n

.meas tran Vdout1_49ck88 AVG v(dout1_49) FROM=1119.9n TO=1120.1n

.meas tran Vdout1_50ck88 AVG v(dout1_50) FROM=1119.9n TO=1120.1n

.meas tran Vdout1_51ck88 AVG v(dout1_51) FROM=1119.9n TO=1120.1n

.meas tran Vdout1_52ck88 AVG v(dout1_52) FROM=1119.9n TO=1120.1n

.meas tran Vdout1_53ck88 AVG v(dout1_53) FROM=1119.9n TO=1120.1n

.meas tran Vdout1_54ck88 AVG v(dout1_54) FROM=1119.9n TO=1120.1n

.meas tran Vdout1_55ck88 AVG v(dout1_55) FROM=1119.9n TO=1120.1n

.meas tran Vdout1_56ck88 AVG v(dout1_56) FROM=1119.9n TO=1120.1n

.meas tran Vdout1_57ck88 AVG v(dout1_57) FROM=1119.9n TO=1120.1n

.meas tran Vdout1_58ck88 AVG v(dout1_58) FROM=1119.9n TO=1120.1n

.meas tran Vdout1_59ck88 AVG v(dout1_59) FROM=1119.9n TO=1120.1n

.meas tran Vdout1_60ck88 AVG v(dout1_60) FROM=1119.9n TO=1120.1n

.meas tran Vdout1_61ck88 AVG v(dout1_61) FROM=1119.9n TO=1120.1n

.meas tran Vdout1_62ck88 AVG v(dout1_62) FROM=1119.9n TO=1120.1n

.meas tran Vdout1_63ck88 AVG v(dout1_63) FROM=1119.9n TO=1120.1n

.meas tran Vdout1_64ck88 AVG v(dout1_64) FROM=1119.9n TO=1120.1n

.meas tran Vdout1_65ck88 AVG v(dout1_65) FROM=1119.9n TO=1120.1n

.meas tran Vdout1_66ck88 AVG v(dout1_66) FROM=1119.9n TO=1120.1n

.meas tran Vdout1_67ck88 AVG v(dout1_67) FROM=1119.9n TO=1120.1n

.meas tran Vdout1_68ck88 AVG v(dout1_68) FROM=1119.9n TO=1120.1n

.meas tran Vdout1_69ck88 AVG v(dout1_69) FROM=1119.9n TO=1120.1n

.meas tran Vdout1_70ck88 AVG v(dout1_70) FROM=1119.9n TO=1120.1n

.meas tran Vdout1_71ck88 AVG v(dout1_71) FROM=1119.9n TO=1120.1n

.meas tran Vdout1_72ck88 AVG v(dout1_72) FROM=1119.9n TO=1120.1n

.meas tran Vdout1_73ck88 AVG v(dout1_73) FROM=1119.9n TO=1120.1n

.meas tran Vdout1_74ck88 AVG v(dout1_74) FROM=1119.9n TO=1120.1n

.meas tran Vdout1_75ck88 AVG v(dout1_75) FROM=1119.9n TO=1120.1n

.meas tran Vdout1_76ck88 AVG v(dout1_76) FROM=1119.9n TO=1120.1n

.meas tran Vdout1_77ck88 AVG v(dout1_77) FROM=1119.9n TO=1120.1n

.meas tran Vdout1_78ck88 AVG v(dout1_78) FROM=1119.9n TO=1120.1n

.meas tran Vdout1_79ck88 AVG v(dout1_79) FROM=1119.9n TO=1120.1n

.meas tran Vdout0_0ck89 AVG v(dout0_0) FROM=1129.9n TO=1130.1n

.meas tran Vdout0_1ck89 AVG v(dout0_1) FROM=1129.9n TO=1130.1n

.meas tran Vdout0_2ck89 AVG v(dout0_2) FROM=1129.9n TO=1130.1n

.meas tran Vdout0_3ck89 AVG v(dout0_3) FROM=1129.9n TO=1130.1n

.meas tran Vdout0_4ck89 AVG v(dout0_4) FROM=1129.9n TO=1130.1n

.meas tran Vdout0_5ck89 AVG v(dout0_5) FROM=1129.9n TO=1130.1n

.meas tran Vdout0_6ck89 AVG v(dout0_6) FROM=1129.9n TO=1130.1n

.meas tran Vdout0_7ck89 AVG v(dout0_7) FROM=1129.9n TO=1130.1n

.meas tran Vdout0_8ck89 AVG v(dout0_8) FROM=1129.9n TO=1130.1n

.meas tran Vdout0_9ck89 AVG v(dout0_9) FROM=1129.9n TO=1130.1n

.meas tran Vdout0_10ck89 AVG v(dout0_10) FROM=1129.9n TO=1130.1n

.meas tran Vdout0_11ck89 AVG v(dout0_11) FROM=1129.9n TO=1130.1n

.meas tran Vdout0_12ck89 AVG v(dout0_12) FROM=1129.9n TO=1130.1n

.meas tran Vdout0_13ck89 AVG v(dout0_13) FROM=1129.9n TO=1130.1n

.meas tran Vdout0_14ck89 AVG v(dout0_14) FROM=1129.9n TO=1130.1n

.meas tran Vdout0_15ck89 AVG v(dout0_15) FROM=1129.9n TO=1130.1n

.meas tran Vdout0_16ck89 AVG v(dout0_16) FROM=1129.9n TO=1130.1n

.meas tran Vdout0_17ck89 AVG v(dout0_17) FROM=1129.9n TO=1130.1n

.meas tran Vdout0_18ck89 AVG v(dout0_18) FROM=1129.9n TO=1130.1n

.meas tran Vdout0_19ck89 AVG v(dout0_19) FROM=1129.9n TO=1130.1n

.meas tran Vdout0_20ck89 AVG v(dout0_20) FROM=1129.9n TO=1130.1n

.meas tran Vdout0_21ck89 AVG v(dout0_21) FROM=1129.9n TO=1130.1n

.meas tran Vdout0_22ck89 AVG v(dout0_22) FROM=1129.9n TO=1130.1n

.meas tran Vdout0_23ck89 AVG v(dout0_23) FROM=1129.9n TO=1130.1n

.meas tran Vdout0_24ck89 AVG v(dout0_24) FROM=1129.9n TO=1130.1n

.meas tran Vdout0_25ck89 AVG v(dout0_25) FROM=1129.9n TO=1130.1n

.meas tran Vdout0_26ck89 AVG v(dout0_26) FROM=1129.9n TO=1130.1n

.meas tran Vdout0_27ck89 AVG v(dout0_27) FROM=1129.9n TO=1130.1n

.meas tran Vdout0_28ck89 AVG v(dout0_28) FROM=1129.9n TO=1130.1n

.meas tran Vdout0_29ck89 AVG v(dout0_29) FROM=1129.9n TO=1130.1n

.meas tran Vdout0_30ck89 AVG v(dout0_30) FROM=1129.9n TO=1130.1n

.meas tran Vdout0_31ck89 AVG v(dout0_31) FROM=1129.9n TO=1130.1n

.meas tran Vdout0_32ck89 AVG v(dout0_32) FROM=1129.9n TO=1130.1n

.meas tran Vdout0_33ck89 AVG v(dout0_33) FROM=1129.9n TO=1130.1n

.meas tran Vdout0_34ck89 AVG v(dout0_34) FROM=1129.9n TO=1130.1n

.meas tran Vdout0_35ck89 AVG v(dout0_35) FROM=1129.9n TO=1130.1n

.meas tran Vdout0_36ck89 AVG v(dout0_36) FROM=1129.9n TO=1130.1n

.meas tran Vdout0_37ck89 AVG v(dout0_37) FROM=1129.9n TO=1130.1n

.meas tran Vdout0_38ck89 AVG v(dout0_38) FROM=1129.9n TO=1130.1n

.meas tran Vdout0_39ck89 AVG v(dout0_39) FROM=1129.9n TO=1130.1n

.meas tran Vdout0_40ck89 AVG v(dout0_40) FROM=1129.9n TO=1130.1n

.meas tran Vdout0_41ck89 AVG v(dout0_41) FROM=1129.9n TO=1130.1n

.meas tran Vdout0_42ck89 AVG v(dout0_42) FROM=1129.9n TO=1130.1n

.meas tran Vdout0_43ck89 AVG v(dout0_43) FROM=1129.9n TO=1130.1n

.meas tran Vdout0_44ck89 AVG v(dout0_44) FROM=1129.9n TO=1130.1n

.meas tran Vdout0_45ck89 AVG v(dout0_45) FROM=1129.9n TO=1130.1n

.meas tran Vdout0_46ck89 AVG v(dout0_46) FROM=1129.9n TO=1130.1n

.meas tran Vdout0_47ck89 AVG v(dout0_47) FROM=1129.9n TO=1130.1n

.meas tran Vdout0_48ck89 AVG v(dout0_48) FROM=1129.9n TO=1130.1n

.meas tran Vdout0_49ck89 AVG v(dout0_49) FROM=1129.9n TO=1130.1n

.meas tran Vdout0_50ck89 AVG v(dout0_50) FROM=1129.9n TO=1130.1n

.meas tran Vdout0_51ck89 AVG v(dout0_51) FROM=1129.9n TO=1130.1n

.meas tran Vdout0_52ck89 AVG v(dout0_52) FROM=1129.9n TO=1130.1n

.meas tran Vdout0_53ck89 AVG v(dout0_53) FROM=1129.9n TO=1130.1n

.meas tran Vdout0_54ck89 AVG v(dout0_54) FROM=1129.9n TO=1130.1n

.meas tran Vdout0_55ck89 AVG v(dout0_55) FROM=1129.9n TO=1130.1n

.meas tran Vdout0_56ck89 AVG v(dout0_56) FROM=1129.9n TO=1130.1n

.meas tran Vdout0_57ck89 AVG v(dout0_57) FROM=1129.9n TO=1130.1n

.meas tran Vdout0_58ck89 AVG v(dout0_58) FROM=1129.9n TO=1130.1n

.meas tran Vdout0_59ck89 AVG v(dout0_59) FROM=1129.9n TO=1130.1n

.meas tran Vdout0_60ck89 AVG v(dout0_60) FROM=1129.9n TO=1130.1n

.meas tran Vdout0_61ck89 AVG v(dout0_61) FROM=1129.9n TO=1130.1n

.meas tran Vdout0_62ck89 AVG v(dout0_62) FROM=1129.9n TO=1130.1n

.meas tran Vdout0_63ck89 AVG v(dout0_63) FROM=1129.9n TO=1130.1n

.meas tran Vdout0_64ck89 AVG v(dout0_64) FROM=1129.9n TO=1130.1n

.meas tran Vdout0_65ck89 AVG v(dout0_65) FROM=1129.9n TO=1130.1n

.meas tran Vdout0_66ck89 AVG v(dout0_66) FROM=1129.9n TO=1130.1n

.meas tran Vdout0_67ck89 AVG v(dout0_67) FROM=1129.9n TO=1130.1n

.meas tran Vdout0_68ck89 AVG v(dout0_68) FROM=1129.9n TO=1130.1n

.meas tran Vdout0_69ck89 AVG v(dout0_69) FROM=1129.9n TO=1130.1n

.meas tran Vdout0_70ck89 AVG v(dout0_70) FROM=1129.9n TO=1130.1n

.meas tran Vdout0_71ck89 AVG v(dout0_71) FROM=1129.9n TO=1130.1n

.meas tran Vdout0_72ck89 AVG v(dout0_72) FROM=1129.9n TO=1130.1n

.meas tran Vdout0_73ck89 AVG v(dout0_73) FROM=1129.9n TO=1130.1n

.meas tran Vdout0_74ck89 AVG v(dout0_74) FROM=1129.9n TO=1130.1n

.meas tran Vdout0_75ck89 AVG v(dout0_75) FROM=1129.9n TO=1130.1n

.meas tran Vdout0_76ck89 AVG v(dout0_76) FROM=1129.9n TO=1130.1n

.meas tran Vdout0_77ck89 AVG v(dout0_77) FROM=1129.9n TO=1130.1n

.meas tran Vdout0_78ck89 AVG v(dout0_78) FROM=1129.9n TO=1130.1n

.meas tran Vdout0_79ck89 AVG v(dout0_79) FROM=1129.9n TO=1130.1n

.meas tran Vdout0_0ck90 AVG v(dout0_0) FROM=1139.9n TO=1140.1n

.meas tran Vdout0_1ck90 AVG v(dout0_1) FROM=1139.9n TO=1140.1n

.meas tran Vdout0_2ck90 AVG v(dout0_2) FROM=1139.9n TO=1140.1n

.meas tran Vdout0_3ck90 AVG v(dout0_3) FROM=1139.9n TO=1140.1n

.meas tran Vdout0_4ck90 AVG v(dout0_4) FROM=1139.9n TO=1140.1n

.meas tran Vdout0_5ck90 AVG v(dout0_5) FROM=1139.9n TO=1140.1n

.meas tran Vdout0_6ck90 AVG v(dout0_6) FROM=1139.9n TO=1140.1n

.meas tran Vdout0_7ck90 AVG v(dout0_7) FROM=1139.9n TO=1140.1n

.meas tran Vdout0_8ck90 AVG v(dout0_8) FROM=1139.9n TO=1140.1n

.meas tran Vdout0_9ck90 AVG v(dout0_9) FROM=1139.9n TO=1140.1n

.meas tran Vdout0_10ck90 AVG v(dout0_10) FROM=1139.9n TO=1140.1n

.meas tran Vdout0_11ck90 AVG v(dout0_11) FROM=1139.9n TO=1140.1n

.meas tran Vdout0_12ck90 AVG v(dout0_12) FROM=1139.9n TO=1140.1n

.meas tran Vdout0_13ck90 AVG v(dout0_13) FROM=1139.9n TO=1140.1n

.meas tran Vdout0_14ck90 AVG v(dout0_14) FROM=1139.9n TO=1140.1n

.meas tran Vdout0_15ck90 AVG v(dout0_15) FROM=1139.9n TO=1140.1n

.meas tran Vdout0_16ck90 AVG v(dout0_16) FROM=1139.9n TO=1140.1n

.meas tran Vdout0_17ck90 AVG v(dout0_17) FROM=1139.9n TO=1140.1n

.meas tran Vdout0_18ck90 AVG v(dout0_18) FROM=1139.9n TO=1140.1n

.meas tran Vdout0_19ck90 AVG v(dout0_19) FROM=1139.9n TO=1140.1n

.meas tran Vdout0_20ck90 AVG v(dout0_20) FROM=1139.9n TO=1140.1n

.meas tran Vdout0_21ck90 AVG v(dout0_21) FROM=1139.9n TO=1140.1n

.meas tran Vdout0_22ck90 AVG v(dout0_22) FROM=1139.9n TO=1140.1n

.meas tran Vdout0_23ck90 AVG v(dout0_23) FROM=1139.9n TO=1140.1n

.meas tran Vdout0_24ck90 AVG v(dout0_24) FROM=1139.9n TO=1140.1n

.meas tran Vdout0_25ck90 AVG v(dout0_25) FROM=1139.9n TO=1140.1n

.meas tran Vdout0_26ck90 AVG v(dout0_26) FROM=1139.9n TO=1140.1n

.meas tran Vdout0_27ck90 AVG v(dout0_27) FROM=1139.9n TO=1140.1n

.meas tran Vdout0_28ck90 AVG v(dout0_28) FROM=1139.9n TO=1140.1n

.meas tran Vdout0_29ck90 AVG v(dout0_29) FROM=1139.9n TO=1140.1n

.meas tran Vdout0_30ck90 AVG v(dout0_30) FROM=1139.9n TO=1140.1n

.meas tran Vdout0_31ck90 AVG v(dout0_31) FROM=1139.9n TO=1140.1n

.meas tran Vdout0_32ck90 AVG v(dout0_32) FROM=1139.9n TO=1140.1n

.meas tran Vdout0_33ck90 AVG v(dout0_33) FROM=1139.9n TO=1140.1n

.meas tran Vdout0_34ck90 AVG v(dout0_34) FROM=1139.9n TO=1140.1n

.meas tran Vdout0_35ck90 AVG v(dout0_35) FROM=1139.9n TO=1140.1n

.meas tran Vdout0_36ck90 AVG v(dout0_36) FROM=1139.9n TO=1140.1n

.meas tran Vdout0_37ck90 AVG v(dout0_37) FROM=1139.9n TO=1140.1n

.meas tran Vdout0_38ck90 AVG v(dout0_38) FROM=1139.9n TO=1140.1n

.meas tran Vdout0_39ck90 AVG v(dout0_39) FROM=1139.9n TO=1140.1n

.meas tran Vdout0_40ck90 AVG v(dout0_40) FROM=1139.9n TO=1140.1n

.meas tran Vdout0_41ck90 AVG v(dout0_41) FROM=1139.9n TO=1140.1n

.meas tran Vdout0_42ck90 AVG v(dout0_42) FROM=1139.9n TO=1140.1n

.meas tran Vdout0_43ck90 AVG v(dout0_43) FROM=1139.9n TO=1140.1n

.meas tran Vdout0_44ck90 AVG v(dout0_44) FROM=1139.9n TO=1140.1n

.meas tran Vdout0_45ck90 AVG v(dout0_45) FROM=1139.9n TO=1140.1n

.meas tran Vdout0_46ck90 AVG v(dout0_46) FROM=1139.9n TO=1140.1n

.meas tran Vdout0_47ck90 AVG v(dout0_47) FROM=1139.9n TO=1140.1n

.meas tran Vdout0_48ck90 AVG v(dout0_48) FROM=1139.9n TO=1140.1n

.meas tran Vdout0_49ck90 AVG v(dout0_49) FROM=1139.9n TO=1140.1n

.meas tran Vdout0_50ck90 AVG v(dout0_50) FROM=1139.9n TO=1140.1n

.meas tran Vdout0_51ck90 AVG v(dout0_51) FROM=1139.9n TO=1140.1n

.meas tran Vdout0_52ck90 AVG v(dout0_52) FROM=1139.9n TO=1140.1n

.meas tran Vdout0_53ck90 AVG v(dout0_53) FROM=1139.9n TO=1140.1n

.meas tran Vdout0_54ck90 AVG v(dout0_54) FROM=1139.9n TO=1140.1n

.meas tran Vdout0_55ck90 AVG v(dout0_55) FROM=1139.9n TO=1140.1n

.meas tran Vdout0_56ck90 AVG v(dout0_56) FROM=1139.9n TO=1140.1n

.meas tran Vdout0_57ck90 AVG v(dout0_57) FROM=1139.9n TO=1140.1n

.meas tran Vdout0_58ck90 AVG v(dout0_58) FROM=1139.9n TO=1140.1n

.meas tran Vdout0_59ck90 AVG v(dout0_59) FROM=1139.9n TO=1140.1n

.meas tran Vdout0_60ck90 AVG v(dout0_60) FROM=1139.9n TO=1140.1n

.meas tran Vdout0_61ck90 AVG v(dout0_61) FROM=1139.9n TO=1140.1n

.meas tran Vdout0_62ck90 AVG v(dout0_62) FROM=1139.9n TO=1140.1n

.meas tran Vdout0_63ck90 AVG v(dout0_63) FROM=1139.9n TO=1140.1n

.meas tran Vdout0_64ck90 AVG v(dout0_64) FROM=1139.9n TO=1140.1n

.meas tran Vdout0_65ck90 AVG v(dout0_65) FROM=1139.9n TO=1140.1n

.meas tran Vdout0_66ck90 AVG v(dout0_66) FROM=1139.9n TO=1140.1n

.meas tran Vdout0_67ck90 AVG v(dout0_67) FROM=1139.9n TO=1140.1n

.meas tran Vdout0_68ck90 AVG v(dout0_68) FROM=1139.9n TO=1140.1n

.meas tran Vdout0_69ck90 AVG v(dout0_69) FROM=1139.9n TO=1140.1n

.meas tran Vdout0_70ck90 AVG v(dout0_70) FROM=1139.9n TO=1140.1n

.meas tran Vdout0_71ck90 AVG v(dout0_71) FROM=1139.9n TO=1140.1n

.meas tran Vdout0_72ck90 AVG v(dout0_72) FROM=1139.9n TO=1140.1n

.meas tran Vdout0_73ck90 AVG v(dout0_73) FROM=1139.9n TO=1140.1n

.meas tran Vdout0_74ck90 AVG v(dout0_74) FROM=1139.9n TO=1140.1n

.meas tran Vdout0_75ck90 AVG v(dout0_75) FROM=1139.9n TO=1140.1n

.meas tran Vdout0_76ck90 AVG v(dout0_76) FROM=1139.9n TO=1140.1n

.meas tran Vdout0_77ck90 AVG v(dout0_77) FROM=1139.9n TO=1140.1n

.meas tran Vdout0_78ck90 AVG v(dout0_78) FROM=1139.9n TO=1140.1n

.meas tran Vdout0_79ck90 AVG v(dout0_79) FROM=1139.9n TO=1140.1n

.meas tran Vdout1_0ck91 AVG v(dout1_0) FROM=1139.9n TO=1140.1n

.meas tran Vdout1_1ck91 AVG v(dout1_1) FROM=1139.9n TO=1140.1n

.meas tran Vdout1_2ck91 AVG v(dout1_2) FROM=1139.9n TO=1140.1n

.meas tran Vdout1_3ck91 AVG v(dout1_3) FROM=1139.9n TO=1140.1n

.meas tran Vdout1_4ck91 AVG v(dout1_4) FROM=1139.9n TO=1140.1n

.meas tran Vdout1_5ck91 AVG v(dout1_5) FROM=1139.9n TO=1140.1n

.meas tran Vdout1_6ck91 AVG v(dout1_6) FROM=1139.9n TO=1140.1n

.meas tran Vdout1_7ck91 AVG v(dout1_7) FROM=1139.9n TO=1140.1n

.meas tran Vdout1_8ck91 AVG v(dout1_8) FROM=1139.9n TO=1140.1n

.meas tran Vdout1_9ck91 AVG v(dout1_9) FROM=1139.9n TO=1140.1n

.meas tran Vdout1_10ck91 AVG v(dout1_10) FROM=1139.9n TO=1140.1n

.meas tran Vdout1_11ck91 AVG v(dout1_11) FROM=1139.9n TO=1140.1n

.meas tran Vdout1_12ck91 AVG v(dout1_12) FROM=1139.9n TO=1140.1n

.meas tran Vdout1_13ck91 AVG v(dout1_13) FROM=1139.9n TO=1140.1n

.meas tran Vdout1_14ck91 AVG v(dout1_14) FROM=1139.9n TO=1140.1n

.meas tran Vdout1_15ck91 AVG v(dout1_15) FROM=1139.9n TO=1140.1n

.meas tran Vdout1_16ck91 AVG v(dout1_16) FROM=1139.9n TO=1140.1n

.meas tran Vdout1_17ck91 AVG v(dout1_17) FROM=1139.9n TO=1140.1n

.meas tran Vdout1_18ck91 AVG v(dout1_18) FROM=1139.9n TO=1140.1n

.meas tran Vdout1_19ck91 AVG v(dout1_19) FROM=1139.9n TO=1140.1n

.meas tran Vdout1_20ck91 AVG v(dout1_20) FROM=1139.9n TO=1140.1n

.meas tran Vdout1_21ck91 AVG v(dout1_21) FROM=1139.9n TO=1140.1n

.meas tran Vdout1_22ck91 AVG v(dout1_22) FROM=1139.9n TO=1140.1n

.meas tran Vdout1_23ck91 AVG v(dout1_23) FROM=1139.9n TO=1140.1n

.meas tran Vdout1_24ck91 AVG v(dout1_24) FROM=1139.9n TO=1140.1n

.meas tran Vdout1_25ck91 AVG v(dout1_25) FROM=1139.9n TO=1140.1n

.meas tran Vdout1_26ck91 AVG v(dout1_26) FROM=1139.9n TO=1140.1n

.meas tran Vdout1_27ck91 AVG v(dout1_27) FROM=1139.9n TO=1140.1n

.meas tran Vdout1_28ck91 AVG v(dout1_28) FROM=1139.9n TO=1140.1n

.meas tran Vdout1_29ck91 AVG v(dout1_29) FROM=1139.9n TO=1140.1n

.meas tran Vdout1_30ck91 AVG v(dout1_30) FROM=1139.9n TO=1140.1n

.meas tran Vdout1_31ck91 AVG v(dout1_31) FROM=1139.9n TO=1140.1n

.meas tran Vdout1_32ck91 AVG v(dout1_32) FROM=1139.9n TO=1140.1n

.meas tran Vdout1_33ck91 AVG v(dout1_33) FROM=1139.9n TO=1140.1n

.meas tran Vdout1_34ck91 AVG v(dout1_34) FROM=1139.9n TO=1140.1n

.meas tran Vdout1_35ck91 AVG v(dout1_35) FROM=1139.9n TO=1140.1n

.meas tran Vdout1_36ck91 AVG v(dout1_36) FROM=1139.9n TO=1140.1n

.meas tran Vdout1_37ck91 AVG v(dout1_37) FROM=1139.9n TO=1140.1n

.meas tran Vdout1_38ck91 AVG v(dout1_38) FROM=1139.9n TO=1140.1n

.meas tran Vdout1_39ck91 AVG v(dout1_39) FROM=1139.9n TO=1140.1n

.meas tran Vdout1_40ck91 AVG v(dout1_40) FROM=1139.9n TO=1140.1n

.meas tran Vdout1_41ck91 AVG v(dout1_41) FROM=1139.9n TO=1140.1n

.meas tran Vdout1_42ck91 AVG v(dout1_42) FROM=1139.9n TO=1140.1n

.meas tran Vdout1_43ck91 AVG v(dout1_43) FROM=1139.9n TO=1140.1n

.meas tran Vdout1_44ck91 AVG v(dout1_44) FROM=1139.9n TO=1140.1n

.meas tran Vdout1_45ck91 AVG v(dout1_45) FROM=1139.9n TO=1140.1n

.meas tran Vdout1_46ck91 AVG v(dout1_46) FROM=1139.9n TO=1140.1n

.meas tran Vdout1_47ck91 AVG v(dout1_47) FROM=1139.9n TO=1140.1n

.meas tran Vdout1_48ck91 AVG v(dout1_48) FROM=1139.9n TO=1140.1n

.meas tran Vdout1_49ck91 AVG v(dout1_49) FROM=1139.9n TO=1140.1n

.meas tran Vdout1_50ck91 AVG v(dout1_50) FROM=1139.9n TO=1140.1n

.meas tran Vdout1_51ck91 AVG v(dout1_51) FROM=1139.9n TO=1140.1n

.meas tran Vdout1_52ck91 AVG v(dout1_52) FROM=1139.9n TO=1140.1n

.meas tran Vdout1_53ck91 AVG v(dout1_53) FROM=1139.9n TO=1140.1n

.meas tran Vdout1_54ck91 AVG v(dout1_54) FROM=1139.9n TO=1140.1n

.meas tran Vdout1_55ck91 AVG v(dout1_55) FROM=1139.9n TO=1140.1n

.meas tran Vdout1_56ck91 AVG v(dout1_56) FROM=1139.9n TO=1140.1n

.meas tran Vdout1_57ck91 AVG v(dout1_57) FROM=1139.9n TO=1140.1n

.meas tran Vdout1_58ck91 AVG v(dout1_58) FROM=1139.9n TO=1140.1n

.meas tran Vdout1_59ck91 AVG v(dout1_59) FROM=1139.9n TO=1140.1n

.meas tran Vdout1_60ck91 AVG v(dout1_60) FROM=1139.9n TO=1140.1n

.meas tran Vdout1_61ck91 AVG v(dout1_61) FROM=1139.9n TO=1140.1n

.meas tran Vdout1_62ck91 AVG v(dout1_62) FROM=1139.9n TO=1140.1n

.meas tran Vdout1_63ck91 AVG v(dout1_63) FROM=1139.9n TO=1140.1n

.meas tran Vdout1_64ck91 AVG v(dout1_64) FROM=1139.9n TO=1140.1n

.meas tran Vdout1_65ck91 AVG v(dout1_65) FROM=1139.9n TO=1140.1n

.meas tran Vdout1_66ck91 AVG v(dout1_66) FROM=1139.9n TO=1140.1n

.meas tran Vdout1_67ck91 AVG v(dout1_67) FROM=1139.9n TO=1140.1n

.meas tran Vdout1_68ck91 AVG v(dout1_68) FROM=1139.9n TO=1140.1n

.meas tran Vdout1_69ck91 AVG v(dout1_69) FROM=1139.9n TO=1140.1n

.meas tran Vdout1_70ck91 AVG v(dout1_70) FROM=1139.9n TO=1140.1n

.meas tran Vdout1_71ck91 AVG v(dout1_71) FROM=1139.9n TO=1140.1n

.meas tran Vdout1_72ck91 AVG v(dout1_72) FROM=1139.9n TO=1140.1n

.meas tran Vdout1_73ck91 AVG v(dout1_73) FROM=1139.9n TO=1140.1n

.meas tran Vdout1_74ck91 AVG v(dout1_74) FROM=1139.9n TO=1140.1n

.meas tran Vdout1_75ck91 AVG v(dout1_75) FROM=1139.9n TO=1140.1n

.meas tran Vdout1_76ck91 AVG v(dout1_76) FROM=1139.9n TO=1140.1n

.meas tran Vdout1_77ck91 AVG v(dout1_77) FROM=1139.9n TO=1140.1n

.meas tran Vdout1_78ck91 AVG v(dout1_78) FROM=1139.9n TO=1140.1n

.meas tran Vdout1_79ck91 AVG v(dout1_79) FROM=1139.9n TO=1140.1n

.meas tran Vdout0_0ck92 AVG v(dout0_0) FROM=1149.9n TO=1150.1n

.meas tran Vdout0_1ck92 AVG v(dout0_1) FROM=1149.9n TO=1150.1n

.meas tran Vdout0_2ck92 AVG v(dout0_2) FROM=1149.9n TO=1150.1n

.meas tran Vdout0_3ck92 AVG v(dout0_3) FROM=1149.9n TO=1150.1n

.meas tran Vdout0_4ck92 AVG v(dout0_4) FROM=1149.9n TO=1150.1n

.meas tran Vdout0_5ck92 AVG v(dout0_5) FROM=1149.9n TO=1150.1n

.meas tran Vdout0_6ck92 AVG v(dout0_6) FROM=1149.9n TO=1150.1n

.meas tran Vdout0_7ck92 AVG v(dout0_7) FROM=1149.9n TO=1150.1n

.meas tran Vdout0_8ck92 AVG v(dout0_8) FROM=1149.9n TO=1150.1n

.meas tran Vdout0_9ck92 AVG v(dout0_9) FROM=1149.9n TO=1150.1n

.meas tran Vdout0_10ck92 AVG v(dout0_10) FROM=1149.9n TO=1150.1n

.meas tran Vdout0_11ck92 AVG v(dout0_11) FROM=1149.9n TO=1150.1n

.meas tran Vdout0_12ck92 AVG v(dout0_12) FROM=1149.9n TO=1150.1n

.meas tran Vdout0_13ck92 AVG v(dout0_13) FROM=1149.9n TO=1150.1n

.meas tran Vdout0_14ck92 AVG v(dout0_14) FROM=1149.9n TO=1150.1n

.meas tran Vdout0_15ck92 AVG v(dout0_15) FROM=1149.9n TO=1150.1n

.meas tran Vdout0_16ck92 AVG v(dout0_16) FROM=1149.9n TO=1150.1n

.meas tran Vdout0_17ck92 AVG v(dout0_17) FROM=1149.9n TO=1150.1n

.meas tran Vdout0_18ck92 AVG v(dout0_18) FROM=1149.9n TO=1150.1n

.meas tran Vdout0_19ck92 AVG v(dout0_19) FROM=1149.9n TO=1150.1n

.meas tran Vdout0_20ck92 AVG v(dout0_20) FROM=1149.9n TO=1150.1n

.meas tran Vdout0_21ck92 AVG v(dout0_21) FROM=1149.9n TO=1150.1n

.meas tran Vdout0_22ck92 AVG v(dout0_22) FROM=1149.9n TO=1150.1n

.meas tran Vdout0_23ck92 AVG v(dout0_23) FROM=1149.9n TO=1150.1n

.meas tran Vdout0_24ck92 AVG v(dout0_24) FROM=1149.9n TO=1150.1n

.meas tran Vdout0_25ck92 AVG v(dout0_25) FROM=1149.9n TO=1150.1n

.meas tran Vdout0_26ck92 AVG v(dout0_26) FROM=1149.9n TO=1150.1n

.meas tran Vdout0_27ck92 AVG v(dout0_27) FROM=1149.9n TO=1150.1n

.meas tran Vdout0_28ck92 AVG v(dout0_28) FROM=1149.9n TO=1150.1n

.meas tran Vdout0_29ck92 AVG v(dout0_29) FROM=1149.9n TO=1150.1n

.meas tran Vdout0_30ck92 AVG v(dout0_30) FROM=1149.9n TO=1150.1n

.meas tran Vdout0_31ck92 AVG v(dout0_31) FROM=1149.9n TO=1150.1n

.meas tran Vdout0_32ck92 AVG v(dout0_32) FROM=1149.9n TO=1150.1n

.meas tran Vdout0_33ck92 AVG v(dout0_33) FROM=1149.9n TO=1150.1n

.meas tran Vdout0_34ck92 AVG v(dout0_34) FROM=1149.9n TO=1150.1n

.meas tran Vdout0_35ck92 AVG v(dout0_35) FROM=1149.9n TO=1150.1n

.meas tran Vdout0_36ck92 AVG v(dout0_36) FROM=1149.9n TO=1150.1n

.meas tran Vdout0_37ck92 AVG v(dout0_37) FROM=1149.9n TO=1150.1n

.meas tran Vdout0_38ck92 AVG v(dout0_38) FROM=1149.9n TO=1150.1n

.meas tran Vdout0_39ck92 AVG v(dout0_39) FROM=1149.9n TO=1150.1n

.meas tran Vdout0_40ck92 AVG v(dout0_40) FROM=1149.9n TO=1150.1n

.meas tran Vdout0_41ck92 AVG v(dout0_41) FROM=1149.9n TO=1150.1n

.meas tran Vdout0_42ck92 AVG v(dout0_42) FROM=1149.9n TO=1150.1n

.meas tran Vdout0_43ck92 AVG v(dout0_43) FROM=1149.9n TO=1150.1n

.meas tran Vdout0_44ck92 AVG v(dout0_44) FROM=1149.9n TO=1150.1n

.meas tran Vdout0_45ck92 AVG v(dout0_45) FROM=1149.9n TO=1150.1n

.meas tran Vdout0_46ck92 AVG v(dout0_46) FROM=1149.9n TO=1150.1n

.meas tran Vdout0_47ck92 AVG v(dout0_47) FROM=1149.9n TO=1150.1n

.meas tran Vdout0_48ck92 AVG v(dout0_48) FROM=1149.9n TO=1150.1n

.meas tran Vdout0_49ck92 AVG v(dout0_49) FROM=1149.9n TO=1150.1n

.meas tran Vdout0_50ck92 AVG v(dout0_50) FROM=1149.9n TO=1150.1n

.meas tran Vdout0_51ck92 AVG v(dout0_51) FROM=1149.9n TO=1150.1n

.meas tran Vdout0_52ck92 AVG v(dout0_52) FROM=1149.9n TO=1150.1n

.meas tran Vdout0_53ck92 AVG v(dout0_53) FROM=1149.9n TO=1150.1n

.meas tran Vdout0_54ck92 AVG v(dout0_54) FROM=1149.9n TO=1150.1n

.meas tran Vdout0_55ck92 AVG v(dout0_55) FROM=1149.9n TO=1150.1n

.meas tran Vdout0_56ck92 AVG v(dout0_56) FROM=1149.9n TO=1150.1n

.meas tran Vdout0_57ck92 AVG v(dout0_57) FROM=1149.9n TO=1150.1n

.meas tran Vdout0_58ck92 AVG v(dout0_58) FROM=1149.9n TO=1150.1n

.meas tran Vdout0_59ck92 AVG v(dout0_59) FROM=1149.9n TO=1150.1n

.meas tran Vdout0_60ck92 AVG v(dout0_60) FROM=1149.9n TO=1150.1n

.meas tran Vdout0_61ck92 AVG v(dout0_61) FROM=1149.9n TO=1150.1n

.meas tran Vdout0_62ck92 AVG v(dout0_62) FROM=1149.9n TO=1150.1n

.meas tran Vdout0_63ck92 AVG v(dout0_63) FROM=1149.9n TO=1150.1n

.meas tran Vdout0_64ck92 AVG v(dout0_64) FROM=1149.9n TO=1150.1n

.meas tran Vdout0_65ck92 AVG v(dout0_65) FROM=1149.9n TO=1150.1n

.meas tran Vdout0_66ck92 AVG v(dout0_66) FROM=1149.9n TO=1150.1n

.meas tran Vdout0_67ck92 AVG v(dout0_67) FROM=1149.9n TO=1150.1n

.meas tran Vdout0_68ck92 AVG v(dout0_68) FROM=1149.9n TO=1150.1n

.meas tran Vdout0_69ck92 AVG v(dout0_69) FROM=1149.9n TO=1150.1n

.meas tran Vdout0_70ck92 AVG v(dout0_70) FROM=1149.9n TO=1150.1n

.meas tran Vdout0_71ck92 AVG v(dout0_71) FROM=1149.9n TO=1150.1n

.meas tran Vdout0_72ck92 AVG v(dout0_72) FROM=1149.9n TO=1150.1n

.meas tran Vdout0_73ck92 AVG v(dout0_73) FROM=1149.9n TO=1150.1n

.meas tran Vdout0_74ck92 AVG v(dout0_74) FROM=1149.9n TO=1150.1n

.meas tran Vdout0_75ck92 AVG v(dout0_75) FROM=1149.9n TO=1150.1n

.meas tran Vdout0_76ck92 AVG v(dout0_76) FROM=1149.9n TO=1150.1n

.meas tran Vdout0_77ck92 AVG v(dout0_77) FROM=1149.9n TO=1150.1n

.meas tran Vdout0_78ck92 AVG v(dout0_78) FROM=1149.9n TO=1150.1n

.meas tran Vdout0_79ck92 AVG v(dout0_79) FROM=1149.9n TO=1150.1n

.meas tran Vdout1_0ck93 AVG v(dout1_0) FROM=1149.9n TO=1150.1n

.meas tran Vdout1_1ck93 AVG v(dout1_1) FROM=1149.9n TO=1150.1n

.meas tran Vdout1_2ck93 AVG v(dout1_2) FROM=1149.9n TO=1150.1n

.meas tran Vdout1_3ck93 AVG v(dout1_3) FROM=1149.9n TO=1150.1n

.meas tran Vdout1_4ck93 AVG v(dout1_4) FROM=1149.9n TO=1150.1n

.meas tran Vdout1_5ck93 AVG v(dout1_5) FROM=1149.9n TO=1150.1n

.meas tran Vdout1_6ck93 AVG v(dout1_6) FROM=1149.9n TO=1150.1n

.meas tran Vdout1_7ck93 AVG v(dout1_7) FROM=1149.9n TO=1150.1n

.meas tran Vdout1_8ck93 AVG v(dout1_8) FROM=1149.9n TO=1150.1n

.meas tran Vdout1_9ck93 AVG v(dout1_9) FROM=1149.9n TO=1150.1n

.meas tran Vdout1_10ck93 AVG v(dout1_10) FROM=1149.9n TO=1150.1n

.meas tran Vdout1_11ck93 AVG v(dout1_11) FROM=1149.9n TO=1150.1n

.meas tran Vdout1_12ck93 AVG v(dout1_12) FROM=1149.9n TO=1150.1n

.meas tran Vdout1_13ck93 AVG v(dout1_13) FROM=1149.9n TO=1150.1n

.meas tran Vdout1_14ck93 AVG v(dout1_14) FROM=1149.9n TO=1150.1n

.meas tran Vdout1_15ck93 AVG v(dout1_15) FROM=1149.9n TO=1150.1n

.meas tran Vdout1_16ck93 AVG v(dout1_16) FROM=1149.9n TO=1150.1n

.meas tran Vdout1_17ck93 AVG v(dout1_17) FROM=1149.9n TO=1150.1n

.meas tran Vdout1_18ck93 AVG v(dout1_18) FROM=1149.9n TO=1150.1n

.meas tran Vdout1_19ck93 AVG v(dout1_19) FROM=1149.9n TO=1150.1n

.meas tran Vdout1_20ck93 AVG v(dout1_20) FROM=1149.9n TO=1150.1n

.meas tran Vdout1_21ck93 AVG v(dout1_21) FROM=1149.9n TO=1150.1n

.meas tran Vdout1_22ck93 AVG v(dout1_22) FROM=1149.9n TO=1150.1n

.meas tran Vdout1_23ck93 AVG v(dout1_23) FROM=1149.9n TO=1150.1n

.meas tran Vdout1_24ck93 AVG v(dout1_24) FROM=1149.9n TO=1150.1n

.meas tran Vdout1_25ck93 AVG v(dout1_25) FROM=1149.9n TO=1150.1n

.meas tran Vdout1_26ck93 AVG v(dout1_26) FROM=1149.9n TO=1150.1n

.meas tran Vdout1_27ck93 AVG v(dout1_27) FROM=1149.9n TO=1150.1n

.meas tran Vdout1_28ck93 AVG v(dout1_28) FROM=1149.9n TO=1150.1n

.meas tran Vdout1_29ck93 AVG v(dout1_29) FROM=1149.9n TO=1150.1n

.meas tran Vdout1_30ck93 AVG v(dout1_30) FROM=1149.9n TO=1150.1n

.meas tran Vdout1_31ck93 AVG v(dout1_31) FROM=1149.9n TO=1150.1n

.meas tran Vdout1_32ck93 AVG v(dout1_32) FROM=1149.9n TO=1150.1n

.meas tran Vdout1_33ck93 AVG v(dout1_33) FROM=1149.9n TO=1150.1n

.meas tran Vdout1_34ck93 AVG v(dout1_34) FROM=1149.9n TO=1150.1n

.meas tran Vdout1_35ck93 AVG v(dout1_35) FROM=1149.9n TO=1150.1n

.meas tran Vdout1_36ck93 AVG v(dout1_36) FROM=1149.9n TO=1150.1n

.meas tran Vdout1_37ck93 AVG v(dout1_37) FROM=1149.9n TO=1150.1n

.meas tran Vdout1_38ck93 AVG v(dout1_38) FROM=1149.9n TO=1150.1n

.meas tran Vdout1_39ck93 AVG v(dout1_39) FROM=1149.9n TO=1150.1n

.meas tran Vdout1_40ck93 AVG v(dout1_40) FROM=1149.9n TO=1150.1n

.meas tran Vdout1_41ck93 AVG v(dout1_41) FROM=1149.9n TO=1150.1n

.meas tran Vdout1_42ck93 AVG v(dout1_42) FROM=1149.9n TO=1150.1n

.meas tran Vdout1_43ck93 AVG v(dout1_43) FROM=1149.9n TO=1150.1n

.meas tran Vdout1_44ck93 AVG v(dout1_44) FROM=1149.9n TO=1150.1n

.meas tran Vdout1_45ck93 AVG v(dout1_45) FROM=1149.9n TO=1150.1n

.meas tran Vdout1_46ck93 AVG v(dout1_46) FROM=1149.9n TO=1150.1n

.meas tran Vdout1_47ck93 AVG v(dout1_47) FROM=1149.9n TO=1150.1n

.meas tran Vdout1_48ck93 AVG v(dout1_48) FROM=1149.9n TO=1150.1n

.meas tran Vdout1_49ck93 AVG v(dout1_49) FROM=1149.9n TO=1150.1n

.meas tran Vdout1_50ck93 AVG v(dout1_50) FROM=1149.9n TO=1150.1n

.meas tran Vdout1_51ck93 AVG v(dout1_51) FROM=1149.9n TO=1150.1n

.meas tran Vdout1_52ck93 AVG v(dout1_52) FROM=1149.9n TO=1150.1n

.meas tran Vdout1_53ck93 AVG v(dout1_53) FROM=1149.9n TO=1150.1n

.meas tran Vdout1_54ck93 AVG v(dout1_54) FROM=1149.9n TO=1150.1n

.meas tran Vdout1_55ck93 AVG v(dout1_55) FROM=1149.9n TO=1150.1n

.meas tran Vdout1_56ck93 AVG v(dout1_56) FROM=1149.9n TO=1150.1n

.meas tran Vdout1_57ck93 AVG v(dout1_57) FROM=1149.9n TO=1150.1n

.meas tran Vdout1_58ck93 AVG v(dout1_58) FROM=1149.9n TO=1150.1n

.meas tran Vdout1_59ck93 AVG v(dout1_59) FROM=1149.9n TO=1150.1n

.meas tran Vdout1_60ck93 AVG v(dout1_60) FROM=1149.9n TO=1150.1n

.meas tran Vdout1_61ck93 AVG v(dout1_61) FROM=1149.9n TO=1150.1n

.meas tran Vdout1_62ck93 AVG v(dout1_62) FROM=1149.9n TO=1150.1n

.meas tran Vdout1_63ck93 AVG v(dout1_63) FROM=1149.9n TO=1150.1n

.meas tran Vdout1_64ck93 AVG v(dout1_64) FROM=1149.9n TO=1150.1n

.meas tran Vdout1_65ck93 AVG v(dout1_65) FROM=1149.9n TO=1150.1n

.meas tran Vdout1_66ck93 AVG v(dout1_66) FROM=1149.9n TO=1150.1n

.meas tran Vdout1_67ck93 AVG v(dout1_67) FROM=1149.9n TO=1150.1n

.meas tran Vdout1_68ck93 AVG v(dout1_68) FROM=1149.9n TO=1150.1n

.meas tran Vdout1_69ck93 AVG v(dout1_69) FROM=1149.9n TO=1150.1n

.meas tran Vdout1_70ck93 AVG v(dout1_70) FROM=1149.9n TO=1150.1n

.meas tran Vdout1_71ck93 AVG v(dout1_71) FROM=1149.9n TO=1150.1n

.meas tran Vdout1_72ck93 AVG v(dout1_72) FROM=1149.9n TO=1150.1n

.meas tran Vdout1_73ck93 AVG v(dout1_73) FROM=1149.9n TO=1150.1n

.meas tran Vdout1_74ck93 AVG v(dout1_74) FROM=1149.9n TO=1150.1n

.meas tran Vdout1_75ck93 AVG v(dout1_75) FROM=1149.9n TO=1150.1n

.meas tran Vdout1_76ck93 AVG v(dout1_76) FROM=1149.9n TO=1150.1n

.meas tran Vdout1_77ck93 AVG v(dout1_77) FROM=1149.9n TO=1150.1n

.meas tran Vdout1_78ck93 AVG v(dout1_78) FROM=1149.9n TO=1150.1n

.meas tran Vdout1_79ck93 AVG v(dout1_79) FROM=1149.9n TO=1150.1n

.meas tran Vdout1_0ck94 AVG v(dout1_0) FROM=1159.9n TO=1160.1n

.meas tran Vdout1_1ck94 AVG v(dout1_1) FROM=1159.9n TO=1160.1n

.meas tran Vdout1_2ck94 AVG v(dout1_2) FROM=1159.9n TO=1160.1n

.meas tran Vdout1_3ck94 AVG v(dout1_3) FROM=1159.9n TO=1160.1n

.meas tran Vdout1_4ck94 AVG v(dout1_4) FROM=1159.9n TO=1160.1n

.meas tran Vdout1_5ck94 AVG v(dout1_5) FROM=1159.9n TO=1160.1n

.meas tran Vdout1_6ck94 AVG v(dout1_6) FROM=1159.9n TO=1160.1n

.meas tran Vdout1_7ck94 AVG v(dout1_7) FROM=1159.9n TO=1160.1n

.meas tran Vdout1_8ck94 AVG v(dout1_8) FROM=1159.9n TO=1160.1n

.meas tran Vdout1_9ck94 AVG v(dout1_9) FROM=1159.9n TO=1160.1n

.meas tran Vdout1_10ck94 AVG v(dout1_10) FROM=1159.9n TO=1160.1n

.meas tran Vdout1_11ck94 AVG v(dout1_11) FROM=1159.9n TO=1160.1n

.meas tran Vdout1_12ck94 AVG v(dout1_12) FROM=1159.9n TO=1160.1n

.meas tran Vdout1_13ck94 AVG v(dout1_13) FROM=1159.9n TO=1160.1n

.meas tran Vdout1_14ck94 AVG v(dout1_14) FROM=1159.9n TO=1160.1n

.meas tran Vdout1_15ck94 AVG v(dout1_15) FROM=1159.9n TO=1160.1n

.meas tran Vdout1_16ck94 AVG v(dout1_16) FROM=1159.9n TO=1160.1n

.meas tran Vdout1_17ck94 AVG v(dout1_17) FROM=1159.9n TO=1160.1n

.meas tran Vdout1_18ck94 AVG v(dout1_18) FROM=1159.9n TO=1160.1n

.meas tran Vdout1_19ck94 AVG v(dout1_19) FROM=1159.9n TO=1160.1n

.meas tran Vdout1_20ck94 AVG v(dout1_20) FROM=1159.9n TO=1160.1n

.meas tran Vdout1_21ck94 AVG v(dout1_21) FROM=1159.9n TO=1160.1n

.meas tran Vdout1_22ck94 AVG v(dout1_22) FROM=1159.9n TO=1160.1n

.meas tran Vdout1_23ck94 AVG v(dout1_23) FROM=1159.9n TO=1160.1n

.meas tran Vdout1_24ck94 AVG v(dout1_24) FROM=1159.9n TO=1160.1n

.meas tran Vdout1_25ck94 AVG v(dout1_25) FROM=1159.9n TO=1160.1n

.meas tran Vdout1_26ck94 AVG v(dout1_26) FROM=1159.9n TO=1160.1n

.meas tran Vdout1_27ck94 AVG v(dout1_27) FROM=1159.9n TO=1160.1n

.meas tran Vdout1_28ck94 AVG v(dout1_28) FROM=1159.9n TO=1160.1n

.meas tran Vdout1_29ck94 AVG v(dout1_29) FROM=1159.9n TO=1160.1n

.meas tran Vdout1_30ck94 AVG v(dout1_30) FROM=1159.9n TO=1160.1n

.meas tran Vdout1_31ck94 AVG v(dout1_31) FROM=1159.9n TO=1160.1n

.meas tran Vdout1_32ck94 AVG v(dout1_32) FROM=1159.9n TO=1160.1n

.meas tran Vdout1_33ck94 AVG v(dout1_33) FROM=1159.9n TO=1160.1n

.meas tran Vdout1_34ck94 AVG v(dout1_34) FROM=1159.9n TO=1160.1n

.meas tran Vdout1_35ck94 AVG v(dout1_35) FROM=1159.9n TO=1160.1n

.meas tran Vdout1_36ck94 AVG v(dout1_36) FROM=1159.9n TO=1160.1n

.meas tran Vdout1_37ck94 AVG v(dout1_37) FROM=1159.9n TO=1160.1n

.meas tran Vdout1_38ck94 AVG v(dout1_38) FROM=1159.9n TO=1160.1n

.meas tran Vdout1_39ck94 AVG v(dout1_39) FROM=1159.9n TO=1160.1n

.meas tran Vdout1_40ck94 AVG v(dout1_40) FROM=1159.9n TO=1160.1n

.meas tran Vdout1_41ck94 AVG v(dout1_41) FROM=1159.9n TO=1160.1n

.meas tran Vdout1_42ck94 AVG v(dout1_42) FROM=1159.9n TO=1160.1n

.meas tran Vdout1_43ck94 AVG v(dout1_43) FROM=1159.9n TO=1160.1n

.meas tran Vdout1_44ck94 AVG v(dout1_44) FROM=1159.9n TO=1160.1n

.meas tran Vdout1_45ck94 AVG v(dout1_45) FROM=1159.9n TO=1160.1n

.meas tran Vdout1_46ck94 AVG v(dout1_46) FROM=1159.9n TO=1160.1n

.meas tran Vdout1_47ck94 AVG v(dout1_47) FROM=1159.9n TO=1160.1n

.meas tran Vdout1_48ck94 AVG v(dout1_48) FROM=1159.9n TO=1160.1n

.meas tran Vdout1_49ck94 AVG v(dout1_49) FROM=1159.9n TO=1160.1n

.meas tran Vdout1_50ck94 AVG v(dout1_50) FROM=1159.9n TO=1160.1n

.meas tran Vdout1_51ck94 AVG v(dout1_51) FROM=1159.9n TO=1160.1n

.meas tran Vdout1_52ck94 AVG v(dout1_52) FROM=1159.9n TO=1160.1n

.meas tran Vdout1_53ck94 AVG v(dout1_53) FROM=1159.9n TO=1160.1n

.meas tran Vdout1_54ck94 AVG v(dout1_54) FROM=1159.9n TO=1160.1n

.meas tran Vdout1_55ck94 AVG v(dout1_55) FROM=1159.9n TO=1160.1n

.meas tran Vdout1_56ck94 AVG v(dout1_56) FROM=1159.9n TO=1160.1n

.meas tran Vdout1_57ck94 AVG v(dout1_57) FROM=1159.9n TO=1160.1n

.meas tran Vdout1_58ck94 AVG v(dout1_58) FROM=1159.9n TO=1160.1n

.meas tran Vdout1_59ck94 AVG v(dout1_59) FROM=1159.9n TO=1160.1n

.meas tran Vdout1_60ck94 AVG v(dout1_60) FROM=1159.9n TO=1160.1n

.meas tran Vdout1_61ck94 AVG v(dout1_61) FROM=1159.9n TO=1160.1n

.meas tran Vdout1_62ck94 AVG v(dout1_62) FROM=1159.9n TO=1160.1n

.meas tran Vdout1_63ck94 AVG v(dout1_63) FROM=1159.9n TO=1160.1n

.meas tran Vdout1_64ck94 AVG v(dout1_64) FROM=1159.9n TO=1160.1n

.meas tran Vdout1_65ck94 AVG v(dout1_65) FROM=1159.9n TO=1160.1n

.meas tran Vdout1_66ck94 AVG v(dout1_66) FROM=1159.9n TO=1160.1n

.meas tran Vdout1_67ck94 AVG v(dout1_67) FROM=1159.9n TO=1160.1n

.meas tran Vdout1_68ck94 AVG v(dout1_68) FROM=1159.9n TO=1160.1n

.meas tran Vdout1_69ck94 AVG v(dout1_69) FROM=1159.9n TO=1160.1n

.meas tran Vdout1_70ck94 AVG v(dout1_70) FROM=1159.9n TO=1160.1n

.meas tran Vdout1_71ck94 AVG v(dout1_71) FROM=1159.9n TO=1160.1n

.meas tran Vdout1_72ck94 AVG v(dout1_72) FROM=1159.9n TO=1160.1n

.meas tran Vdout1_73ck94 AVG v(dout1_73) FROM=1159.9n TO=1160.1n

.meas tran Vdout1_74ck94 AVG v(dout1_74) FROM=1159.9n TO=1160.1n

.meas tran Vdout1_75ck94 AVG v(dout1_75) FROM=1159.9n TO=1160.1n

.meas tran Vdout1_76ck94 AVG v(dout1_76) FROM=1159.9n TO=1160.1n

.meas tran Vdout1_77ck94 AVG v(dout1_77) FROM=1159.9n TO=1160.1n

.meas tran Vdout1_78ck94 AVG v(dout1_78) FROM=1159.9n TO=1160.1n

.meas tran Vdout1_79ck94 AVG v(dout1_79) FROM=1159.9n TO=1160.1n

.meas tran Vdout1_0ck95 AVG v(dout1_0) FROM=1179.9n TO=1180.1n

.meas tran Vdout1_1ck95 AVG v(dout1_1) FROM=1179.9n TO=1180.1n

.meas tran Vdout1_2ck95 AVG v(dout1_2) FROM=1179.9n TO=1180.1n

.meas tran Vdout1_3ck95 AVG v(dout1_3) FROM=1179.9n TO=1180.1n

.meas tran Vdout1_4ck95 AVG v(dout1_4) FROM=1179.9n TO=1180.1n

.meas tran Vdout1_5ck95 AVG v(dout1_5) FROM=1179.9n TO=1180.1n

.meas tran Vdout1_6ck95 AVG v(dout1_6) FROM=1179.9n TO=1180.1n

.meas tran Vdout1_7ck95 AVG v(dout1_7) FROM=1179.9n TO=1180.1n

.meas tran Vdout1_8ck95 AVG v(dout1_8) FROM=1179.9n TO=1180.1n

.meas tran Vdout1_9ck95 AVG v(dout1_9) FROM=1179.9n TO=1180.1n

.meas tran Vdout1_10ck95 AVG v(dout1_10) FROM=1179.9n TO=1180.1n

.meas tran Vdout1_11ck95 AVG v(dout1_11) FROM=1179.9n TO=1180.1n

.meas tran Vdout1_12ck95 AVG v(dout1_12) FROM=1179.9n TO=1180.1n

.meas tran Vdout1_13ck95 AVG v(dout1_13) FROM=1179.9n TO=1180.1n

.meas tran Vdout1_14ck95 AVG v(dout1_14) FROM=1179.9n TO=1180.1n

.meas tran Vdout1_15ck95 AVG v(dout1_15) FROM=1179.9n TO=1180.1n

.meas tran Vdout1_16ck95 AVG v(dout1_16) FROM=1179.9n TO=1180.1n

.meas tran Vdout1_17ck95 AVG v(dout1_17) FROM=1179.9n TO=1180.1n

.meas tran Vdout1_18ck95 AVG v(dout1_18) FROM=1179.9n TO=1180.1n

.meas tran Vdout1_19ck95 AVG v(dout1_19) FROM=1179.9n TO=1180.1n

.meas tran Vdout1_20ck95 AVG v(dout1_20) FROM=1179.9n TO=1180.1n

.meas tran Vdout1_21ck95 AVG v(dout1_21) FROM=1179.9n TO=1180.1n

.meas tran Vdout1_22ck95 AVG v(dout1_22) FROM=1179.9n TO=1180.1n

.meas tran Vdout1_23ck95 AVG v(dout1_23) FROM=1179.9n TO=1180.1n

.meas tran Vdout1_24ck95 AVG v(dout1_24) FROM=1179.9n TO=1180.1n

.meas tran Vdout1_25ck95 AVG v(dout1_25) FROM=1179.9n TO=1180.1n

.meas tran Vdout1_26ck95 AVG v(dout1_26) FROM=1179.9n TO=1180.1n

.meas tran Vdout1_27ck95 AVG v(dout1_27) FROM=1179.9n TO=1180.1n

.meas tran Vdout1_28ck95 AVG v(dout1_28) FROM=1179.9n TO=1180.1n

.meas tran Vdout1_29ck95 AVG v(dout1_29) FROM=1179.9n TO=1180.1n

.meas tran Vdout1_30ck95 AVG v(dout1_30) FROM=1179.9n TO=1180.1n

.meas tran Vdout1_31ck95 AVG v(dout1_31) FROM=1179.9n TO=1180.1n

.meas tran Vdout1_32ck95 AVG v(dout1_32) FROM=1179.9n TO=1180.1n

.meas tran Vdout1_33ck95 AVG v(dout1_33) FROM=1179.9n TO=1180.1n

.meas tran Vdout1_34ck95 AVG v(dout1_34) FROM=1179.9n TO=1180.1n

.meas tran Vdout1_35ck95 AVG v(dout1_35) FROM=1179.9n TO=1180.1n

.meas tran Vdout1_36ck95 AVG v(dout1_36) FROM=1179.9n TO=1180.1n

.meas tran Vdout1_37ck95 AVG v(dout1_37) FROM=1179.9n TO=1180.1n

.meas tran Vdout1_38ck95 AVG v(dout1_38) FROM=1179.9n TO=1180.1n

.meas tran Vdout1_39ck95 AVG v(dout1_39) FROM=1179.9n TO=1180.1n

.meas tran Vdout1_40ck95 AVG v(dout1_40) FROM=1179.9n TO=1180.1n

.meas tran Vdout1_41ck95 AVG v(dout1_41) FROM=1179.9n TO=1180.1n

.meas tran Vdout1_42ck95 AVG v(dout1_42) FROM=1179.9n TO=1180.1n

.meas tran Vdout1_43ck95 AVG v(dout1_43) FROM=1179.9n TO=1180.1n

.meas tran Vdout1_44ck95 AVG v(dout1_44) FROM=1179.9n TO=1180.1n

.meas tran Vdout1_45ck95 AVG v(dout1_45) FROM=1179.9n TO=1180.1n

.meas tran Vdout1_46ck95 AVG v(dout1_46) FROM=1179.9n TO=1180.1n

.meas tran Vdout1_47ck95 AVG v(dout1_47) FROM=1179.9n TO=1180.1n

.meas tran Vdout1_48ck95 AVG v(dout1_48) FROM=1179.9n TO=1180.1n

.meas tran Vdout1_49ck95 AVG v(dout1_49) FROM=1179.9n TO=1180.1n

.meas tran Vdout1_50ck95 AVG v(dout1_50) FROM=1179.9n TO=1180.1n

.meas tran Vdout1_51ck95 AVG v(dout1_51) FROM=1179.9n TO=1180.1n

.meas tran Vdout1_52ck95 AVG v(dout1_52) FROM=1179.9n TO=1180.1n

.meas tran Vdout1_53ck95 AVG v(dout1_53) FROM=1179.9n TO=1180.1n

.meas tran Vdout1_54ck95 AVG v(dout1_54) FROM=1179.9n TO=1180.1n

.meas tran Vdout1_55ck95 AVG v(dout1_55) FROM=1179.9n TO=1180.1n

.meas tran Vdout1_56ck95 AVG v(dout1_56) FROM=1179.9n TO=1180.1n

.meas tran Vdout1_57ck95 AVG v(dout1_57) FROM=1179.9n TO=1180.1n

.meas tran Vdout1_58ck95 AVG v(dout1_58) FROM=1179.9n TO=1180.1n

.meas tran Vdout1_59ck95 AVG v(dout1_59) FROM=1179.9n TO=1180.1n

.meas tran Vdout1_60ck95 AVG v(dout1_60) FROM=1179.9n TO=1180.1n

.meas tran Vdout1_61ck95 AVG v(dout1_61) FROM=1179.9n TO=1180.1n

.meas tran Vdout1_62ck95 AVG v(dout1_62) FROM=1179.9n TO=1180.1n

.meas tran Vdout1_63ck95 AVG v(dout1_63) FROM=1179.9n TO=1180.1n

.meas tran Vdout1_64ck95 AVG v(dout1_64) FROM=1179.9n TO=1180.1n

.meas tran Vdout1_65ck95 AVG v(dout1_65) FROM=1179.9n TO=1180.1n

.meas tran Vdout1_66ck95 AVG v(dout1_66) FROM=1179.9n TO=1180.1n

.meas tran Vdout1_67ck95 AVG v(dout1_67) FROM=1179.9n TO=1180.1n

.meas tran Vdout1_68ck95 AVG v(dout1_68) FROM=1179.9n TO=1180.1n

.meas tran Vdout1_69ck95 AVG v(dout1_69) FROM=1179.9n TO=1180.1n

.meas tran Vdout1_70ck95 AVG v(dout1_70) FROM=1179.9n TO=1180.1n

.meas tran Vdout1_71ck95 AVG v(dout1_71) FROM=1179.9n TO=1180.1n

.meas tran Vdout1_72ck95 AVG v(dout1_72) FROM=1179.9n TO=1180.1n

.meas tran Vdout1_73ck95 AVG v(dout1_73) FROM=1179.9n TO=1180.1n

.meas tran Vdout1_74ck95 AVG v(dout1_74) FROM=1179.9n TO=1180.1n

.meas tran Vdout1_75ck95 AVG v(dout1_75) FROM=1179.9n TO=1180.1n

.meas tran Vdout1_76ck95 AVG v(dout1_76) FROM=1179.9n TO=1180.1n

.meas tran Vdout1_77ck95 AVG v(dout1_77) FROM=1179.9n TO=1180.1n

.meas tran Vdout1_78ck95 AVG v(dout1_78) FROM=1179.9n TO=1180.1n

.meas tran Vdout1_79ck95 AVG v(dout1_79) FROM=1179.9n TO=1180.1n

.meas tran Vdout1_0ck96 AVG v(dout1_0) FROM=1199.9n TO=1200.1n

.meas tran Vdout1_1ck96 AVG v(dout1_1) FROM=1199.9n TO=1200.1n

.meas tran Vdout1_2ck96 AVG v(dout1_2) FROM=1199.9n TO=1200.1n

.meas tran Vdout1_3ck96 AVG v(dout1_3) FROM=1199.9n TO=1200.1n

.meas tran Vdout1_4ck96 AVG v(dout1_4) FROM=1199.9n TO=1200.1n

.meas tran Vdout1_5ck96 AVG v(dout1_5) FROM=1199.9n TO=1200.1n

.meas tran Vdout1_6ck96 AVG v(dout1_6) FROM=1199.9n TO=1200.1n

.meas tran Vdout1_7ck96 AVG v(dout1_7) FROM=1199.9n TO=1200.1n

.meas tran Vdout1_8ck96 AVG v(dout1_8) FROM=1199.9n TO=1200.1n

.meas tran Vdout1_9ck96 AVG v(dout1_9) FROM=1199.9n TO=1200.1n

.meas tran Vdout1_10ck96 AVG v(dout1_10) FROM=1199.9n TO=1200.1n

.meas tran Vdout1_11ck96 AVG v(dout1_11) FROM=1199.9n TO=1200.1n

.meas tran Vdout1_12ck96 AVG v(dout1_12) FROM=1199.9n TO=1200.1n

.meas tran Vdout1_13ck96 AVG v(dout1_13) FROM=1199.9n TO=1200.1n

.meas tran Vdout1_14ck96 AVG v(dout1_14) FROM=1199.9n TO=1200.1n

.meas tran Vdout1_15ck96 AVG v(dout1_15) FROM=1199.9n TO=1200.1n

.meas tran Vdout1_16ck96 AVG v(dout1_16) FROM=1199.9n TO=1200.1n

.meas tran Vdout1_17ck96 AVG v(dout1_17) FROM=1199.9n TO=1200.1n

.meas tran Vdout1_18ck96 AVG v(dout1_18) FROM=1199.9n TO=1200.1n

.meas tran Vdout1_19ck96 AVG v(dout1_19) FROM=1199.9n TO=1200.1n

.meas tran Vdout1_20ck96 AVG v(dout1_20) FROM=1199.9n TO=1200.1n

.meas tran Vdout1_21ck96 AVG v(dout1_21) FROM=1199.9n TO=1200.1n

.meas tran Vdout1_22ck96 AVG v(dout1_22) FROM=1199.9n TO=1200.1n

.meas tran Vdout1_23ck96 AVG v(dout1_23) FROM=1199.9n TO=1200.1n

.meas tran Vdout1_24ck96 AVG v(dout1_24) FROM=1199.9n TO=1200.1n

.meas tran Vdout1_25ck96 AVG v(dout1_25) FROM=1199.9n TO=1200.1n

.meas tran Vdout1_26ck96 AVG v(dout1_26) FROM=1199.9n TO=1200.1n

.meas tran Vdout1_27ck96 AVG v(dout1_27) FROM=1199.9n TO=1200.1n

.meas tran Vdout1_28ck96 AVG v(dout1_28) FROM=1199.9n TO=1200.1n

.meas tran Vdout1_29ck96 AVG v(dout1_29) FROM=1199.9n TO=1200.1n

.meas tran Vdout1_30ck96 AVG v(dout1_30) FROM=1199.9n TO=1200.1n

.meas tran Vdout1_31ck96 AVG v(dout1_31) FROM=1199.9n TO=1200.1n

.meas tran Vdout1_32ck96 AVG v(dout1_32) FROM=1199.9n TO=1200.1n

.meas tran Vdout1_33ck96 AVG v(dout1_33) FROM=1199.9n TO=1200.1n

.meas tran Vdout1_34ck96 AVG v(dout1_34) FROM=1199.9n TO=1200.1n

.meas tran Vdout1_35ck96 AVG v(dout1_35) FROM=1199.9n TO=1200.1n

.meas tran Vdout1_36ck96 AVG v(dout1_36) FROM=1199.9n TO=1200.1n

.meas tran Vdout1_37ck96 AVG v(dout1_37) FROM=1199.9n TO=1200.1n

.meas tran Vdout1_38ck96 AVG v(dout1_38) FROM=1199.9n TO=1200.1n

.meas tran Vdout1_39ck96 AVG v(dout1_39) FROM=1199.9n TO=1200.1n

.meas tran Vdout1_40ck96 AVG v(dout1_40) FROM=1199.9n TO=1200.1n

.meas tran Vdout1_41ck96 AVG v(dout1_41) FROM=1199.9n TO=1200.1n

.meas tran Vdout1_42ck96 AVG v(dout1_42) FROM=1199.9n TO=1200.1n

.meas tran Vdout1_43ck96 AVG v(dout1_43) FROM=1199.9n TO=1200.1n

.meas tran Vdout1_44ck96 AVG v(dout1_44) FROM=1199.9n TO=1200.1n

.meas tran Vdout1_45ck96 AVG v(dout1_45) FROM=1199.9n TO=1200.1n

.meas tran Vdout1_46ck96 AVG v(dout1_46) FROM=1199.9n TO=1200.1n

.meas tran Vdout1_47ck96 AVG v(dout1_47) FROM=1199.9n TO=1200.1n

.meas tran Vdout1_48ck96 AVG v(dout1_48) FROM=1199.9n TO=1200.1n

.meas tran Vdout1_49ck96 AVG v(dout1_49) FROM=1199.9n TO=1200.1n

.meas tran Vdout1_50ck96 AVG v(dout1_50) FROM=1199.9n TO=1200.1n

.meas tran Vdout1_51ck96 AVG v(dout1_51) FROM=1199.9n TO=1200.1n

.meas tran Vdout1_52ck96 AVG v(dout1_52) FROM=1199.9n TO=1200.1n

.meas tran Vdout1_53ck96 AVG v(dout1_53) FROM=1199.9n TO=1200.1n

.meas tran Vdout1_54ck96 AVG v(dout1_54) FROM=1199.9n TO=1200.1n

.meas tran Vdout1_55ck96 AVG v(dout1_55) FROM=1199.9n TO=1200.1n

.meas tran Vdout1_56ck96 AVG v(dout1_56) FROM=1199.9n TO=1200.1n

.meas tran Vdout1_57ck96 AVG v(dout1_57) FROM=1199.9n TO=1200.1n

.meas tran Vdout1_58ck96 AVG v(dout1_58) FROM=1199.9n TO=1200.1n

.meas tran Vdout1_59ck96 AVG v(dout1_59) FROM=1199.9n TO=1200.1n

.meas tran Vdout1_60ck96 AVG v(dout1_60) FROM=1199.9n TO=1200.1n

.meas tran Vdout1_61ck96 AVG v(dout1_61) FROM=1199.9n TO=1200.1n

.meas tran Vdout1_62ck96 AVG v(dout1_62) FROM=1199.9n TO=1200.1n

.meas tran Vdout1_63ck96 AVG v(dout1_63) FROM=1199.9n TO=1200.1n

.meas tran Vdout1_64ck96 AVG v(dout1_64) FROM=1199.9n TO=1200.1n

.meas tran Vdout1_65ck96 AVG v(dout1_65) FROM=1199.9n TO=1200.1n

.meas tran Vdout1_66ck96 AVG v(dout1_66) FROM=1199.9n TO=1200.1n

.meas tran Vdout1_67ck96 AVG v(dout1_67) FROM=1199.9n TO=1200.1n

.meas tran Vdout1_68ck96 AVG v(dout1_68) FROM=1199.9n TO=1200.1n

.meas tran Vdout1_69ck96 AVG v(dout1_69) FROM=1199.9n TO=1200.1n

.meas tran Vdout1_70ck96 AVG v(dout1_70) FROM=1199.9n TO=1200.1n

.meas tran Vdout1_71ck96 AVG v(dout1_71) FROM=1199.9n TO=1200.1n

.meas tran Vdout1_72ck96 AVG v(dout1_72) FROM=1199.9n TO=1200.1n

.meas tran Vdout1_73ck96 AVG v(dout1_73) FROM=1199.9n TO=1200.1n

.meas tran Vdout1_74ck96 AVG v(dout1_74) FROM=1199.9n TO=1200.1n

.meas tran Vdout1_75ck96 AVG v(dout1_75) FROM=1199.9n TO=1200.1n

.meas tran Vdout1_76ck96 AVG v(dout1_76) FROM=1199.9n TO=1200.1n

.meas tran Vdout1_77ck96 AVG v(dout1_77) FROM=1199.9n TO=1200.1n

.meas tran Vdout1_78ck96 AVG v(dout1_78) FROM=1199.9n TO=1200.1n

.meas tran Vdout1_79ck96 AVG v(dout1_79) FROM=1199.9n TO=1200.1n

.meas tran Vdout1_0ck97 AVG v(dout1_0) FROM=1209.9n TO=1210.1n

.meas tran Vdout1_1ck97 AVG v(dout1_1) FROM=1209.9n TO=1210.1n

.meas tran Vdout1_2ck97 AVG v(dout1_2) FROM=1209.9n TO=1210.1n

.meas tran Vdout1_3ck97 AVG v(dout1_3) FROM=1209.9n TO=1210.1n

.meas tran Vdout1_4ck97 AVG v(dout1_4) FROM=1209.9n TO=1210.1n

.meas tran Vdout1_5ck97 AVG v(dout1_5) FROM=1209.9n TO=1210.1n

.meas tran Vdout1_6ck97 AVG v(dout1_6) FROM=1209.9n TO=1210.1n

.meas tran Vdout1_7ck97 AVG v(dout1_7) FROM=1209.9n TO=1210.1n

.meas tran Vdout1_8ck97 AVG v(dout1_8) FROM=1209.9n TO=1210.1n

.meas tran Vdout1_9ck97 AVG v(dout1_9) FROM=1209.9n TO=1210.1n

.meas tran Vdout1_10ck97 AVG v(dout1_10) FROM=1209.9n TO=1210.1n

.meas tran Vdout1_11ck97 AVG v(dout1_11) FROM=1209.9n TO=1210.1n

.meas tran Vdout1_12ck97 AVG v(dout1_12) FROM=1209.9n TO=1210.1n

.meas tran Vdout1_13ck97 AVG v(dout1_13) FROM=1209.9n TO=1210.1n

.meas tran Vdout1_14ck97 AVG v(dout1_14) FROM=1209.9n TO=1210.1n

.meas tran Vdout1_15ck97 AVG v(dout1_15) FROM=1209.9n TO=1210.1n

.meas tran Vdout1_16ck97 AVG v(dout1_16) FROM=1209.9n TO=1210.1n

.meas tran Vdout1_17ck97 AVG v(dout1_17) FROM=1209.9n TO=1210.1n

.meas tran Vdout1_18ck97 AVG v(dout1_18) FROM=1209.9n TO=1210.1n

.meas tran Vdout1_19ck97 AVG v(dout1_19) FROM=1209.9n TO=1210.1n

.meas tran Vdout1_20ck97 AVG v(dout1_20) FROM=1209.9n TO=1210.1n

.meas tran Vdout1_21ck97 AVG v(dout1_21) FROM=1209.9n TO=1210.1n

.meas tran Vdout1_22ck97 AVG v(dout1_22) FROM=1209.9n TO=1210.1n

.meas tran Vdout1_23ck97 AVG v(dout1_23) FROM=1209.9n TO=1210.1n

.meas tran Vdout1_24ck97 AVG v(dout1_24) FROM=1209.9n TO=1210.1n

.meas tran Vdout1_25ck97 AVG v(dout1_25) FROM=1209.9n TO=1210.1n

.meas tran Vdout1_26ck97 AVG v(dout1_26) FROM=1209.9n TO=1210.1n

.meas tran Vdout1_27ck97 AVG v(dout1_27) FROM=1209.9n TO=1210.1n

.meas tran Vdout1_28ck97 AVG v(dout1_28) FROM=1209.9n TO=1210.1n

.meas tran Vdout1_29ck97 AVG v(dout1_29) FROM=1209.9n TO=1210.1n

.meas tran Vdout1_30ck97 AVG v(dout1_30) FROM=1209.9n TO=1210.1n

.meas tran Vdout1_31ck97 AVG v(dout1_31) FROM=1209.9n TO=1210.1n

.meas tran Vdout1_32ck97 AVG v(dout1_32) FROM=1209.9n TO=1210.1n

.meas tran Vdout1_33ck97 AVG v(dout1_33) FROM=1209.9n TO=1210.1n

.meas tran Vdout1_34ck97 AVG v(dout1_34) FROM=1209.9n TO=1210.1n

.meas tran Vdout1_35ck97 AVG v(dout1_35) FROM=1209.9n TO=1210.1n

.meas tran Vdout1_36ck97 AVG v(dout1_36) FROM=1209.9n TO=1210.1n

.meas tran Vdout1_37ck97 AVG v(dout1_37) FROM=1209.9n TO=1210.1n

.meas tran Vdout1_38ck97 AVG v(dout1_38) FROM=1209.9n TO=1210.1n

.meas tran Vdout1_39ck97 AVG v(dout1_39) FROM=1209.9n TO=1210.1n

.meas tran Vdout1_40ck97 AVG v(dout1_40) FROM=1209.9n TO=1210.1n

.meas tran Vdout1_41ck97 AVG v(dout1_41) FROM=1209.9n TO=1210.1n

.meas tran Vdout1_42ck97 AVG v(dout1_42) FROM=1209.9n TO=1210.1n

.meas tran Vdout1_43ck97 AVG v(dout1_43) FROM=1209.9n TO=1210.1n

.meas tran Vdout1_44ck97 AVG v(dout1_44) FROM=1209.9n TO=1210.1n

.meas tran Vdout1_45ck97 AVG v(dout1_45) FROM=1209.9n TO=1210.1n

.meas tran Vdout1_46ck97 AVG v(dout1_46) FROM=1209.9n TO=1210.1n

.meas tran Vdout1_47ck97 AVG v(dout1_47) FROM=1209.9n TO=1210.1n

.meas tran Vdout1_48ck97 AVG v(dout1_48) FROM=1209.9n TO=1210.1n

.meas tran Vdout1_49ck97 AVG v(dout1_49) FROM=1209.9n TO=1210.1n

.meas tran Vdout1_50ck97 AVG v(dout1_50) FROM=1209.9n TO=1210.1n

.meas tran Vdout1_51ck97 AVG v(dout1_51) FROM=1209.9n TO=1210.1n

.meas tran Vdout1_52ck97 AVG v(dout1_52) FROM=1209.9n TO=1210.1n

.meas tran Vdout1_53ck97 AVG v(dout1_53) FROM=1209.9n TO=1210.1n

.meas tran Vdout1_54ck97 AVG v(dout1_54) FROM=1209.9n TO=1210.1n

.meas tran Vdout1_55ck97 AVG v(dout1_55) FROM=1209.9n TO=1210.1n

.meas tran Vdout1_56ck97 AVG v(dout1_56) FROM=1209.9n TO=1210.1n

.meas tran Vdout1_57ck97 AVG v(dout1_57) FROM=1209.9n TO=1210.1n

.meas tran Vdout1_58ck97 AVG v(dout1_58) FROM=1209.9n TO=1210.1n

.meas tran Vdout1_59ck97 AVG v(dout1_59) FROM=1209.9n TO=1210.1n

.meas tran Vdout1_60ck97 AVG v(dout1_60) FROM=1209.9n TO=1210.1n

.meas tran Vdout1_61ck97 AVG v(dout1_61) FROM=1209.9n TO=1210.1n

.meas tran Vdout1_62ck97 AVG v(dout1_62) FROM=1209.9n TO=1210.1n

.meas tran Vdout1_63ck97 AVG v(dout1_63) FROM=1209.9n TO=1210.1n

.meas tran Vdout1_64ck97 AVG v(dout1_64) FROM=1209.9n TO=1210.1n

.meas tran Vdout1_65ck97 AVG v(dout1_65) FROM=1209.9n TO=1210.1n

.meas tran Vdout1_66ck97 AVG v(dout1_66) FROM=1209.9n TO=1210.1n

.meas tran Vdout1_67ck97 AVG v(dout1_67) FROM=1209.9n TO=1210.1n

.meas tran Vdout1_68ck97 AVG v(dout1_68) FROM=1209.9n TO=1210.1n

.meas tran Vdout1_69ck97 AVG v(dout1_69) FROM=1209.9n TO=1210.1n

.meas tran Vdout1_70ck97 AVG v(dout1_70) FROM=1209.9n TO=1210.1n

.meas tran Vdout1_71ck97 AVG v(dout1_71) FROM=1209.9n TO=1210.1n

.meas tran Vdout1_72ck97 AVG v(dout1_72) FROM=1209.9n TO=1210.1n

.meas tran Vdout1_73ck97 AVG v(dout1_73) FROM=1209.9n TO=1210.1n

.meas tran Vdout1_74ck97 AVG v(dout1_74) FROM=1209.9n TO=1210.1n

.meas tran Vdout1_75ck97 AVG v(dout1_75) FROM=1209.9n TO=1210.1n

.meas tran Vdout1_76ck97 AVG v(dout1_76) FROM=1209.9n TO=1210.1n

.meas tran Vdout1_77ck97 AVG v(dout1_77) FROM=1209.9n TO=1210.1n

.meas tran Vdout1_78ck97 AVG v(dout1_78) FROM=1209.9n TO=1210.1n

.meas tran Vdout1_79ck97 AVG v(dout1_79) FROM=1209.9n TO=1210.1n

.meas tran Vdout1_0ck98 AVG v(dout1_0) FROM=1219.9n TO=1220.1n

.meas tran Vdout1_1ck98 AVG v(dout1_1) FROM=1219.9n TO=1220.1n

.meas tran Vdout1_2ck98 AVG v(dout1_2) FROM=1219.9n TO=1220.1n

.meas tran Vdout1_3ck98 AVG v(dout1_3) FROM=1219.9n TO=1220.1n

.meas tran Vdout1_4ck98 AVG v(dout1_4) FROM=1219.9n TO=1220.1n

.meas tran Vdout1_5ck98 AVG v(dout1_5) FROM=1219.9n TO=1220.1n

.meas tran Vdout1_6ck98 AVG v(dout1_6) FROM=1219.9n TO=1220.1n

.meas tran Vdout1_7ck98 AVG v(dout1_7) FROM=1219.9n TO=1220.1n

.meas tran Vdout1_8ck98 AVG v(dout1_8) FROM=1219.9n TO=1220.1n

.meas tran Vdout1_9ck98 AVG v(dout1_9) FROM=1219.9n TO=1220.1n

.meas tran Vdout1_10ck98 AVG v(dout1_10) FROM=1219.9n TO=1220.1n

.meas tran Vdout1_11ck98 AVG v(dout1_11) FROM=1219.9n TO=1220.1n

.meas tran Vdout1_12ck98 AVG v(dout1_12) FROM=1219.9n TO=1220.1n

.meas tran Vdout1_13ck98 AVG v(dout1_13) FROM=1219.9n TO=1220.1n

.meas tran Vdout1_14ck98 AVG v(dout1_14) FROM=1219.9n TO=1220.1n

.meas tran Vdout1_15ck98 AVG v(dout1_15) FROM=1219.9n TO=1220.1n

.meas tran Vdout1_16ck98 AVG v(dout1_16) FROM=1219.9n TO=1220.1n

.meas tran Vdout1_17ck98 AVG v(dout1_17) FROM=1219.9n TO=1220.1n

.meas tran Vdout1_18ck98 AVG v(dout1_18) FROM=1219.9n TO=1220.1n

.meas tran Vdout1_19ck98 AVG v(dout1_19) FROM=1219.9n TO=1220.1n

.meas tran Vdout1_20ck98 AVG v(dout1_20) FROM=1219.9n TO=1220.1n

.meas tran Vdout1_21ck98 AVG v(dout1_21) FROM=1219.9n TO=1220.1n

.meas tran Vdout1_22ck98 AVG v(dout1_22) FROM=1219.9n TO=1220.1n

.meas tran Vdout1_23ck98 AVG v(dout1_23) FROM=1219.9n TO=1220.1n

.meas tran Vdout1_24ck98 AVG v(dout1_24) FROM=1219.9n TO=1220.1n

.meas tran Vdout1_25ck98 AVG v(dout1_25) FROM=1219.9n TO=1220.1n

.meas tran Vdout1_26ck98 AVG v(dout1_26) FROM=1219.9n TO=1220.1n

.meas tran Vdout1_27ck98 AVG v(dout1_27) FROM=1219.9n TO=1220.1n

.meas tran Vdout1_28ck98 AVG v(dout1_28) FROM=1219.9n TO=1220.1n

.meas tran Vdout1_29ck98 AVG v(dout1_29) FROM=1219.9n TO=1220.1n

.meas tran Vdout1_30ck98 AVG v(dout1_30) FROM=1219.9n TO=1220.1n

.meas tran Vdout1_31ck98 AVG v(dout1_31) FROM=1219.9n TO=1220.1n

.meas tran Vdout1_32ck98 AVG v(dout1_32) FROM=1219.9n TO=1220.1n

.meas tran Vdout1_33ck98 AVG v(dout1_33) FROM=1219.9n TO=1220.1n

.meas tran Vdout1_34ck98 AVG v(dout1_34) FROM=1219.9n TO=1220.1n

.meas tran Vdout1_35ck98 AVG v(dout1_35) FROM=1219.9n TO=1220.1n

.meas tran Vdout1_36ck98 AVG v(dout1_36) FROM=1219.9n TO=1220.1n

.meas tran Vdout1_37ck98 AVG v(dout1_37) FROM=1219.9n TO=1220.1n

.meas tran Vdout1_38ck98 AVG v(dout1_38) FROM=1219.9n TO=1220.1n

.meas tran Vdout1_39ck98 AVG v(dout1_39) FROM=1219.9n TO=1220.1n

.meas tran Vdout1_40ck98 AVG v(dout1_40) FROM=1219.9n TO=1220.1n

.meas tran Vdout1_41ck98 AVG v(dout1_41) FROM=1219.9n TO=1220.1n

.meas tran Vdout1_42ck98 AVG v(dout1_42) FROM=1219.9n TO=1220.1n

.meas tran Vdout1_43ck98 AVG v(dout1_43) FROM=1219.9n TO=1220.1n

.meas tran Vdout1_44ck98 AVG v(dout1_44) FROM=1219.9n TO=1220.1n

.meas tran Vdout1_45ck98 AVG v(dout1_45) FROM=1219.9n TO=1220.1n

.meas tran Vdout1_46ck98 AVG v(dout1_46) FROM=1219.9n TO=1220.1n

.meas tran Vdout1_47ck98 AVG v(dout1_47) FROM=1219.9n TO=1220.1n

.meas tran Vdout1_48ck98 AVG v(dout1_48) FROM=1219.9n TO=1220.1n

.meas tran Vdout1_49ck98 AVG v(dout1_49) FROM=1219.9n TO=1220.1n

.meas tran Vdout1_50ck98 AVG v(dout1_50) FROM=1219.9n TO=1220.1n

.meas tran Vdout1_51ck98 AVG v(dout1_51) FROM=1219.9n TO=1220.1n

.meas tran Vdout1_52ck98 AVG v(dout1_52) FROM=1219.9n TO=1220.1n

.meas tran Vdout1_53ck98 AVG v(dout1_53) FROM=1219.9n TO=1220.1n

.meas tran Vdout1_54ck98 AVG v(dout1_54) FROM=1219.9n TO=1220.1n

.meas tran Vdout1_55ck98 AVG v(dout1_55) FROM=1219.9n TO=1220.1n

.meas tran Vdout1_56ck98 AVG v(dout1_56) FROM=1219.9n TO=1220.1n

.meas tran Vdout1_57ck98 AVG v(dout1_57) FROM=1219.9n TO=1220.1n

.meas tran Vdout1_58ck98 AVG v(dout1_58) FROM=1219.9n TO=1220.1n

.meas tran Vdout1_59ck98 AVG v(dout1_59) FROM=1219.9n TO=1220.1n

.meas tran Vdout1_60ck98 AVG v(dout1_60) FROM=1219.9n TO=1220.1n

.meas tran Vdout1_61ck98 AVG v(dout1_61) FROM=1219.9n TO=1220.1n

.meas tran Vdout1_62ck98 AVG v(dout1_62) FROM=1219.9n TO=1220.1n

.meas tran Vdout1_63ck98 AVG v(dout1_63) FROM=1219.9n TO=1220.1n

.meas tran Vdout1_64ck98 AVG v(dout1_64) FROM=1219.9n TO=1220.1n

.meas tran Vdout1_65ck98 AVG v(dout1_65) FROM=1219.9n TO=1220.1n

.meas tran Vdout1_66ck98 AVG v(dout1_66) FROM=1219.9n TO=1220.1n

.meas tran Vdout1_67ck98 AVG v(dout1_67) FROM=1219.9n TO=1220.1n

.meas tran Vdout1_68ck98 AVG v(dout1_68) FROM=1219.9n TO=1220.1n

.meas tran Vdout1_69ck98 AVG v(dout1_69) FROM=1219.9n TO=1220.1n

.meas tran Vdout1_70ck98 AVG v(dout1_70) FROM=1219.9n TO=1220.1n

.meas tran Vdout1_71ck98 AVG v(dout1_71) FROM=1219.9n TO=1220.1n

.meas tran Vdout1_72ck98 AVG v(dout1_72) FROM=1219.9n TO=1220.1n

.meas tran Vdout1_73ck98 AVG v(dout1_73) FROM=1219.9n TO=1220.1n

.meas tran Vdout1_74ck98 AVG v(dout1_74) FROM=1219.9n TO=1220.1n

.meas tran Vdout1_75ck98 AVG v(dout1_75) FROM=1219.9n TO=1220.1n

.meas tran Vdout1_76ck98 AVG v(dout1_76) FROM=1219.9n TO=1220.1n

.meas tran Vdout1_77ck98 AVG v(dout1_77) FROM=1219.9n TO=1220.1n

.meas tran Vdout1_78ck98 AVG v(dout1_78) FROM=1219.9n TO=1220.1n

.meas tran Vdout1_79ck98 AVG v(dout1_79) FROM=1219.9n TO=1220.1n

.meas tran Vdout1_0ck99 AVG v(dout1_0) FROM=1229.9n TO=1230.1n

.meas tran Vdout1_1ck99 AVG v(dout1_1) FROM=1229.9n TO=1230.1n

.meas tran Vdout1_2ck99 AVG v(dout1_2) FROM=1229.9n TO=1230.1n

.meas tran Vdout1_3ck99 AVG v(dout1_3) FROM=1229.9n TO=1230.1n

.meas tran Vdout1_4ck99 AVG v(dout1_4) FROM=1229.9n TO=1230.1n

.meas tran Vdout1_5ck99 AVG v(dout1_5) FROM=1229.9n TO=1230.1n

.meas tran Vdout1_6ck99 AVG v(dout1_6) FROM=1229.9n TO=1230.1n

.meas tran Vdout1_7ck99 AVG v(dout1_7) FROM=1229.9n TO=1230.1n

.meas tran Vdout1_8ck99 AVG v(dout1_8) FROM=1229.9n TO=1230.1n

.meas tran Vdout1_9ck99 AVG v(dout1_9) FROM=1229.9n TO=1230.1n

.meas tran Vdout1_10ck99 AVG v(dout1_10) FROM=1229.9n TO=1230.1n

.meas tran Vdout1_11ck99 AVG v(dout1_11) FROM=1229.9n TO=1230.1n

.meas tran Vdout1_12ck99 AVG v(dout1_12) FROM=1229.9n TO=1230.1n

.meas tran Vdout1_13ck99 AVG v(dout1_13) FROM=1229.9n TO=1230.1n

.meas tran Vdout1_14ck99 AVG v(dout1_14) FROM=1229.9n TO=1230.1n

.meas tran Vdout1_15ck99 AVG v(dout1_15) FROM=1229.9n TO=1230.1n

.meas tran Vdout1_16ck99 AVG v(dout1_16) FROM=1229.9n TO=1230.1n

.meas tran Vdout1_17ck99 AVG v(dout1_17) FROM=1229.9n TO=1230.1n

.meas tran Vdout1_18ck99 AVG v(dout1_18) FROM=1229.9n TO=1230.1n

.meas tran Vdout1_19ck99 AVG v(dout1_19) FROM=1229.9n TO=1230.1n

.meas tran Vdout1_20ck99 AVG v(dout1_20) FROM=1229.9n TO=1230.1n

.meas tran Vdout1_21ck99 AVG v(dout1_21) FROM=1229.9n TO=1230.1n

.meas tran Vdout1_22ck99 AVG v(dout1_22) FROM=1229.9n TO=1230.1n

.meas tran Vdout1_23ck99 AVG v(dout1_23) FROM=1229.9n TO=1230.1n

.meas tran Vdout1_24ck99 AVG v(dout1_24) FROM=1229.9n TO=1230.1n

.meas tran Vdout1_25ck99 AVG v(dout1_25) FROM=1229.9n TO=1230.1n

.meas tran Vdout1_26ck99 AVG v(dout1_26) FROM=1229.9n TO=1230.1n

.meas tran Vdout1_27ck99 AVG v(dout1_27) FROM=1229.9n TO=1230.1n

.meas tran Vdout1_28ck99 AVG v(dout1_28) FROM=1229.9n TO=1230.1n

.meas tran Vdout1_29ck99 AVG v(dout1_29) FROM=1229.9n TO=1230.1n

.meas tran Vdout1_30ck99 AVG v(dout1_30) FROM=1229.9n TO=1230.1n

.meas tran Vdout1_31ck99 AVG v(dout1_31) FROM=1229.9n TO=1230.1n

.meas tran Vdout1_32ck99 AVG v(dout1_32) FROM=1229.9n TO=1230.1n

.meas tran Vdout1_33ck99 AVG v(dout1_33) FROM=1229.9n TO=1230.1n

.meas tran Vdout1_34ck99 AVG v(dout1_34) FROM=1229.9n TO=1230.1n

.meas tran Vdout1_35ck99 AVG v(dout1_35) FROM=1229.9n TO=1230.1n

.meas tran Vdout1_36ck99 AVG v(dout1_36) FROM=1229.9n TO=1230.1n

.meas tran Vdout1_37ck99 AVG v(dout1_37) FROM=1229.9n TO=1230.1n

.meas tran Vdout1_38ck99 AVG v(dout1_38) FROM=1229.9n TO=1230.1n

.meas tran Vdout1_39ck99 AVG v(dout1_39) FROM=1229.9n TO=1230.1n

.meas tran Vdout1_40ck99 AVG v(dout1_40) FROM=1229.9n TO=1230.1n

.meas tran Vdout1_41ck99 AVG v(dout1_41) FROM=1229.9n TO=1230.1n

.meas tran Vdout1_42ck99 AVG v(dout1_42) FROM=1229.9n TO=1230.1n

.meas tran Vdout1_43ck99 AVG v(dout1_43) FROM=1229.9n TO=1230.1n

.meas tran Vdout1_44ck99 AVG v(dout1_44) FROM=1229.9n TO=1230.1n

.meas tran Vdout1_45ck99 AVG v(dout1_45) FROM=1229.9n TO=1230.1n

.meas tran Vdout1_46ck99 AVG v(dout1_46) FROM=1229.9n TO=1230.1n

.meas tran Vdout1_47ck99 AVG v(dout1_47) FROM=1229.9n TO=1230.1n

.meas tran Vdout1_48ck99 AVG v(dout1_48) FROM=1229.9n TO=1230.1n

.meas tran Vdout1_49ck99 AVG v(dout1_49) FROM=1229.9n TO=1230.1n

.meas tran Vdout1_50ck99 AVG v(dout1_50) FROM=1229.9n TO=1230.1n

.meas tran Vdout1_51ck99 AVG v(dout1_51) FROM=1229.9n TO=1230.1n

.meas tran Vdout1_52ck99 AVG v(dout1_52) FROM=1229.9n TO=1230.1n

.meas tran Vdout1_53ck99 AVG v(dout1_53) FROM=1229.9n TO=1230.1n

.meas tran Vdout1_54ck99 AVG v(dout1_54) FROM=1229.9n TO=1230.1n

.meas tran Vdout1_55ck99 AVG v(dout1_55) FROM=1229.9n TO=1230.1n

.meas tran Vdout1_56ck99 AVG v(dout1_56) FROM=1229.9n TO=1230.1n

.meas tran Vdout1_57ck99 AVG v(dout1_57) FROM=1229.9n TO=1230.1n

.meas tran Vdout1_58ck99 AVG v(dout1_58) FROM=1229.9n TO=1230.1n

.meas tran Vdout1_59ck99 AVG v(dout1_59) FROM=1229.9n TO=1230.1n

.meas tran Vdout1_60ck99 AVG v(dout1_60) FROM=1229.9n TO=1230.1n

.meas tran Vdout1_61ck99 AVG v(dout1_61) FROM=1229.9n TO=1230.1n

.meas tran Vdout1_62ck99 AVG v(dout1_62) FROM=1229.9n TO=1230.1n

.meas tran Vdout1_63ck99 AVG v(dout1_63) FROM=1229.9n TO=1230.1n

.meas tran Vdout1_64ck99 AVG v(dout1_64) FROM=1229.9n TO=1230.1n

.meas tran Vdout1_65ck99 AVG v(dout1_65) FROM=1229.9n TO=1230.1n

.meas tran Vdout1_66ck99 AVG v(dout1_66) FROM=1229.9n TO=1230.1n

.meas tran Vdout1_67ck99 AVG v(dout1_67) FROM=1229.9n TO=1230.1n

.meas tran Vdout1_68ck99 AVG v(dout1_68) FROM=1229.9n TO=1230.1n

.meas tran Vdout1_69ck99 AVG v(dout1_69) FROM=1229.9n TO=1230.1n

.meas tran Vdout1_70ck99 AVG v(dout1_70) FROM=1229.9n TO=1230.1n

.meas tran Vdout1_71ck99 AVG v(dout1_71) FROM=1229.9n TO=1230.1n

.meas tran Vdout1_72ck99 AVG v(dout1_72) FROM=1229.9n TO=1230.1n

.meas tran Vdout1_73ck99 AVG v(dout1_73) FROM=1229.9n TO=1230.1n

.meas tran Vdout1_74ck99 AVG v(dout1_74) FROM=1229.9n TO=1230.1n

.meas tran Vdout1_75ck99 AVG v(dout1_75) FROM=1229.9n TO=1230.1n

.meas tran Vdout1_76ck99 AVG v(dout1_76) FROM=1229.9n TO=1230.1n

.meas tran Vdout1_77ck99 AVG v(dout1_77) FROM=1229.9n TO=1230.1n

.meas tran Vdout1_78ck99 AVG v(dout1_78) FROM=1229.9n TO=1230.1n

.meas tran Vdout1_79ck99 AVG v(dout1_79) FROM=1229.9n TO=1230.1n

.meas tran Vdout1_0ck100 AVG v(dout1_0) FROM=1239.9n TO=1240.1n

.meas tran Vdout1_1ck100 AVG v(dout1_1) FROM=1239.9n TO=1240.1n

.meas tran Vdout1_2ck100 AVG v(dout1_2) FROM=1239.9n TO=1240.1n

.meas tran Vdout1_3ck100 AVG v(dout1_3) FROM=1239.9n TO=1240.1n

.meas tran Vdout1_4ck100 AVG v(dout1_4) FROM=1239.9n TO=1240.1n

.meas tran Vdout1_5ck100 AVG v(dout1_5) FROM=1239.9n TO=1240.1n

.meas tran Vdout1_6ck100 AVG v(dout1_6) FROM=1239.9n TO=1240.1n

.meas tran Vdout1_7ck100 AVG v(dout1_7) FROM=1239.9n TO=1240.1n

.meas tran Vdout1_8ck100 AVG v(dout1_8) FROM=1239.9n TO=1240.1n

.meas tran Vdout1_9ck100 AVG v(dout1_9) FROM=1239.9n TO=1240.1n

.meas tran Vdout1_10ck100 AVG v(dout1_10) FROM=1239.9n TO=1240.1n

.meas tran Vdout1_11ck100 AVG v(dout1_11) FROM=1239.9n TO=1240.1n

.meas tran Vdout1_12ck100 AVG v(dout1_12) FROM=1239.9n TO=1240.1n

.meas tran Vdout1_13ck100 AVG v(dout1_13) FROM=1239.9n TO=1240.1n

.meas tran Vdout1_14ck100 AVG v(dout1_14) FROM=1239.9n TO=1240.1n

.meas tran Vdout1_15ck100 AVG v(dout1_15) FROM=1239.9n TO=1240.1n

.meas tran Vdout1_16ck100 AVG v(dout1_16) FROM=1239.9n TO=1240.1n

.meas tran Vdout1_17ck100 AVG v(dout1_17) FROM=1239.9n TO=1240.1n

.meas tran Vdout1_18ck100 AVG v(dout1_18) FROM=1239.9n TO=1240.1n

.meas tran Vdout1_19ck100 AVG v(dout1_19) FROM=1239.9n TO=1240.1n

.meas tran Vdout1_20ck100 AVG v(dout1_20) FROM=1239.9n TO=1240.1n

.meas tran Vdout1_21ck100 AVG v(dout1_21) FROM=1239.9n TO=1240.1n

.meas tran Vdout1_22ck100 AVG v(dout1_22) FROM=1239.9n TO=1240.1n

.meas tran Vdout1_23ck100 AVG v(dout1_23) FROM=1239.9n TO=1240.1n

.meas tran Vdout1_24ck100 AVG v(dout1_24) FROM=1239.9n TO=1240.1n

.meas tran Vdout1_25ck100 AVG v(dout1_25) FROM=1239.9n TO=1240.1n

.meas tran Vdout1_26ck100 AVG v(dout1_26) FROM=1239.9n TO=1240.1n

.meas tran Vdout1_27ck100 AVG v(dout1_27) FROM=1239.9n TO=1240.1n

.meas tran Vdout1_28ck100 AVG v(dout1_28) FROM=1239.9n TO=1240.1n

.meas tran Vdout1_29ck100 AVG v(dout1_29) FROM=1239.9n TO=1240.1n

.meas tran Vdout1_30ck100 AVG v(dout1_30) FROM=1239.9n TO=1240.1n

.meas tran Vdout1_31ck100 AVG v(dout1_31) FROM=1239.9n TO=1240.1n

.meas tran Vdout1_32ck100 AVG v(dout1_32) FROM=1239.9n TO=1240.1n

.meas tran Vdout1_33ck100 AVG v(dout1_33) FROM=1239.9n TO=1240.1n

.meas tran Vdout1_34ck100 AVG v(dout1_34) FROM=1239.9n TO=1240.1n

.meas tran Vdout1_35ck100 AVG v(dout1_35) FROM=1239.9n TO=1240.1n

.meas tran Vdout1_36ck100 AVG v(dout1_36) FROM=1239.9n TO=1240.1n

.meas tran Vdout1_37ck100 AVG v(dout1_37) FROM=1239.9n TO=1240.1n

.meas tran Vdout1_38ck100 AVG v(dout1_38) FROM=1239.9n TO=1240.1n

.meas tran Vdout1_39ck100 AVG v(dout1_39) FROM=1239.9n TO=1240.1n

.meas tran Vdout1_40ck100 AVG v(dout1_40) FROM=1239.9n TO=1240.1n

.meas tran Vdout1_41ck100 AVG v(dout1_41) FROM=1239.9n TO=1240.1n

.meas tran Vdout1_42ck100 AVG v(dout1_42) FROM=1239.9n TO=1240.1n

.meas tran Vdout1_43ck100 AVG v(dout1_43) FROM=1239.9n TO=1240.1n

.meas tran Vdout1_44ck100 AVG v(dout1_44) FROM=1239.9n TO=1240.1n

.meas tran Vdout1_45ck100 AVG v(dout1_45) FROM=1239.9n TO=1240.1n

.meas tran Vdout1_46ck100 AVG v(dout1_46) FROM=1239.9n TO=1240.1n

.meas tran Vdout1_47ck100 AVG v(dout1_47) FROM=1239.9n TO=1240.1n

.meas tran Vdout1_48ck100 AVG v(dout1_48) FROM=1239.9n TO=1240.1n

.meas tran Vdout1_49ck100 AVG v(dout1_49) FROM=1239.9n TO=1240.1n

.meas tran Vdout1_50ck100 AVG v(dout1_50) FROM=1239.9n TO=1240.1n

.meas tran Vdout1_51ck100 AVG v(dout1_51) FROM=1239.9n TO=1240.1n

.meas tran Vdout1_52ck100 AVG v(dout1_52) FROM=1239.9n TO=1240.1n

.meas tran Vdout1_53ck100 AVG v(dout1_53) FROM=1239.9n TO=1240.1n

.meas tran Vdout1_54ck100 AVG v(dout1_54) FROM=1239.9n TO=1240.1n

.meas tran Vdout1_55ck100 AVG v(dout1_55) FROM=1239.9n TO=1240.1n

.meas tran Vdout1_56ck100 AVG v(dout1_56) FROM=1239.9n TO=1240.1n

.meas tran Vdout1_57ck100 AVG v(dout1_57) FROM=1239.9n TO=1240.1n

.meas tran Vdout1_58ck100 AVG v(dout1_58) FROM=1239.9n TO=1240.1n

.meas tran Vdout1_59ck100 AVG v(dout1_59) FROM=1239.9n TO=1240.1n

.meas tran Vdout1_60ck100 AVG v(dout1_60) FROM=1239.9n TO=1240.1n

.meas tran Vdout1_61ck100 AVG v(dout1_61) FROM=1239.9n TO=1240.1n

.meas tran Vdout1_62ck100 AVG v(dout1_62) FROM=1239.9n TO=1240.1n

.meas tran Vdout1_63ck100 AVG v(dout1_63) FROM=1239.9n TO=1240.1n

.meas tran Vdout1_64ck100 AVG v(dout1_64) FROM=1239.9n TO=1240.1n

.meas tran Vdout1_65ck100 AVG v(dout1_65) FROM=1239.9n TO=1240.1n

.meas tran Vdout1_66ck100 AVG v(dout1_66) FROM=1239.9n TO=1240.1n

.meas tran Vdout1_67ck100 AVG v(dout1_67) FROM=1239.9n TO=1240.1n

.meas tran Vdout1_68ck100 AVG v(dout1_68) FROM=1239.9n TO=1240.1n

.meas tran Vdout1_69ck100 AVG v(dout1_69) FROM=1239.9n TO=1240.1n

.meas tran Vdout1_70ck100 AVG v(dout1_70) FROM=1239.9n TO=1240.1n

.meas tran Vdout1_71ck100 AVG v(dout1_71) FROM=1239.9n TO=1240.1n

.meas tran Vdout1_72ck100 AVG v(dout1_72) FROM=1239.9n TO=1240.1n

.meas tran Vdout1_73ck100 AVG v(dout1_73) FROM=1239.9n TO=1240.1n

.meas tran Vdout1_74ck100 AVG v(dout1_74) FROM=1239.9n TO=1240.1n

.meas tran Vdout1_75ck100 AVG v(dout1_75) FROM=1239.9n TO=1240.1n

.meas tran Vdout1_76ck100 AVG v(dout1_76) FROM=1239.9n TO=1240.1n

.meas tran Vdout1_77ck100 AVG v(dout1_77) FROM=1239.9n TO=1240.1n

.meas tran Vdout1_78ck100 AVG v(dout1_78) FROM=1239.9n TO=1240.1n

.meas tran Vdout1_79ck100 AVG v(dout1_79) FROM=1239.9n TO=1240.1n

.meas tran Vdout0_0ck101 AVG v(dout0_0) FROM=1259.9n TO=1260.1n

.meas tran Vdout0_1ck101 AVG v(dout0_1) FROM=1259.9n TO=1260.1n

.meas tran Vdout0_2ck101 AVG v(dout0_2) FROM=1259.9n TO=1260.1n

.meas tran Vdout0_3ck101 AVG v(dout0_3) FROM=1259.9n TO=1260.1n

.meas tran Vdout0_4ck101 AVG v(dout0_4) FROM=1259.9n TO=1260.1n

.meas tran Vdout0_5ck101 AVG v(dout0_5) FROM=1259.9n TO=1260.1n

.meas tran Vdout0_6ck101 AVG v(dout0_6) FROM=1259.9n TO=1260.1n

.meas tran Vdout0_7ck101 AVG v(dout0_7) FROM=1259.9n TO=1260.1n

.meas tran Vdout0_8ck101 AVG v(dout0_8) FROM=1259.9n TO=1260.1n

.meas tran Vdout0_9ck101 AVG v(dout0_9) FROM=1259.9n TO=1260.1n

.meas tran Vdout0_10ck101 AVG v(dout0_10) FROM=1259.9n TO=1260.1n

.meas tran Vdout0_11ck101 AVG v(dout0_11) FROM=1259.9n TO=1260.1n

.meas tran Vdout0_12ck101 AVG v(dout0_12) FROM=1259.9n TO=1260.1n

.meas tran Vdout0_13ck101 AVG v(dout0_13) FROM=1259.9n TO=1260.1n

.meas tran Vdout0_14ck101 AVG v(dout0_14) FROM=1259.9n TO=1260.1n

.meas tran Vdout0_15ck101 AVG v(dout0_15) FROM=1259.9n TO=1260.1n

.meas tran Vdout0_16ck101 AVG v(dout0_16) FROM=1259.9n TO=1260.1n

.meas tran Vdout0_17ck101 AVG v(dout0_17) FROM=1259.9n TO=1260.1n

.meas tran Vdout0_18ck101 AVG v(dout0_18) FROM=1259.9n TO=1260.1n

.meas tran Vdout0_19ck101 AVG v(dout0_19) FROM=1259.9n TO=1260.1n

.meas tran Vdout0_20ck101 AVG v(dout0_20) FROM=1259.9n TO=1260.1n

.meas tran Vdout0_21ck101 AVG v(dout0_21) FROM=1259.9n TO=1260.1n

.meas tran Vdout0_22ck101 AVG v(dout0_22) FROM=1259.9n TO=1260.1n

.meas tran Vdout0_23ck101 AVG v(dout0_23) FROM=1259.9n TO=1260.1n

.meas tran Vdout0_24ck101 AVG v(dout0_24) FROM=1259.9n TO=1260.1n

.meas tran Vdout0_25ck101 AVG v(dout0_25) FROM=1259.9n TO=1260.1n

.meas tran Vdout0_26ck101 AVG v(dout0_26) FROM=1259.9n TO=1260.1n

.meas tran Vdout0_27ck101 AVG v(dout0_27) FROM=1259.9n TO=1260.1n

.meas tran Vdout0_28ck101 AVG v(dout0_28) FROM=1259.9n TO=1260.1n

.meas tran Vdout0_29ck101 AVG v(dout0_29) FROM=1259.9n TO=1260.1n

.meas tran Vdout0_30ck101 AVG v(dout0_30) FROM=1259.9n TO=1260.1n

.meas tran Vdout0_31ck101 AVG v(dout0_31) FROM=1259.9n TO=1260.1n

.meas tran Vdout0_32ck101 AVG v(dout0_32) FROM=1259.9n TO=1260.1n

.meas tran Vdout0_33ck101 AVG v(dout0_33) FROM=1259.9n TO=1260.1n

.meas tran Vdout0_34ck101 AVG v(dout0_34) FROM=1259.9n TO=1260.1n

.meas tran Vdout0_35ck101 AVG v(dout0_35) FROM=1259.9n TO=1260.1n

.meas tran Vdout0_36ck101 AVG v(dout0_36) FROM=1259.9n TO=1260.1n

.meas tran Vdout0_37ck101 AVG v(dout0_37) FROM=1259.9n TO=1260.1n

.meas tran Vdout0_38ck101 AVG v(dout0_38) FROM=1259.9n TO=1260.1n

.meas tran Vdout0_39ck101 AVG v(dout0_39) FROM=1259.9n TO=1260.1n

.meas tran Vdout0_40ck101 AVG v(dout0_40) FROM=1259.9n TO=1260.1n

.meas tran Vdout0_41ck101 AVG v(dout0_41) FROM=1259.9n TO=1260.1n

.meas tran Vdout0_42ck101 AVG v(dout0_42) FROM=1259.9n TO=1260.1n

.meas tran Vdout0_43ck101 AVG v(dout0_43) FROM=1259.9n TO=1260.1n

.meas tran Vdout0_44ck101 AVG v(dout0_44) FROM=1259.9n TO=1260.1n

.meas tran Vdout0_45ck101 AVG v(dout0_45) FROM=1259.9n TO=1260.1n

.meas tran Vdout0_46ck101 AVG v(dout0_46) FROM=1259.9n TO=1260.1n

.meas tran Vdout0_47ck101 AVG v(dout0_47) FROM=1259.9n TO=1260.1n

.meas tran Vdout0_48ck101 AVG v(dout0_48) FROM=1259.9n TO=1260.1n

.meas tran Vdout0_49ck101 AVG v(dout0_49) FROM=1259.9n TO=1260.1n

.meas tran Vdout0_50ck101 AVG v(dout0_50) FROM=1259.9n TO=1260.1n

.meas tran Vdout0_51ck101 AVG v(dout0_51) FROM=1259.9n TO=1260.1n

.meas tran Vdout0_52ck101 AVG v(dout0_52) FROM=1259.9n TO=1260.1n

.meas tran Vdout0_53ck101 AVG v(dout0_53) FROM=1259.9n TO=1260.1n

.meas tran Vdout0_54ck101 AVG v(dout0_54) FROM=1259.9n TO=1260.1n

.meas tran Vdout0_55ck101 AVG v(dout0_55) FROM=1259.9n TO=1260.1n

.meas tran Vdout0_56ck101 AVG v(dout0_56) FROM=1259.9n TO=1260.1n

.meas tran Vdout0_57ck101 AVG v(dout0_57) FROM=1259.9n TO=1260.1n

.meas tran Vdout0_58ck101 AVG v(dout0_58) FROM=1259.9n TO=1260.1n

.meas tran Vdout0_59ck101 AVG v(dout0_59) FROM=1259.9n TO=1260.1n

.meas tran Vdout0_60ck101 AVG v(dout0_60) FROM=1259.9n TO=1260.1n

.meas tran Vdout0_61ck101 AVG v(dout0_61) FROM=1259.9n TO=1260.1n

.meas tran Vdout0_62ck101 AVG v(dout0_62) FROM=1259.9n TO=1260.1n

.meas tran Vdout0_63ck101 AVG v(dout0_63) FROM=1259.9n TO=1260.1n

.meas tran Vdout0_64ck101 AVG v(dout0_64) FROM=1259.9n TO=1260.1n

.meas tran Vdout0_65ck101 AVG v(dout0_65) FROM=1259.9n TO=1260.1n

.meas tran Vdout0_66ck101 AVG v(dout0_66) FROM=1259.9n TO=1260.1n

.meas tran Vdout0_67ck101 AVG v(dout0_67) FROM=1259.9n TO=1260.1n

.meas tran Vdout0_68ck101 AVG v(dout0_68) FROM=1259.9n TO=1260.1n

.meas tran Vdout0_69ck101 AVG v(dout0_69) FROM=1259.9n TO=1260.1n

.meas tran Vdout0_70ck101 AVG v(dout0_70) FROM=1259.9n TO=1260.1n

.meas tran Vdout0_71ck101 AVG v(dout0_71) FROM=1259.9n TO=1260.1n

.meas tran Vdout0_72ck101 AVG v(dout0_72) FROM=1259.9n TO=1260.1n

.meas tran Vdout0_73ck101 AVG v(dout0_73) FROM=1259.9n TO=1260.1n

.meas tran Vdout0_74ck101 AVG v(dout0_74) FROM=1259.9n TO=1260.1n

.meas tran Vdout0_75ck101 AVG v(dout0_75) FROM=1259.9n TO=1260.1n

.meas tran Vdout0_76ck101 AVG v(dout0_76) FROM=1259.9n TO=1260.1n

.meas tran Vdout0_77ck101 AVG v(dout0_77) FROM=1259.9n TO=1260.1n

.meas tran Vdout0_78ck101 AVG v(dout0_78) FROM=1259.9n TO=1260.1n

.meas tran Vdout0_79ck101 AVG v(dout0_79) FROM=1259.9n TO=1260.1n

.meas tran Vdout0_0ck102 AVG v(dout0_0) FROM=1269.9n TO=1270.1n

.meas tran Vdout0_1ck102 AVG v(dout0_1) FROM=1269.9n TO=1270.1n

.meas tran Vdout0_2ck102 AVG v(dout0_2) FROM=1269.9n TO=1270.1n

.meas tran Vdout0_3ck102 AVG v(dout0_3) FROM=1269.9n TO=1270.1n

.meas tran Vdout0_4ck102 AVG v(dout0_4) FROM=1269.9n TO=1270.1n

.meas tran Vdout0_5ck102 AVG v(dout0_5) FROM=1269.9n TO=1270.1n

.meas tran Vdout0_6ck102 AVG v(dout0_6) FROM=1269.9n TO=1270.1n

.meas tran Vdout0_7ck102 AVG v(dout0_7) FROM=1269.9n TO=1270.1n

.meas tran Vdout0_8ck102 AVG v(dout0_8) FROM=1269.9n TO=1270.1n

.meas tran Vdout0_9ck102 AVG v(dout0_9) FROM=1269.9n TO=1270.1n

.meas tran Vdout0_10ck102 AVG v(dout0_10) FROM=1269.9n TO=1270.1n

.meas tran Vdout0_11ck102 AVG v(dout0_11) FROM=1269.9n TO=1270.1n

.meas tran Vdout0_12ck102 AVG v(dout0_12) FROM=1269.9n TO=1270.1n

.meas tran Vdout0_13ck102 AVG v(dout0_13) FROM=1269.9n TO=1270.1n

.meas tran Vdout0_14ck102 AVG v(dout0_14) FROM=1269.9n TO=1270.1n

.meas tran Vdout0_15ck102 AVG v(dout0_15) FROM=1269.9n TO=1270.1n

.meas tran Vdout0_16ck102 AVG v(dout0_16) FROM=1269.9n TO=1270.1n

.meas tran Vdout0_17ck102 AVG v(dout0_17) FROM=1269.9n TO=1270.1n

.meas tran Vdout0_18ck102 AVG v(dout0_18) FROM=1269.9n TO=1270.1n

.meas tran Vdout0_19ck102 AVG v(dout0_19) FROM=1269.9n TO=1270.1n

.meas tran Vdout0_20ck102 AVG v(dout0_20) FROM=1269.9n TO=1270.1n

.meas tran Vdout0_21ck102 AVG v(dout0_21) FROM=1269.9n TO=1270.1n

.meas tran Vdout0_22ck102 AVG v(dout0_22) FROM=1269.9n TO=1270.1n

.meas tran Vdout0_23ck102 AVG v(dout0_23) FROM=1269.9n TO=1270.1n

.meas tran Vdout0_24ck102 AVG v(dout0_24) FROM=1269.9n TO=1270.1n

.meas tran Vdout0_25ck102 AVG v(dout0_25) FROM=1269.9n TO=1270.1n

.meas tran Vdout0_26ck102 AVG v(dout0_26) FROM=1269.9n TO=1270.1n

.meas tran Vdout0_27ck102 AVG v(dout0_27) FROM=1269.9n TO=1270.1n

.meas tran Vdout0_28ck102 AVG v(dout0_28) FROM=1269.9n TO=1270.1n

.meas tran Vdout0_29ck102 AVG v(dout0_29) FROM=1269.9n TO=1270.1n

.meas tran Vdout0_30ck102 AVG v(dout0_30) FROM=1269.9n TO=1270.1n

.meas tran Vdout0_31ck102 AVG v(dout0_31) FROM=1269.9n TO=1270.1n

.meas tran Vdout0_32ck102 AVG v(dout0_32) FROM=1269.9n TO=1270.1n

.meas tran Vdout0_33ck102 AVG v(dout0_33) FROM=1269.9n TO=1270.1n

.meas tran Vdout0_34ck102 AVG v(dout0_34) FROM=1269.9n TO=1270.1n

.meas tran Vdout0_35ck102 AVG v(dout0_35) FROM=1269.9n TO=1270.1n

.meas tran Vdout0_36ck102 AVG v(dout0_36) FROM=1269.9n TO=1270.1n

.meas tran Vdout0_37ck102 AVG v(dout0_37) FROM=1269.9n TO=1270.1n

.meas tran Vdout0_38ck102 AVG v(dout0_38) FROM=1269.9n TO=1270.1n

.meas tran Vdout0_39ck102 AVG v(dout0_39) FROM=1269.9n TO=1270.1n

.meas tran Vdout0_40ck102 AVG v(dout0_40) FROM=1269.9n TO=1270.1n

.meas tran Vdout0_41ck102 AVG v(dout0_41) FROM=1269.9n TO=1270.1n

.meas tran Vdout0_42ck102 AVG v(dout0_42) FROM=1269.9n TO=1270.1n

.meas tran Vdout0_43ck102 AVG v(dout0_43) FROM=1269.9n TO=1270.1n

.meas tran Vdout0_44ck102 AVG v(dout0_44) FROM=1269.9n TO=1270.1n

.meas tran Vdout0_45ck102 AVG v(dout0_45) FROM=1269.9n TO=1270.1n

.meas tran Vdout0_46ck102 AVG v(dout0_46) FROM=1269.9n TO=1270.1n

.meas tran Vdout0_47ck102 AVG v(dout0_47) FROM=1269.9n TO=1270.1n

.meas tran Vdout0_48ck102 AVG v(dout0_48) FROM=1269.9n TO=1270.1n

.meas tran Vdout0_49ck102 AVG v(dout0_49) FROM=1269.9n TO=1270.1n

.meas tran Vdout0_50ck102 AVG v(dout0_50) FROM=1269.9n TO=1270.1n

.meas tran Vdout0_51ck102 AVG v(dout0_51) FROM=1269.9n TO=1270.1n

.meas tran Vdout0_52ck102 AVG v(dout0_52) FROM=1269.9n TO=1270.1n

.meas tran Vdout0_53ck102 AVG v(dout0_53) FROM=1269.9n TO=1270.1n

.meas tran Vdout0_54ck102 AVG v(dout0_54) FROM=1269.9n TO=1270.1n

.meas tran Vdout0_55ck102 AVG v(dout0_55) FROM=1269.9n TO=1270.1n

.meas tran Vdout0_56ck102 AVG v(dout0_56) FROM=1269.9n TO=1270.1n

.meas tran Vdout0_57ck102 AVG v(dout0_57) FROM=1269.9n TO=1270.1n

.meas tran Vdout0_58ck102 AVG v(dout0_58) FROM=1269.9n TO=1270.1n

.meas tran Vdout0_59ck102 AVG v(dout0_59) FROM=1269.9n TO=1270.1n

.meas tran Vdout0_60ck102 AVG v(dout0_60) FROM=1269.9n TO=1270.1n

.meas tran Vdout0_61ck102 AVG v(dout0_61) FROM=1269.9n TO=1270.1n

.meas tran Vdout0_62ck102 AVG v(dout0_62) FROM=1269.9n TO=1270.1n

.meas tran Vdout0_63ck102 AVG v(dout0_63) FROM=1269.9n TO=1270.1n

.meas tran Vdout0_64ck102 AVG v(dout0_64) FROM=1269.9n TO=1270.1n

.meas tran Vdout0_65ck102 AVG v(dout0_65) FROM=1269.9n TO=1270.1n

.meas tran Vdout0_66ck102 AVG v(dout0_66) FROM=1269.9n TO=1270.1n

.meas tran Vdout0_67ck102 AVG v(dout0_67) FROM=1269.9n TO=1270.1n

.meas tran Vdout0_68ck102 AVG v(dout0_68) FROM=1269.9n TO=1270.1n

.meas tran Vdout0_69ck102 AVG v(dout0_69) FROM=1269.9n TO=1270.1n

.meas tran Vdout0_70ck102 AVG v(dout0_70) FROM=1269.9n TO=1270.1n

.meas tran Vdout0_71ck102 AVG v(dout0_71) FROM=1269.9n TO=1270.1n

.meas tran Vdout0_72ck102 AVG v(dout0_72) FROM=1269.9n TO=1270.1n

.meas tran Vdout0_73ck102 AVG v(dout0_73) FROM=1269.9n TO=1270.1n

.meas tran Vdout0_74ck102 AVG v(dout0_74) FROM=1269.9n TO=1270.1n

.meas tran Vdout0_75ck102 AVG v(dout0_75) FROM=1269.9n TO=1270.1n

.meas tran Vdout0_76ck102 AVG v(dout0_76) FROM=1269.9n TO=1270.1n

.meas tran Vdout0_77ck102 AVG v(dout0_77) FROM=1269.9n TO=1270.1n

.meas tran Vdout0_78ck102 AVG v(dout0_78) FROM=1269.9n TO=1270.1n

.meas tran Vdout0_79ck102 AVG v(dout0_79) FROM=1269.9n TO=1270.1n

.meas tran Vdout1_0ck103 AVG v(dout1_0) FROM=1279.9n TO=1280.1n

.meas tran Vdout1_1ck103 AVG v(dout1_1) FROM=1279.9n TO=1280.1n

.meas tran Vdout1_2ck103 AVG v(dout1_2) FROM=1279.9n TO=1280.1n

.meas tran Vdout1_3ck103 AVG v(dout1_3) FROM=1279.9n TO=1280.1n

.meas tran Vdout1_4ck103 AVG v(dout1_4) FROM=1279.9n TO=1280.1n

.meas tran Vdout1_5ck103 AVG v(dout1_5) FROM=1279.9n TO=1280.1n

.meas tran Vdout1_6ck103 AVG v(dout1_6) FROM=1279.9n TO=1280.1n

.meas tran Vdout1_7ck103 AVG v(dout1_7) FROM=1279.9n TO=1280.1n

.meas tran Vdout1_8ck103 AVG v(dout1_8) FROM=1279.9n TO=1280.1n

.meas tran Vdout1_9ck103 AVG v(dout1_9) FROM=1279.9n TO=1280.1n

.meas tran Vdout1_10ck103 AVG v(dout1_10) FROM=1279.9n TO=1280.1n

.meas tran Vdout1_11ck103 AVG v(dout1_11) FROM=1279.9n TO=1280.1n

.meas tran Vdout1_12ck103 AVG v(dout1_12) FROM=1279.9n TO=1280.1n

.meas tran Vdout1_13ck103 AVG v(dout1_13) FROM=1279.9n TO=1280.1n

.meas tran Vdout1_14ck103 AVG v(dout1_14) FROM=1279.9n TO=1280.1n

.meas tran Vdout1_15ck103 AVG v(dout1_15) FROM=1279.9n TO=1280.1n

.meas tran Vdout1_16ck103 AVG v(dout1_16) FROM=1279.9n TO=1280.1n

.meas tran Vdout1_17ck103 AVG v(dout1_17) FROM=1279.9n TO=1280.1n

.meas tran Vdout1_18ck103 AVG v(dout1_18) FROM=1279.9n TO=1280.1n

.meas tran Vdout1_19ck103 AVG v(dout1_19) FROM=1279.9n TO=1280.1n

.meas tran Vdout1_20ck103 AVG v(dout1_20) FROM=1279.9n TO=1280.1n

.meas tran Vdout1_21ck103 AVG v(dout1_21) FROM=1279.9n TO=1280.1n

.meas tran Vdout1_22ck103 AVG v(dout1_22) FROM=1279.9n TO=1280.1n

.meas tran Vdout1_23ck103 AVG v(dout1_23) FROM=1279.9n TO=1280.1n

.meas tran Vdout1_24ck103 AVG v(dout1_24) FROM=1279.9n TO=1280.1n

.meas tran Vdout1_25ck103 AVG v(dout1_25) FROM=1279.9n TO=1280.1n

.meas tran Vdout1_26ck103 AVG v(dout1_26) FROM=1279.9n TO=1280.1n

.meas tran Vdout1_27ck103 AVG v(dout1_27) FROM=1279.9n TO=1280.1n

.meas tran Vdout1_28ck103 AVG v(dout1_28) FROM=1279.9n TO=1280.1n

.meas tran Vdout1_29ck103 AVG v(dout1_29) FROM=1279.9n TO=1280.1n

.meas tran Vdout1_30ck103 AVG v(dout1_30) FROM=1279.9n TO=1280.1n

.meas tran Vdout1_31ck103 AVG v(dout1_31) FROM=1279.9n TO=1280.1n

.meas tran Vdout1_32ck103 AVG v(dout1_32) FROM=1279.9n TO=1280.1n

.meas tran Vdout1_33ck103 AVG v(dout1_33) FROM=1279.9n TO=1280.1n

.meas tran Vdout1_34ck103 AVG v(dout1_34) FROM=1279.9n TO=1280.1n

.meas tran Vdout1_35ck103 AVG v(dout1_35) FROM=1279.9n TO=1280.1n

.meas tran Vdout1_36ck103 AVG v(dout1_36) FROM=1279.9n TO=1280.1n

.meas tran Vdout1_37ck103 AVG v(dout1_37) FROM=1279.9n TO=1280.1n

.meas tran Vdout1_38ck103 AVG v(dout1_38) FROM=1279.9n TO=1280.1n

.meas tran Vdout1_39ck103 AVG v(dout1_39) FROM=1279.9n TO=1280.1n

.meas tran Vdout1_40ck103 AVG v(dout1_40) FROM=1279.9n TO=1280.1n

.meas tran Vdout1_41ck103 AVG v(dout1_41) FROM=1279.9n TO=1280.1n

.meas tran Vdout1_42ck103 AVG v(dout1_42) FROM=1279.9n TO=1280.1n

.meas tran Vdout1_43ck103 AVG v(dout1_43) FROM=1279.9n TO=1280.1n

.meas tran Vdout1_44ck103 AVG v(dout1_44) FROM=1279.9n TO=1280.1n

.meas tran Vdout1_45ck103 AVG v(dout1_45) FROM=1279.9n TO=1280.1n

.meas tran Vdout1_46ck103 AVG v(dout1_46) FROM=1279.9n TO=1280.1n

.meas tran Vdout1_47ck103 AVG v(dout1_47) FROM=1279.9n TO=1280.1n

.meas tran Vdout1_48ck103 AVG v(dout1_48) FROM=1279.9n TO=1280.1n

.meas tran Vdout1_49ck103 AVG v(dout1_49) FROM=1279.9n TO=1280.1n

.meas tran Vdout1_50ck103 AVG v(dout1_50) FROM=1279.9n TO=1280.1n

.meas tran Vdout1_51ck103 AVG v(dout1_51) FROM=1279.9n TO=1280.1n

.meas tran Vdout1_52ck103 AVG v(dout1_52) FROM=1279.9n TO=1280.1n

.meas tran Vdout1_53ck103 AVG v(dout1_53) FROM=1279.9n TO=1280.1n

.meas tran Vdout1_54ck103 AVG v(dout1_54) FROM=1279.9n TO=1280.1n

.meas tran Vdout1_55ck103 AVG v(dout1_55) FROM=1279.9n TO=1280.1n

.meas tran Vdout1_56ck103 AVG v(dout1_56) FROM=1279.9n TO=1280.1n

.meas tran Vdout1_57ck103 AVG v(dout1_57) FROM=1279.9n TO=1280.1n

.meas tran Vdout1_58ck103 AVG v(dout1_58) FROM=1279.9n TO=1280.1n

.meas tran Vdout1_59ck103 AVG v(dout1_59) FROM=1279.9n TO=1280.1n

.meas tran Vdout1_60ck103 AVG v(dout1_60) FROM=1279.9n TO=1280.1n

.meas tran Vdout1_61ck103 AVG v(dout1_61) FROM=1279.9n TO=1280.1n

.meas tran Vdout1_62ck103 AVG v(dout1_62) FROM=1279.9n TO=1280.1n

.meas tran Vdout1_63ck103 AVG v(dout1_63) FROM=1279.9n TO=1280.1n

.meas tran Vdout1_64ck103 AVG v(dout1_64) FROM=1279.9n TO=1280.1n

.meas tran Vdout1_65ck103 AVG v(dout1_65) FROM=1279.9n TO=1280.1n

.meas tran Vdout1_66ck103 AVG v(dout1_66) FROM=1279.9n TO=1280.1n

.meas tran Vdout1_67ck103 AVG v(dout1_67) FROM=1279.9n TO=1280.1n

.meas tran Vdout1_68ck103 AVG v(dout1_68) FROM=1279.9n TO=1280.1n

.meas tran Vdout1_69ck103 AVG v(dout1_69) FROM=1279.9n TO=1280.1n

.meas tran Vdout1_70ck103 AVG v(dout1_70) FROM=1279.9n TO=1280.1n

.meas tran Vdout1_71ck103 AVG v(dout1_71) FROM=1279.9n TO=1280.1n

.meas tran Vdout1_72ck103 AVG v(dout1_72) FROM=1279.9n TO=1280.1n

.meas tran Vdout1_73ck103 AVG v(dout1_73) FROM=1279.9n TO=1280.1n

.meas tran Vdout1_74ck103 AVG v(dout1_74) FROM=1279.9n TO=1280.1n

.meas tran Vdout1_75ck103 AVG v(dout1_75) FROM=1279.9n TO=1280.1n

.meas tran Vdout1_76ck103 AVG v(dout1_76) FROM=1279.9n TO=1280.1n

.meas tran Vdout1_77ck103 AVG v(dout1_77) FROM=1279.9n TO=1280.1n

.meas tran Vdout1_78ck103 AVG v(dout1_78) FROM=1279.9n TO=1280.1n

.meas tran Vdout1_79ck103 AVG v(dout1_79) FROM=1279.9n TO=1280.1n

.meas tran Vdout0_0ck104 AVG v(dout0_0) FROM=1299.9n TO=1300.1n

.meas tran Vdout0_1ck104 AVG v(dout0_1) FROM=1299.9n TO=1300.1n

.meas tran Vdout0_2ck104 AVG v(dout0_2) FROM=1299.9n TO=1300.1n

.meas tran Vdout0_3ck104 AVG v(dout0_3) FROM=1299.9n TO=1300.1n

.meas tran Vdout0_4ck104 AVG v(dout0_4) FROM=1299.9n TO=1300.1n

.meas tran Vdout0_5ck104 AVG v(dout0_5) FROM=1299.9n TO=1300.1n

.meas tran Vdout0_6ck104 AVG v(dout0_6) FROM=1299.9n TO=1300.1n

.meas tran Vdout0_7ck104 AVG v(dout0_7) FROM=1299.9n TO=1300.1n

.meas tran Vdout0_8ck104 AVG v(dout0_8) FROM=1299.9n TO=1300.1n

.meas tran Vdout0_9ck104 AVG v(dout0_9) FROM=1299.9n TO=1300.1n

.meas tran Vdout0_10ck104 AVG v(dout0_10) FROM=1299.9n TO=1300.1n

.meas tran Vdout0_11ck104 AVG v(dout0_11) FROM=1299.9n TO=1300.1n

.meas tran Vdout0_12ck104 AVG v(dout0_12) FROM=1299.9n TO=1300.1n

.meas tran Vdout0_13ck104 AVG v(dout0_13) FROM=1299.9n TO=1300.1n

.meas tran Vdout0_14ck104 AVG v(dout0_14) FROM=1299.9n TO=1300.1n

.meas tran Vdout0_15ck104 AVG v(dout0_15) FROM=1299.9n TO=1300.1n

.meas tran Vdout0_16ck104 AVG v(dout0_16) FROM=1299.9n TO=1300.1n

.meas tran Vdout0_17ck104 AVG v(dout0_17) FROM=1299.9n TO=1300.1n

.meas tran Vdout0_18ck104 AVG v(dout0_18) FROM=1299.9n TO=1300.1n

.meas tran Vdout0_19ck104 AVG v(dout0_19) FROM=1299.9n TO=1300.1n

.meas tran Vdout0_20ck104 AVG v(dout0_20) FROM=1299.9n TO=1300.1n

.meas tran Vdout0_21ck104 AVG v(dout0_21) FROM=1299.9n TO=1300.1n

.meas tran Vdout0_22ck104 AVG v(dout0_22) FROM=1299.9n TO=1300.1n

.meas tran Vdout0_23ck104 AVG v(dout0_23) FROM=1299.9n TO=1300.1n

.meas tran Vdout0_24ck104 AVG v(dout0_24) FROM=1299.9n TO=1300.1n

.meas tran Vdout0_25ck104 AVG v(dout0_25) FROM=1299.9n TO=1300.1n

.meas tran Vdout0_26ck104 AVG v(dout0_26) FROM=1299.9n TO=1300.1n

.meas tran Vdout0_27ck104 AVG v(dout0_27) FROM=1299.9n TO=1300.1n

.meas tran Vdout0_28ck104 AVG v(dout0_28) FROM=1299.9n TO=1300.1n

.meas tran Vdout0_29ck104 AVG v(dout0_29) FROM=1299.9n TO=1300.1n

.meas tran Vdout0_30ck104 AVG v(dout0_30) FROM=1299.9n TO=1300.1n

.meas tran Vdout0_31ck104 AVG v(dout0_31) FROM=1299.9n TO=1300.1n

.meas tran Vdout0_32ck104 AVG v(dout0_32) FROM=1299.9n TO=1300.1n

.meas tran Vdout0_33ck104 AVG v(dout0_33) FROM=1299.9n TO=1300.1n

.meas tran Vdout0_34ck104 AVG v(dout0_34) FROM=1299.9n TO=1300.1n

.meas tran Vdout0_35ck104 AVG v(dout0_35) FROM=1299.9n TO=1300.1n

.meas tran Vdout0_36ck104 AVG v(dout0_36) FROM=1299.9n TO=1300.1n

.meas tran Vdout0_37ck104 AVG v(dout0_37) FROM=1299.9n TO=1300.1n

.meas tran Vdout0_38ck104 AVG v(dout0_38) FROM=1299.9n TO=1300.1n

.meas tran Vdout0_39ck104 AVG v(dout0_39) FROM=1299.9n TO=1300.1n

.meas tran Vdout0_40ck104 AVG v(dout0_40) FROM=1299.9n TO=1300.1n

.meas tran Vdout0_41ck104 AVG v(dout0_41) FROM=1299.9n TO=1300.1n

.meas tran Vdout0_42ck104 AVG v(dout0_42) FROM=1299.9n TO=1300.1n

.meas tran Vdout0_43ck104 AVG v(dout0_43) FROM=1299.9n TO=1300.1n

.meas tran Vdout0_44ck104 AVG v(dout0_44) FROM=1299.9n TO=1300.1n

.meas tran Vdout0_45ck104 AVG v(dout0_45) FROM=1299.9n TO=1300.1n

.meas tran Vdout0_46ck104 AVG v(dout0_46) FROM=1299.9n TO=1300.1n

.meas tran Vdout0_47ck104 AVG v(dout0_47) FROM=1299.9n TO=1300.1n

.meas tran Vdout0_48ck104 AVG v(dout0_48) FROM=1299.9n TO=1300.1n

.meas tran Vdout0_49ck104 AVG v(dout0_49) FROM=1299.9n TO=1300.1n

.meas tran Vdout0_50ck104 AVG v(dout0_50) FROM=1299.9n TO=1300.1n

.meas tran Vdout0_51ck104 AVG v(dout0_51) FROM=1299.9n TO=1300.1n

.meas tran Vdout0_52ck104 AVG v(dout0_52) FROM=1299.9n TO=1300.1n

.meas tran Vdout0_53ck104 AVG v(dout0_53) FROM=1299.9n TO=1300.1n

.meas tran Vdout0_54ck104 AVG v(dout0_54) FROM=1299.9n TO=1300.1n

.meas tran Vdout0_55ck104 AVG v(dout0_55) FROM=1299.9n TO=1300.1n

.meas tran Vdout0_56ck104 AVG v(dout0_56) FROM=1299.9n TO=1300.1n

.meas tran Vdout0_57ck104 AVG v(dout0_57) FROM=1299.9n TO=1300.1n

.meas tran Vdout0_58ck104 AVG v(dout0_58) FROM=1299.9n TO=1300.1n

.meas tran Vdout0_59ck104 AVG v(dout0_59) FROM=1299.9n TO=1300.1n

.meas tran Vdout0_60ck104 AVG v(dout0_60) FROM=1299.9n TO=1300.1n

.meas tran Vdout0_61ck104 AVG v(dout0_61) FROM=1299.9n TO=1300.1n

.meas tran Vdout0_62ck104 AVG v(dout0_62) FROM=1299.9n TO=1300.1n

.meas tran Vdout0_63ck104 AVG v(dout0_63) FROM=1299.9n TO=1300.1n

.meas tran Vdout0_64ck104 AVG v(dout0_64) FROM=1299.9n TO=1300.1n

.meas tran Vdout0_65ck104 AVG v(dout0_65) FROM=1299.9n TO=1300.1n

.meas tran Vdout0_66ck104 AVG v(dout0_66) FROM=1299.9n TO=1300.1n

.meas tran Vdout0_67ck104 AVG v(dout0_67) FROM=1299.9n TO=1300.1n

.meas tran Vdout0_68ck104 AVG v(dout0_68) FROM=1299.9n TO=1300.1n

.meas tran Vdout0_69ck104 AVG v(dout0_69) FROM=1299.9n TO=1300.1n

.meas tran Vdout0_70ck104 AVG v(dout0_70) FROM=1299.9n TO=1300.1n

.meas tran Vdout0_71ck104 AVG v(dout0_71) FROM=1299.9n TO=1300.1n

.meas tran Vdout0_72ck104 AVG v(dout0_72) FROM=1299.9n TO=1300.1n

.meas tran Vdout0_73ck104 AVG v(dout0_73) FROM=1299.9n TO=1300.1n

.meas tran Vdout0_74ck104 AVG v(dout0_74) FROM=1299.9n TO=1300.1n

.meas tran Vdout0_75ck104 AVG v(dout0_75) FROM=1299.9n TO=1300.1n

.meas tran Vdout0_76ck104 AVG v(dout0_76) FROM=1299.9n TO=1300.1n

.meas tran Vdout0_77ck104 AVG v(dout0_77) FROM=1299.9n TO=1300.1n

.meas tran Vdout0_78ck104 AVG v(dout0_78) FROM=1299.9n TO=1300.1n

.meas tran Vdout0_79ck104 AVG v(dout0_79) FROM=1299.9n TO=1300.1n

.meas tran Vdout0_0ck105 AVG v(dout0_0) FROM=1319.9n TO=1320.1n

.meas tran Vdout0_1ck105 AVG v(dout0_1) FROM=1319.9n TO=1320.1n

.meas tran Vdout0_2ck105 AVG v(dout0_2) FROM=1319.9n TO=1320.1n

.meas tran Vdout0_3ck105 AVG v(dout0_3) FROM=1319.9n TO=1320.1n

.meas tran Vdout0_4ck105 AVG v(dout0_4) FROM=1319.9n TO=1320.1n

.meas tran Vdout0_5ck105 AVG v(dout0_5) FROM=1319.9n TO=1320.1n

.meas tran Vdout0_6ck105 AVG v(dout0_6) FROM=1319.9n TO=1320.1n

.meas tran Vdout0_7ck105 AVG v(dout0_7) FROM=1319.9n TO=1320.1n

.meas tran Vdout0_8ck105 AVG v(dout0_8) FROM=1319.9n TO=1320.1n

.meas tran Vdout0_9ck105 AVG v(dout0_9) FROM=1319.9n TO=1320.1n

.meas tran Vdout0_10ck105 AVG v(dout0_10) FROM=1319.9n TO=1320.1n

.meas tran Vdout0_11ck105 AVG v(dout0_11) FROM=1319.9n TO=1320.1n

.meas tran Vdout0_12ck105 AVG v(dout0_12) FROM=1319.9n TO=1320.1n

.meas tran Vdout0_13ck105 AVG v(dout0_13) FROM=1319.9n TO=1320.1n

.meas tran Vdout0_14ck105 AVG v(dout0_14) FROM=1319.9n TO=1320.1n

.meas tran Vdout0_15ck105 AVG v(dout0_15) FROM=1319.9n TO=1320.1n

.meas tran Vdout0_16ck105 AVG v(dout0_16) FROM=1319.9n TO=1320.1n

.meas tran Vdout0_17ck105 AVG v(dout0_17) FROM=1319.9n TO=1320.1n

.meas tran Vdout0_18ck105 AVG v(dout0_18) FROM=1319.9n TO=1320.1n

.meas tran Vdout0_19ck105 AVG v(dout0_19) FROM=1319.9n TO=1320.1n

.meas tran Vdout0_20ck105 AVG v(dout0_20) FROM=1319.9n TO=1320.1n

.meas tran Vdout0_21ck105 AVG v(dout0_21) FROM=1319.9n TO=1320.1n

.meas tran Vdout0_22ck105 AVG v(dout0_22) FROM=1319.9n TO=1320.1n

.meas tran Vdout0_23ck105 AVG v(dout0_23) FROM=1319.9n TO=1320.1n

.meas tran Vdout0_24ck105 AVG v(dout0_24) FROM=1319.9n TO=1320.1n

.meas tran Vdout0_25ck105 AVG v(dout0_25) FROM=1319.9n TO=1320.1n

.meas tran Vdout0_26ck105 AVG v(dout0_26) FROM=1319.9n TO=1320.1n

.meas tran Vdout0_27ck105 AVG v(dout0_27) FROM=1319.9n TO=1320.1n

.meas tran Vdout0_28ck105 AVG v(dout0_28) FROM=1319.9n TO=1320.1n

.meas tran Vdout0_29ck105 AVG v(dout0_29) FROM=1319.9n TO=1320.1n

.meas tran Vdout0_30ck105 AVG v(dout0_30) FROM=1319.9n TO=1320.1n

.meas tran Vdout0_31ck105 AVG v(dout0_31) FROM=1319.9n TO=1320.1n

.meas tran Vdout0_32ck105 AVG v(dout0_32) FROM=1319.9n TO=1320.1n

.meas tran Vdout0_33ck105 AVG v(dout0_33) FROM=1319.9n TO=1320.1n

.meas tran Vdout0_34ck105 AVG v(dout0_34) FROM=1319.9n TO=1320.1n

.meas tran Vdout0_35ck105 AVG v(dout0_35) FROM=1319.9n TO=1320.1n

.meas tran Vdout0_36ck105 AVG v(dout0_36) FROM=1319.9n TO=1320.1n

.meas tran Vdout0_37ck105 AVG v(dout0_37) FROM=1319.9n TO=1320.1n

.meas tran Vdout0_38ck105 AVG v(dout0_38) FROM=1319.9n TO=1320.1n

.meas tran Vdout0_39ck105 AVG v(dout0_39) FROM=1319.9n TO=1320.1n

.meas tran Vdout0_40ck105 AVG v(dout0_40) FROM=1319.9n TO=1320.1n

.meas tran Vdout0_41ck105 AVG v(dout0_41) FROM=1319.9n TO=1320.1n

.meas tran Vdout0_42ck105 AVG v(dout0_42) FROM=1319.9n TO=1320.1n

.meas tran Vdout0_43ck105 AVG v(dout0_43) FROM=1319.9n TO=1320.1n

.meas tran Vdout0_44ck105 AVG v(dout0_44) FROM=1319.9n TO=1320.1n

.meas tran Vdout0_45ck105 AVG v(dout0_45) FROM=1319.9n TO=1320.1n

.meas tran Vdout0_46ck105 AVG v(dout0_46) FROM=1319.9n TO=1320.1n

.meas tran Vdout0_47ck105 AVG v(dout0_47) FROM=1319.9n TO=1320.1n

.meas tran Vdout0_48ck105 AVG v(dout0_48) FROM=1319.9n TO=1320.1n

.meas tran Vdout0_49ck105 AVG v(dout0_49) FROM=1319.9n TO=1320.1n

.meas tran Vdout0_50ck105 AVG v(dout0_50) FROM=1319.9n TO=1320.1n

.meas tran Vdout0_51ck105 AVG v(dout0_51) FROM=1319.9n TO=1320.1n

.meas tran Vdout0_52ck105 AVG v(dout0_52) FROM=1319.9n TO=1320.1n

.meas tran Vdout0_53ck105 AVG v(dout0_53) FROM=1319.9n TO=1320.1n

.meas tran Vdout0_54ck105 AVG v(dout0_54) FROM=1319.9n TO=1320.1n

.meas tran Vdout0_55ck105 AVG v(dout0_55) FROM=1319.9n TO=1320.1n

.meas tran Vdout0_56ck105 AVG v(dout0_56) FROM=1319.9n TO=1320.1n

.meas tran Vdout0_57ck105 AVG v(dout0_57) FROM=1319.9n TO=1320.1n

.meas tran Vdout0_58ck105 AVG v(dout0_58) FROM=1319.9n TO=1320.1n

.meas tran Vdout0_59ck105 AVG v(dout0_59) FROM=1319.9n TO=1320.1n

.meas tran Vdout0_60ck105 AVG v(dout0_60) FROM=1319.9n TO=1320.1n

.meas tran Vdout0_61ck105 AVG v(dout0_61) FROM=1319.9n TO=1320.1n

.meas tran Vdout0_62ck105 AVG v(dout0_62) FROM=1319.9n TO=1320.1n

.meas tran Vdout0_63ck105 AVG v(dout0_63) FROM=1319.9n TO=1320.1n

.meas tran Vdout0_64ck105 AVG v(dout0_64) FROM=1319.9n TO=1320.1n

.meas tran Vdout0_65ck105 AVG v(dout0_65) FROM=1319.9n TO=1320.1n

.meas tran Vdout0_66ck105 AVG v(dout0_66) FROM=1319.9n TO=1320.1n

.meas tran Vdout0_67ck105 AVG v(dout0_67) FROM=1319.9n TO=1320.1n

.meas tran Vdout0_68ck105 AVG v(dout0_68) FROM=1319.9n TO=1320.1n

.meas tran Vdout0_69ck105 AVG v(dout0_69) FROM=1319.9n TO=1320.1n

.meas tran Vdout0_70ck105 AVG v(dout0_70) FROM=1319.9n TO=1320.1n

.meas tran Vdout0_71ck105 AVG v(dout0_71) FROM=1319.9n TO=1320.1n

.meas tran Vdout0_72ck105 AVG v(dout0_72) FROM=1319.9n TO=1320.1n

.meas tran Vdout0_73ck105 AVG v(dout0_73) FROM=1319.9n TO=1320.1n

.meas tran Vdout0_74ck105 AVG v(dout0_74) FROM=1319.9n TO=1320.1n

.meas tran Vdout0_75ck105 AVG v(dout0_75) FROM=1319.9n TO=1320.1n

.meas tran Vdout0_76ck105 AVG v(dout0_76) FROM=1319.9n TO=1320.1n

.meas tran Vdout0_77ck105 AVG v(dout0_77) FROM=1319.9n TO=1320.1n

.meas tran Vdout0_78ck105 AVG v(dout0_78) FROM=1319.9n TO=1320.1n

.meas tran Vdout0_79ck105 AVG v(dout0_79) FROM=1319.9n TO=1320.1n

.meas tran Vdout0_0ck106 AVG v(dout0_0) FROM=1329.9n TO=1330.1n

.meas tran Vdout0_1ck106 AVG v(dout0_1) FROM=1329.9n TO=1330.1n

.meas tran Vdout0_2ck106 AVG v(dout0_2) FROM=1329.9n TO=1330.1n

.meas tran Vdout0_3ck106 AVG v(dout0_3) FROM=1329.9n TO=1330.1n

.meas tran Vdout0_4ck106 AVG v(dout0_4) FROM=1329.9n TO=1330.1n

.meas tran Vdout0_5ck106 AVG v(dout0_5) FROM=1329.9n TO=1330.1n

.meas tran Vdout0_6ck106 AVG v(dout0_6) FROM=1329.9n TO=1330.1n

.meas tran Vdout0_7ck106 AVG v(dout0_7) FROM=1329.9n TO=1330.1n

.meas tran Vdout0_8ck106 AVG v(dout0_8) FROM=1329.9n TO=1330.1n

.meas tran Vdout0_9ck106 AVG v(dout0_9) FROM=1329.9n TO=1330.1n

.meas tran Vdout0_10ck106 AVG v(dout0_10) FROM=1329.9n TO=1330.1n

.meas tran Vdout0_11ck106 AVG v(dout0_11) FROM=1329.9n TO=1330.1n

.meas tran Vdout0_12ck106 AVG v(dout0_12) FROM=1329.9n TO=1330.1n

.meas tran Vdout0_13ck106 AVG v(dout0_13) FROM=1329.9n TO=1330.1n

.meas tran Vdout0_14ck106 AVG v(dout0_14) FROM=1329.9n TO=1330.1n

.meas tran Vdout0_15ck106 AVG v(dout0_15) FROM=1329.9n TO=1330.1n

.meas tran Vdout0_16ck106 AVG v(dout0_16) FROM=1329.9n TO=1330.1n

.meas tran Vdout0_17ck106 AVG v(dout0_17) FROM=1329.9n TO=1330.1n

.meas tran Vdout0_18ck106 AVG v(dout0_18) FROM=1329.9n TO=1330.1n

.meas tran Vdout0_19ck106 AVG v(dout0_19) FROM=1329.9n TO=1330.1n

.meas tran Vdout0_20ck106 AVG v(dout0_20) FROM=1329.9n TO=1330.1n

.meas tran Vdout0_21ck106 AVG v(dout0_21) FROM=1329.9n TO=1330.1n

.meas tran Vdout0_22ck106 AVG v(dout0_22) FROM=1329.9n TO=1330.1n

.meas tran Vdout0_23ck106 AVG v(dout0_23) FROM=1329.9n TO=1330.1n

.meas tran Vdout0_24ck106 AVG v(dout0_24) FROM=1329.9n TO=1330.1n

.meas tran Vdout0_25ck106 AVG v(dout0_25) FROM=1329.9n TO=1330.1n

.meas tran Vdout0_26ck106 AVG v(dout0_26) FROM=1329.9n TO=1330.1n

.meas tran Vdout0_27ck106 AVG v(dout0_27) FROM=1329.9n TO=1330.1n

.meas tran Vdout0_28ck106 AVG v(dout0_28) FROM=1329.9n TO=1330.1n

.meas tran Vdout0_29ck106 AVG v(dout0_29) FROM=1329.9n TO=1330.1n

.meas tran Vdout0_30ck106 AVG v(dout0_30) FROM=1329.9n TO=1330.1n

.meas tran Vdout0_31ck106 AVG v(dout0_31) FROM=1329.9n TO=1330.1n

.meas tran Vdout0_32ck106 AVG v(dout0_32) FROM=1329.9n TO=1330.1n

.meas tran Vdout0_33ck106 AVG v(dout0_33) FROM=1329.9n TO=1330.1n

.meas tran Vdout0_34ck106 AVG v(dout0_34) FROM=1329.9n TO=1330.1n

.meas tran Vdout0_35ck106 AVG v(dout0_35) FROM=1329.9n TO=1330.1n

.meas tran Vdout0_36ck106 AVG v(dout0_36) FROM=1329.9n TO=1330.1n

.meas tran Vdout0_37ck106 AVG v(dout0_37) FROM=1329.9n TO=1330.1n

.meas tran Vdout0_38ck106 AVG v(dout0_38) FROM=1329.9n TO=1330.1n

.meas tran Vdout0_39ck106 AVG v(dout0_39) FROM=1329.9n TO=1330.1n

.meas tran Vdout0_40ck106 AVG v(dout0_40) FROM=1329.9n TO=1330.1n

.meas tran Vdout0_41ck106 AVG v(dout0_41) FROM=1329.9n TO=1330.1n

.meas tran Vdout0_42ck106 AVG v(dout0_42) FROM=1329.9n TO=1330.1n

.meas tran Vdout0_43ck106 AVG v(dout0_43) FROM=1329.9n TO=1330.1n

.meas tran Vdout0_44ck106 AVG v(dout0_44) FROM=1329.9n TO=1330.1n

.meas tran Vdout0_45ck106 AVG v(dout0_45) FROM=1329.9n TO=1330.1n

.meas tran Vdout0_46ck106 AVG v(dout0_46) FROM=1329.9n TO=1330.1n

.meas tran Vdout0_47ck106 AVG v(dout0_47) FROM=1329.9n TO=1330.1n

.meas tran Vdout0_48ck106 AVG v(dout0_48) FROM=1329.9n TO=1330.1n

.meas tran Vdout0_49ck106 AVG v(dout0_49) FROM=1329.9n TO=1330.1n

.meas tran Vdout0_50ck106 AVG v(dout0_50) FROM=1329.9n TO=1330.1n

.meas tran Vdout0_51ck106 AVG v(dout0_51) FROM=1329.9n TO=1330.1n

.meas tran Vdout0_52ck106 AVG v(dout0_52) FROM=1329.9n TO=1330.1n

.meas tran Vdout0_53ck106 AVG v(dout0_53) FROM=1329.9n TO=1330.1n

.meas tran Vdout0_54ck106 AVG v(dout0_54) FROM=1329.9n TO=1330.1n

.meas tran Vdout0_55ck106 AVG v(dout0_55) FROM=1329.9n TO=1330.1n

.meas tran Vdout0_56ck106 AVG v(dout0_56) FROM=1329.9n TO=1330.1n

.meas tran Vdout0_57ck106 AVG v(dout0_57) FROM=1329.9n TO=1330.1n

.meas tran Vdout0_58ck106 AVG v(dout0_58) FROM=1329.9n TO=1330.1n

.meas tran Vdout0_59ck106 AVG v(dout0_59) FROM=1329.9n TO=1330.1n

.meas tran Vdout0_60ck106 AVG v(dout0_60) FROM=1329.9n TO=1330.1n

.meas tran Vdout0_61ck106 AVG v(dout0_61) FROM=1329.9n TO=1330.1n

.meas tran Vdout0_62ck106 AVG v(dout0_62) FROM=1329.9n TO=1330.1n

.meas tran Vdout0_63ck106 AVG v(dout0_63) FROM=1329.9n TO=1330.1n

.meas tran Vdout0_64ck106 AVG v(dout0_64) FROM=1329.9n TO=1330.1n

.meas tran Vdout0_65ck106 AVG v(dout0_65) FROM=1329.9n TO=1330.1n

.meas tran Vdout0_66ck106 AVG v(dout0_66) FROM=1329.9n TO=1330.1n

.meas tran Vdout0_67ck106 AVG v(dout0_67) FROM=1329.9n TO=1330.1n

.meas tran Vdout0_68ck106 AVG v(dout0_68) FROM=1329.9n TO=1330.1n

.meas tran Vdout0_69ck106 AVG v(dout0_69) FROM=1329.9n TO=1330.1n

.meas tran Vdout0_70ck106 AVG v(dout0_70) FROM=1329.9n TO=1330.1n

.meas tran Vdout0_71ck106 AVG v(dout0_71) FROM=1329.9n TO=1330.1n

.meas tran Vdout0_72ck106 AVG v(dout0_72) FROM=1329.9n TO=1330.1n

.meas tran Vdout0_73ck106 AVG v(dout0_73) FROM=1329.9n TO=1330.1n

.meas tran Vdout0_74ck106 AVG v(dout0_74) FROM=1329.9n TO=1330.1n

.meas tran Vdout0_75ck106 AVG v(dout0_75) FROM=1329.9n TO=1330.1n

.meas tran Vdout0_76ck106 AVG v(dout0_76) FROM=1329.9n TO=1330.1n

.meas tran Vdout0_77ck106 AVG v(dout0_77) FROM=1329.9n TO=1330.1n

.meas tran Vdout0_78ck106 AVG v(dout0_78) FROM=1329.9n TO=1330.1n

.meas tran Vdout0_79ck106 AVG v(dout0_79) FROM=1329.9n TO=1330.1n

.meas tran Vdout1_0ck107 AVG v(dout1_0) FROM=1329.9n TO=1330.1n

.meas tran Vdout1_1ck107 AVG v(dout1_1) FROM=1329.9n TO=1330.1n

.meas tran Vdout1_2ck107 AVG v(dout1_2) FROM=1329.9n TO=1330.1n

.meas tran Vdout1_3ck107 AVG v(dout1_3) FROM=1329.9n TO=1330.1n

.meas tran Vdout1_4ck107 AVG v(dout1_4) FROM=1329.9n TO=1330.1n

.meas tran Vdout1_5ck107 AVG v(dout1_5) FROM=1329.9n TO=1330.1n

.meas tran Vdout1_6ck107 AVG v(dout1_6) FROM=1329.9n TO=1330.1n

.meas tran Vdout1_7ck107 AVG v(dout1_7) FROM=1329.9n TO=1330.1n

.meas tran Vdout1_8ck107 AVG v(dout1_8) FROM=1329.9n TO=1330.1n

.meas tran Vdout1_9ck107 AVG v(dout1_9) FROM=1329.9n TO=1330.1n

.meas tran Vdout1_10ck107 AVG v(dout1_10) FROM=1329.9n TO=1330.1n

.meas tran Vdout1_11ck107 AVG v(dout1_11) FROM=1329.9n TO=1330.1n

.meas tran Vdout1_12ck107 AVG v(dout1_12) FROM=1329.9n TO=1330.1n

.meas tran Vdout1_13ck107 AVG v(dout1_13) FROM=1329.9n TO=1330.1n

.meas tran Vdout1_14ck107 AVG v(dout1_14) FROM=1329.9n TO=1330.1n

.meas tran Vdout1_15ck107 AVG v(dout1_15) FROM=1329.9n TO=1330.1n

.meas tran Vdout1_16ck107 AVG v(dout1_16) FROM=1329.9n TO=1330.1n

.meas tran Vdout1_17ck107 AVG v(dout1_17) FROM=1329.9n TO=1330.1n

.meas tran Vdout1_18ck107 AVG v(dout1_18) FROM=1329.9n TO=1330.1n

.meas tran Vdout1_19ck107 AVG v(dout1_19) FROM=1329.9n TO=1330.1n

.meas tran Vdout1_20ck107 AVG v(dout1_20) FROM=1329.9n TO=1330.1n

.meas tran Vdout1_21ck107 AVG v(dout1_21) FROM=1329.9n TO=1330.1n

.meas tran Vdout1_22ck107 AVG v(dout1_22) FROM=1329.9n TO=1330.1n

.meas tran Vdout1_23ck107 AVG v(dout1_23) FROM=1329.9n TO=1330.1n

.meas tran Vdout1_24ck107 AVG v(dout1_24) FROM=1329.9n TO=1330.1n

.meas tran Vdout1_25ck107 AVG v(dout1_25) FROM=1329.9n TO=1330.1n

.meas tran Vdout1_26ck107 AVG v(dout1_26) FROM=1329.9n TO=1330.1n

.meas tran Vdout1_27ck107 AVG v(dout1_27) FROM=1329.9n TO=1330.1n

.meas tran Vdout1_28ck107 AVG v(dout1_28) FROM=1329.9n TO=1330.1n

.meas tran Vdout1_29ck107 AVG v(dout1_29) FROM=1329.9n TO=1330.1n

.meas tran Vdout1_30ck107 AVG v(dout1_30) FROM=1329.9n TO=1330.1n

.meas tran Vdout1_31ck107 AVG v(dout1_31) FROM=1329.9n TO=1330.1n

.meas tran Vdout1_32ck107 AVG v(dout1_32) FROM=1329.9n TO=1330.1n

.meas tran Vdout1_33ck107 AVG v(dout1_33) FROM=1329.9n TO=1330.1n

.meas tran Vdout1_34ck107 AVG v(dout1_34) FROM=1329.9n TO=1330.1n

.meas tran Vdout1_35ck107 AVG v(dout1_35) FROM=1329.9n TO=1330.1n

.meas tran Vdout1_36ck107 AVG v(dout1_36) FROM=1329.9n TO=1330.1n

.meas tran Vdout1_37ck107 AVG v(dout1_37) FROM=1329.9n TO=1330.1n

.meas tran Vdout1_38ck107 AVG v(dout1_38) FROM=1329.9n TO=1330.1n

.meas tran Vdout1_39ck107 AVG v(dout1_39) FROM=1329.9n TO=1330.1n

.meas tran Vdout1_40ck107 AVG v(dout1_40) FROM=1329.9n TO=1330.1n

.meas tran Vdout1_41ck107 AVG v(dout1_41) FROM=1329.9n TO=1330.1n

.meas tran Vdout1_42ck107 AVG v(dout1_42) FROM=1329.9n TO=1330.1n

.meas tran Vdout1_43ck107 AVG v(dout1_43) FROM=1329.9n TO=1330.1n

.meas tran Vdout1_44ck107 AVG v(dout1_44) FROM=1329.9n TO=1330.1n

.meas tran Vdout1_45ck107 AVG v(dout1_45) FROM=1329.9n TO=1330.1n

.meas tran Vdout1_46ck107 AVG v(dout1_46) FROM=1329.9n TO=1330.1n

.meas tran Vdout1_47ck107 AVG v(dout1_47) FROM=1329.9n TO=1330.1n

.meas tran Vdout1_48ck107 AVG v(dout1_48) FROM=1329.9n TO=1330.1n

.meas tran Vdout1_49ck107 AVG v(dout1_49) FROM=1329.9n TO=1330.1n

.meas tran Vdout1_50ck107 AVG v(dout1_50) FROM=1329.9n TO=1330.1n

.meas tran Vdout1_51ck107 AVG v(dout1_51) FROM=1329.9n TO=1330.1n

.meas tran Vdout1_52ck107 AVG v(dout1_52) FROM=1329.9n TO=1330.1n

.meas tran Vdout1_53ck107 AVG v(dout1_53) FROM=1329.9n TO=1330.1n

.meas tran Vdout1_54ck107 AVG v(dout1_54) FROM=1329.9n TO=1330.1n

.meas tran Vdout1_55ck107 AVG v(dout1_55) FROM=1329.9n TO=1330.1n

.meas tran Vdout1_56ck107 AVG v(dout1_56) FROM=1329.9n TO=1330.1n

.meas tran Vdout1_57ck107 AVG v(dout1_57) FROM=1329.9n TO=1330.1n

.meas tran Vdout1_58ck107 AVG v(dout1_58) FROM=1329.9n TO=1330.1n

.meas tran Vdout1_59ck107 AVG v(dout1_59) FROM=1329.9n TO=1330.1n

.meas tran Vdout1_60ck107 AVG v(dout1_60) FROM=1329.9n TO=1330.1n

.meas tran Vdout1_61ck107 AVG v(dout1_61) FROM=1329.9n TO=1330.1n

.meas tran Vdout1_62ck107 AVG v(dout1_62) FROM=1329.9n TO=1330.1n

.meas tran Vdout1_63ck107 AVG v(dout1_63) FROM=1329.9n TO=1330.1n

.meas tran Vdout1_64ck107 AVG v(dout1_64) FROM=1329.9n TO=1330.1n

.meas tran Vdout1_65ck107 AVG v(dout1_65) FROM=1329.9n TO=1330.1n

.meas tran Vdout1_66ck107 AVG v(dout1_66) FROM=1329.9n TO=1330.1n

.meas tran Vdout1_67ck107 AVG v(dout1_67) FROM=1329.9n TO=1330.1n

.meas tran Vdout1_68ck107 AVG v(dout1_68) FROM=1329.9n TO=1330.1n

.meas tran Vdout1_69ck107 AVG v(dout1_69) FROM=1329.9n TO=1330.1n

.meas tran Vdout1_70ck107 AVG v(dout1_70) FROM=1329.9n TO=1330.1n

.meas tran Vdout1_71ck107 AVG v(dout1_71) FROM=1329.9n TO=1330.1n

.meas tran Vdout1_72ck107 AVG v(dout1_72) FROM=1329.9n TO=1330.1n

.meas tran Vdout1_73ck107 AVG v(dout1_73) FROM=1329.9n TO=1330.1n

.meas tran Vdout1_74ck107 AVG v(dout1_74) FROM=1329.9n TO=1330.1n

.meas tran Vdout1_75ck107 AVG v(dout1_75) FROM=1329.9n TO=1330.1n

.meas tran Vdout1_76ck107 AVG v(dout1_76) FROM=1329.9n TO=1330.1n

.meas tran Vdout1_77ck107 AVG v(dout1_77) FROM=1329.9n TO=1330.1n

.meas tran Vdout1_78ck107 AVG v(dout1_78) FROM=1329.9n TO=1330.1n

.meas tran Vdout1_79ck107 AVG v(dout1_79) FROM=1329.9n TO=1330.1n

.meas tran Vdout0_0ck108 AVG v(dout0_0) FROM=1339.9n TO=1340.1n

.meas tran Vdout0_1ck108 AVG v(dout0_1) FROM=1339.9n TO=1340.1n

.meas tran Vdout0_2ck108 AVG v(dout0_2) FROM=1339.9n TO=1340.1n

.meas tran Vdout0_3ck108 AVG v(dout0_3) FROM=1339.9n TO=1340.1n

.meas tran Vdout0_4ck108 AVG v(dout0_4) FROM=1339.9n TO=1340.1n

.meas tran Vdout0_5ck108 AVG v(dout0_5) FROM=1339.9n TO=1340.1n

.meas tran Vdout0_6ck108 AVG v(dout0_6) FROM=1339.9n TO=1340.1n

.meas tran Vdout0_7ck108 AVG v(dout0_7) FROM=1339.9n TO=1340.1n

.meas tran Vdout0_8ck108 AVG v(dout0_8) FROM=1339.9n TO=1340.1n

.meas tran Vdout0_9ck108 AVG v(dout0_9) FROM=1339.9n TO=1340.1n

.meas tran Vdout0_10ck108 AVG v(dout0_10) FROM=1339.9n TO=1340.1n

.meas tran Vdout0_11ck108 AVG v(dout0_11) FROM=1339.9n TO=1340.1n

.meas tran Vdout0_12ck108 AVG v(dout0_12) FROM=1339.9n TO=1340.1n

.meas tran Vdout0_13ck108 AVG v(dout0_13) FROM=1339.9n TO=1340.1n

.meas tran Vdout0_14ck108 AVG v(dout0_14) FROM=1339.9n TO=1340.1n

.meas tran Vdout0_15ck108 AVG v(dout0_15) FROM=1339.9n TO=1340.1n

.meas tran Vdout0_16ck108 AVG v(dout0_16) FROM=1339.9n TO=1340.1n

.meas tran Vdout0_17ck108 AVG v(dout0_17) FROM=1339.9n TO=1340.1n

.meas tran Vdout0_18ck108 AVG v(dout0_18) FROM=1339.9n TO=1340.1n

.meas tran Vdout0_19ck108 AVG v(dout0_19) FROM=1339.9n TO=1340.1n

.meas tran Vdout0_20ck108 AVG v(dout0_20) FROM=1339.9n TO=1340.1n

.meas tran Vdout0_21ck108 AVG v(dout0_21) FROM=1339.9n TO=1340.1n

.meas tran Vdout0_22ck108 AVG v(dout0_22) FROM=1339.9n TO=1340.1n

.meas tran Vdout0_23ck108 AVG v(dout0_23) FROM=1339.9n TO=1340.1n

.meas tran Vdout0_24ck108 AVG v(dout0_24) FROM=1339.9n TO=1340.1n

.meas tran Vdout0_25ck108 AVG v(dout0_25) FROM=1339.9n TO=1340.1n

.meas tran Vdout0_26ck108 AVG v(dout0_26) FROM=1339.9n TO=1340.1n

.meas tran Vdout0_27ck108 AVG v(dout0_27) FROM=1339.9n TO=1340.1n

.meas tran Vdout0_28ck108 AVG v(dout0_28) FROM=1339.9n TO=1340.1n

.meas tran Vdout0_29ck108 AVG v(dout0_29) FROM=1339.9n TO=1340.1n

.meas tran Vdout0_30ck108 AVG v(dout0_30) FROM=1339.9n TO=1340.1n

.meas tran Vdout0_31ck108 AVG v(dout0_31) FROM=1339.9n TO=1340.1n

.meas tran Vdout0_32ck108 AVG v(dout0_32) FROM=1339.9n TO=1340.1n

.meas tran Vdout0_33ck108 AVG v(dout0_33) FROM=1339.9n TO=1340.1n

.meas tran Vdout0_34ck108 AVG v(dout0_34) FROM=1339.9n TO=1340.1n

.meas tran Vdout0_35ck108 AVG v(dout0_35) FROM=1339.9n TO=1340.1n

.meas tran Vdout0_36ck108 AVG v(dout0_36) FROM=1339.9n TO=1340.1n

.meas tran Vdout0_37ck108 AVG v(dout0_37) FROM=1339.9n TO=1340.1n

.meas tran Vdout0_38ck108 AVG v(dout0_38) FROM=1339.9n TO=1340.1n

.meas tran Vdout0_39ck108 AVG v(dout0_39) FROM=1339.9n TO=1340.1n

.meas tran Vdout0_40ck108 AVG v(dout0_40) FROM=1339.9n TO=1340.1n

.meas tran Vdout0_41ck108 AVG v(dout0_41) FROM=1339.9n TO=1340.1n

.meas tran Vdout0_42ck108 AVG v(dout0_42) FROM=1339.9n TO=1340.1n

.meas tran Vdout0_43ck108 AVG v(dout0_43) FROM=1339.9n TO=1340.1n

.meas tran Vdout0_44ck108 AVG v(dout0_44) FROM=1339.9n TO=1340.1n

.meas tran Vdout0_45ck108 AVG v(dout0_45) FROM=1339.9n TO=1340.1n

.meas tran Vdout0_46ck108 AVG v(dout0_46) FROM=1339.9n TO=1340.1n

.meas tran Vdout0_47ck108 AVG v(dout0_47) FROM=1339.9n TO=1340.1n

.meas tran Vdout0_48ck108 AVG v(dout0_48) FROM=1339.9n TO=1340.1n

.meas tran Vdout0_49ck108 AVG v(dout0_49) FROM=1339.9n TO=1340.1n

.meas tran Vdout0_50ck108 AVG v(dout0_50) FROM=1339.9n TO=1340.1n

.meas tran Vdout0_51ck108 AVG v(dout0_51) FROM=1339.9n TO=1340.1n

.meas tran Vdout0_52ck108 AVG v(dout0_52) FROM=1339.9n TO=1340.1n

.meas tran Vdout0_53ck108 AVG v(dout0_53) FROM=1339.9n TO=1340.1n

.meas tran Vdout0_54ck108 AVG v(dout0_54) FROM=1339.9n TO=1340.1n

.meas tran Vdout0_55ck108 AVG v(dout0_55) FROM=1339.9n TO=1340.1n

.meas tran Vdout0_56ck108 AVG v(dout0_56) FROM=1339.9n TO=1340.1n

.meas tran Vdout0_57ck108 AVG v(dout0_57) FROM=1339.9n TO=1340.1n

.meas tran Vdout0_58ck108 AVG v(dout0_58) FROM=1339.9n TO=1340.1n

.meas tran Vdout0_59ck108 AVG v(dout0_59) FROM=1339.9n TO=1340.1n

.meas tran Vdout0_60ck108 AVG v(dout0_60) FROM=1339.9n TO=1340.1n

.meas tran Vdout0_61ck108 AVG v(dout0_61) FROM=1339.9n TO=1340.1n

.meas tran Vdout0_62ck108 AVG v(dout0_62) FROM=1339.9n TO=1340.1n

.meas tran Vdout0_63ck108 AVG v(dout0_63) FROM=1339.9n TO=1340.1n

.meas tran Vdout0_64ck108 AVG v(dout0_64) FROM=1339.9n TO=1340.1n

.meas tran Vdout0_65ck108 AVG v(dout0_65) FROM=1339.9n TO=1340.1n

.meas tran Vdout0_66ck108 AVG v(dout0_66) FROM=1339.9n TO=1340.1n

.meas tran Vdout0_67ck108 AVG v(dout0_67) FROM=1339.9n TO=1340.1n

.meas tran Vdout0_68ck108 AVG v(dout0_68) FROM=1339.9n TO=1340.1n

.meas tran Vdout0_69ck108 AVG v(dout0_69) FROM=1339.9n TO=1340.1n

.meas tran Vdout0_70ck108 AVG v(dout0_70) FROM=1339.9n TO=1340.1n

.meas tran Vdout0_71ck108 AVG v(dout0_71) FROM=1339.9n TO=1340.1n

.meas tran Vdout0_72ck108 AVG v(dout0_72) FROM=1339.9n TO=1340.1n

.meas tran Vdout0_73ck108 AVG v(dout0_73) FROM=1339.9n TO=1340.1n

.meas tran Vdout0_74ck108 AVG v(dout0_74) FROM=1339.9n TO=1340.1n

.meas tran Vdout0_75ck108 AVG v(dout0_75) FROM=1339.9n TO=1340.1n

.meas tran Vdout0_76ck108 AVG v(dout0_76) FROM=1339.9n TO=1340.1n

.meas tran Vdout0_77ck108 AVG v(dout0_77) FROM=1339.9n TO=1340.1n

.meas tran Vdout0_78ck108 AVG v(dout0_78) FROM=1339.9n TO=1340.1n

.meas tran Vdout0_79ck108 AVG v(dout0_79) FROM=1339.9n TO=1340.1n

.meas tran Vdout1_0ck109 AVG v(dout1_0) FROM=1339.9n TO=1340.1n

.meas tran Vdout1_1ck109 AVG v(dout1_1) FROM=1339.9n TO=1340.1n

.meas tran Vdout1_2ck109 AVG v(dout1_2) FROM=1339.9n TO=1340.1n

.meas tran Vdout1_3ck109 AVG v(dout1_3) FROM=1339.9n TO=1340.1n

.meas tran Vdout1_4ck109 AVG v(dout1_4) FROM=1339.9n TO=1340.1n

.meas tran Vdout1_5ck109 AVG v(dout1_5) FROM=1339.9n TO=1340.1n

.meas tran Vdout1_6ck109 AVG v(dout1_6) FROM=1339.9n TO=1340.1n

.meas tran Vdout1_7ck109 AVG v(dout1_7) FROM=1339.9n TO=1340.1n

.meas tran Vdout1_8ck109 AVG v(dout1_8) FROM=1339.9n TO=1340.1n

.meas tran Vdout1_9ck109 AVG v(dout1_9) FROM=1339.9n TO=1340.1n

.meas tran Vdout1_10ck109 AVG v(dout1_10) FROM=1339.9n TO=1340.1n

.meas tran Vdout1_11ck109 AVG v(dout1_11) FROM=1339.9n TO=1340.1n

.meas tran Vdout1_12ck109 AVG v(dout1_12) FROM=1339.9n TO=1340.1n

.meas tran Vdout1_13ck109 AVG v(dout1_13) FROM=1339.9n TO=1340.1n

.meas tran Vdout1_14ck109 AVG v(dout1_14) FROM=1339.9n TO=1340.1n

.meas tran Vdout1_15ck109 AVG v(dout1_15) FROM=1339.9n TO=1340.1n

.meas tran Vdout1_16ck109 AVG v(dout1_16) FROM=1339.9n TO=1340.1n

.meas tran Vdout1_17ck109 AVG v(dout1_17) FROM=1339.9n TO=1340.1n

.meas tran Vdout1_18ck109 AVG v(dout1_18) FROM=1339.9n TO=1340.1n

.meas tran Vdout1_19ck109 AVG v(dout1_19) FROM=1339.9n TO=1340.1n

.meas tran Vdout1_20ck109 AVG v(dout1_20) FROM=1339.9n TO=1340.1n

.meas tran Vdout1_21ck109 AVG v(dout1_21) FROM=1339.9n TO=1340.1n

.meas tran Vdout1_22ck109 AVG v(dout1_22) FROM=1339.9n TO=1340.1n

.meas tran Vdout1_23ck109 AVG v(dout1_23) FROM=1339.9n TO=1340.1n

.meas tran Vdout1_24ck109 AVG v(dout1_24) FROM=1339.9n TO=1340.1n

.meas tran Vdout1_25ck109 AVG v(dout1_25) FROM=1339.9n TO=1340.1n

.meas tran Vdout1_26ck109 AVG v(dout1_26) FROM=1339.9n TO=1340.1n

.meas tran Vdout1_27ck109 AVG v(dout1_27) FROM=1339.9n TO=1340.1n

.meas tran Vdout1_28ck109 AVG v(dout1_28) FROM=1339.9n TO=1340.1n

.meas tran Vdout1_29ck109 AVG v(dout1_29) FROM=1339.9n TO=1340.1n

.meas tran Vdout1_30ck109 AVG v(dout1_30) FROM=1339.9n TO=1340.1n

.meas tran Vdout1_31ck109 AVG v(dout1_31) FROM=1339.9n TO=1340.1n

.meas tran Vdout1_32ck109 AVG v(dout1_32) FROM=1339.9n TO=1340.1n

.meas tran Vdout1_33ck109 AVG v(dout1_33) FROM=1339.9n TO=1340.1n

.meas tran Vdout1_34ck109 AVG v(dout1_34) FROM=1339.9n TO=1340.1n

.meas tran Vdout1_35ck109 AVG v(dout1_35) FROM=1339.9n TO=1340.1n

.meas tran Vdout1_36ck109 AVG v(dout1_36) FROM=1339.9n TO=1340.1n

.meas tran Vdout1_37ck109 AVG v(dout1_37) FROM=1339.9n TO=1340.1n

.meas tran Vdout1_38ck109 AVG v(dout1_38) FROM=1339.9n TO=1340.1n

.meas tran Vdout1_39ck109 AVG v(dout1_39) FROM=1339.9n TO=1340.1n

.meas tran Vdout1_40ck109 AVG v(dout1_40) FROM=1339.9n TO=1340.1n

.meas tran Vdout1_41ck109 AVG v(dout1_41) FROM=1339.9n TO=1340.1n

.meas tran Vdout1_42ck109 AVG v(dout1_42) FROM=1339.9n TO=1340.1n

.meas tran Vdout1_43ck109 AVG v(dout1_43) FROM=1339.9n TO=1340.1n

.meas tran Vdout1_44ck109 AVG v(dout1_44) FROM=1339.9n TO=1340.1n

.meas tran Vdout1_45ck109 AVG v(dout1_45) FROM=1339.9n TO=1340.1n

.meas tran Vdout1_46ck109 AVG v(dout1_46) FROM=1339.9n TO=1340.1n

.meas tran Vdout1_47ck109 AVG v(dout1_47) FROM=1339.9n TO=1340.1n

.meas tran Vdout1_48ck109 AVG v(dout1_48) FROM=1339.9n TO=1340.1n

.meas tran Vdout1_49ck109 AVG v(dout1_49) FROM=1339.9n TO=1340.1n

.meas tran Vdout1_50ck109 AVG v(dout1_50) FROM=1339.9n TO=1340.1n

.meas tran Vdout1_51ck109 AVG v(dout1_51) FROM=1339.9n TO=1340.1n

.meas tran Vdout1_52ck109 AVG v(dout1_52) FROM=1339.9n TO=1340.1n

.meas tran Vdout1_53ck109 AVG v(dout1_53) FROM=1339.9n TO=1340.1n

.meas tran Vdout1_54ck109 AVG v(dout1_54) FROM=1339.9n TO=1340.1n

.meas tran Vdout1_55ck109 AVG v(dout1_55) FROM=1339.9n TO=1340.1n

.meas tran Vdout1_56ck109 AVG v(dout1_56) FROM=1339.9n TO=1340.1n

.meas tran Vdout1_57ck109 AVG v(dout1_57) FROM=1339.9n TO=1340.1n

.meas tran Vdout1_58ck109 AVG v(dout1_58) FROM=1339.9n TO=1340.1n

.meas tran Vdout1_59ck109 AVG v(dout1_59) FROM=1339.9n TO=1340.1n

.meas tran Vdout1_60ck109 AVG v(dout1_60) FROM=1339.9n TO=1340.1n

.meas tran Vdout1_61ck109 AVG v(dout1_61) FROM=1339.9n TO=1340.1n

.meas tran Vdout1_62ck109 AVG v(dout1_62) FROM=1339.9n TO=1340.1n

.meas tran Vdout1_63ck109 AVG v(dout1_63) FROM=1339.9n TO=1340.1n

.meas tran Vdout1_64ck109 AVG v(dout1_64) FROM=1339.9n TO=1340.1n

.meas tran Vdout1_65ck109 AVG v(dout1_65) FROM=1339.9n TO=1340.1n

.meas tran Vdout1_66ck109 AVG v(dout1_66) FROM=1339.9n TO=1340.1n

.meas tran Vdout1_67ck109 AVG v(dout1_67) FROM=1339.9n TO=1340.1n

.meas tran Vdout1_68ck109 AVG v(dout1_68) FROM=1339.9n TO=1340.1n

.meas tran Vdout1_69ck109 AVG v(dout1_69) FROM=1339.9n TO=1340.1n

.meas tran Vdout1_70ck109 AVG v(dout1_70) FROM=1339.9n TO=1340.1n

.meas tran Vdout1_71ck109 AVG v(dout1_71) FROM=1339.9n TO=1340.1n

.meas tran Vdout1_72ck109 AVG v(dout1_72) FROM=1339.9n TO=1340.1n

.meas tran Vdout1_73ck109 AVG v(dout1_73) FROM=1339.9n TO=1340.1n

.meas tran Vdout1_74ck109 AVG v(dout1_74) FROM=1339.9n TO=1340.1n

.meas tran Vdout1_75ck109 AVG v(dout1_75) FROM=1339.9n TO=1340.1n

.meas tran Vdout1_76ck109 AVG v(dout1_76) FROM=1339.9n TO=1340.1n

.meas tran Vdout1_77ck109 AVG v(dout1_77) FROM=1339.9n TO=1340.1n

.meas tran Vdout1_78ck109 AVG v(dout1_78) FROM=1339.9n TO=1340.1n

.meas tran Vdout1_79ck109 AVG v(dout1_79) FROM=1339.9n TO=1340.1n

.meas tran Vdout1_0ck110 AVG v(dout1_0) FROM=1359.9n TO=1360.1n

.meas tran Vdout1_1ck110 AVG v(dout1_1) FROM=1359.9n TO=1360.1n

.meas tran Vdout1_2ck110 AVG v(dout1_2) FROM=1359.9n TO=1360.1n

.meas tran Vdout1_3ck110 AVG v(dout1_3) FROM=1359.9n TO=1360.1n

.meas tran Vdout1_4ck110 AVG v(dout1_4) FROM=1359.9n TO=1360.1n

.meas tran Vdout1_5ck110 AVG v(dout1_5) FROM=1359.9n TO=1360.1n

.meas tran Vdout1_6ck110 AVG v(dout1_6) FROM=1359.9n TO=1360.1n

.meas tran Vdout1_7ck110 AVG v(dout1_7) FROM=1359.9n TO=1360.1n

.meas tran Vdout1_8ck110 AVG v(dout1_8) FROM=1359.9n TO=1360.1n

.meas tran Vdout1_9ck110 AVG v(dout1_9) FROM=1359.9n TO=1360.1n

.meas tran Vdout1_10ck110 AVG v(dout1_10) FROM=1359.9n TO=1360.1n

.meas tran Vdout1_11ck110 AVG v(dout1_11) FROM=1359.9n TO=1360.1n

.meas tran Vdout1_12ck110 AVG v(dout1_12) FROM=1359.9n TO=1360.1n

.meas tran Vdout1_13ck110 AVG v(dout1_13) FROM=1359.9n TO=1360.1n

.meas tran Vdout1_14ck110 AVG v(dout1_14) FROM=1359.9n TO=1360.1n

.meas tran Vdout1_15ck110 AVG v(dout1_15) FROM=1359.9n TO=1360.1n

.meas tran Vdout1_16ck110 AVG v(dout1_16) FROM=1359.9n TO=1360.1n

.meas tran Vdout1_17ck110 AVG v(dout1_17) FROM=1359.9n TO=1360.1n

.meas tran Vdout1_18ck110 AVG v(dout1_18) FROM=1359.9n TO=1360.1n

.meas tran Vdout1_19ck110 AVG v(dout1_19) FROM=1359.9n TO=1360.1n

.meas tran Vdout1_20ck110 AVG v(dout1_20) FROM=1359.9n TO=1360.1n

.meas tran Vdout1_21ck110 AVG v(dout1_21) FROM=1359.9n TO=1360.1n

.meas tran Vdout1_22ck110 AVG v(dout1_22) FROM=1359.9n TO=1360.1n

.meas tran Vdout1_23ck110 AVG v(dout1_23) FROM=1359.9n TO=1360.1n

.meas tran Vdout1_24ck110 AVG v(dout1_24) FROM=1359.9n TO=1360.1n

.meas tran Vdout1_25ck110 AVG v(dout1_25) FROM=1359.9n TO=1360.1n

.meas tran Vdout1_26ck110 AVG v(dout1_26) FROM=1359.9n TO=1360.1n

.meas tran Vdout1_27ck110 AVG v(dout1_27) FROM=1359.9n TO=1360.1n

.meas tran Vdout1_28ck110 AVG v(dout1_28) FROM=1359.9n TO=1360.1n

.meas tran Vdout1_29ck110 AVG v(dout1_29) FROM=1359.9n TO=1360.1n

.meas tran Vdout1_30ck110 AVG v(dout1_30) FROM=1359.9n TO=1360.1n

.meas tran Vdout1_31ck110 AVG v(dout1_31) FROM=1359.9n TO=1360.1n

.meas tran Vdout1_32ck110 AVG v(dout1_32) FROM=1359.9n TO=1360.1n

.meas tran Vdout1_33ck110 AVG v(dout1_33) FROM=1359.9n TO=1360.1n

.meas tran Vdout1_34ck110 AVG v(dout1_34) FROM=1359.9n TO=1360.1n

.meas tran Vdout1_35ck110 AVG v(dout1_35) FROM=1359.9n TO=1360.1n

.meas tran Vdout1_36ck110 AVG v(dout1_36) FROM=1359.9n TO=1360.1n

.meas tran Vdout1_37ck110 AVG v(dout1_37) FROM=1359.9n TO=1360.1n

.meas tran Vdout1_38ck110 AVG v(dout1_38) FROM=1359.9n TO=1360.1n

.meas tran Vdout1_39ck110 AVG v(dout1_39) FROM=1359.9n TO=1360.1n

.meas tran Vdout1_40ck110 AVG v(dout1_40) FROM=1359.9n TO=1360.1n

.meas tran Vdout1_41ck110 AVG v(dout1_41) FROM=1359.9n TO=1360.1n

.meas tran Vdout1_42ck110 AVG v(dout1_42) FROM=1359.9n TO=1360.1n

.meas tran Vdout1_43ck110 AVG v(dout1_43) FROM=1359.9n TO=1360.1n

.meas tran Vdout1_44ck110 AVG v(dout1_44) FROM=1359.9n TO=1360.1n

.meas tran Vdout1_45ck110 AVG v(dout1_45) FROM=1359.9n TO=1360.1n

.meas tran Vdout1_46ck110 AVG v(dout1_46) FROM=1359.9n TO=1360.1n

.meas tran Vdout1_47ck110 AVG v(dout1_47) FROM=1359.9n TO=1360.1n

.meas tran Vdout1_48ck110 AVG v(dout1_48) FROM=1359.9n TO=1360.1n

.meas tran Vdout1_49ck110 AVG v(dout1_49) FROM=1359.9n TO=1360.1n

.meas tran Vdout1_50ck110 AVG v(dout1_50) FROM=1359.9n TO=1360.1n

.meas tran Vdout1_51ck110 AVG v(dout1_51) FROM=1359.9n TO=1360.1n

.meas tran Vdout1_52ck110 AVG v(dout1_52) FROM=1359.9n TO=1360.1n

.meas tran Vdout1_53ck110 AVG v(dout1_53) FROM=1359.9n TO=1360.1n

.meas tran Vdout1_54ck110 AVG v(dout1_54) FROM=1359.9n TO=1360.1n

.meas tran Vdout1_55ck110 AVG v(dout1_55) FROM=1359.9n TO=1360.1n

.meas tran Vdout1_56ck110 AVG v(dout1_56) FROM=1359.9n TO=1360.1n

.meas tran Vdout1_57ck110 AVG v(dout1_57) FROM=1359.9n TO=1360.1n

.meas tran Vdout1_58ck110 AVG v(dout1_58) FROM=1359.9n TO=1360.1n

.meas tran Vdout1_59ck110 AVG v(dout1_59) FROM=1359.9n TO=1360.1n

.meas tran Vdout1_60ck110 AVG v(dout1_60) FROM=1359.9n TO=1360.1n

.meas tran Vdout1_61ck110 AVG v(dout1_61) FROM=1359.9n TO=1360.1n

.meas tran Vdout1_62ck110 AVG v(dout1_62) FROM=1359.9n TO=1360.1n

.meas tran Vdout1_63ck110 AVG v(dout1_63) FROM=1359.9n TO=1360.1n

.meas tran Vdout1_64ck110 AVG v(dout1_64) FROM=1359.9n TO=1360.1n

.meas tran Vdout1_65ck110 AVG v(dout1_65) FROM=1359.9n TO=1360.1n

.meas tran Vdout1_66ck110 AVG v(dout1_66) FROM=1359.9n TO=1360.1n

.meas tran Vdout1_67ck110 AVG v(dout1_67) FROM=1359.9n TO=1360.1n

.meas tran Vdout1_68ck110 AVG v(dout1_68) FROM=1359.9n TO=1360.1n

.meas tran Vdout1_69ck110 AVG v(dout1_69) FROM=1359.9n TO=1360.1n

.meas tran Vdout1_70ck110 AVG v(dout1_70) FROM=1359.9n TO=1360.1n

.meas tran Vdout1_71ck110 AVG v(dout1_71) FROM=1359.9n TO=1360.1n

.meas tran Vdout1_72ck110 AVG v(dout1_72) FROM=1359.9n TO=1360.1n

.meas tran Vdout1_73ck110 AVG v(dout1_73) FROM=1359.9n TO=1360.1n

.meas tran Vdout1_74ck110 AVG v(dout1_74) FROM=1359.9n TO=1360.1n

.meas tran Vdout1_75ck110 AVG v(dout1_75) FROM=1359.9n TO=1360.1n

.meas tran Vdout1_76ck110 AVG v(dout1_76) FROM=1359.9n TO=1360.1n

.meas tran Vdout1_77ck110 AVG v(dout1_77) FROM=1359.9n TO=1360.1n

.meas tran Vdout1_78ck110 AVG v(dout1_78) FROM=1359.9n TO=1360.1n

.meas tran Vdout1_79ck110 AVG v(dout1_79) FROM=1359.9n TO=1360.1n

.meas tran Vdout1_0ck111 AVG v(dout1_0) FROM=1369.9n TO=1370.1n

.meas tran Vdout1_1ck111 AVG v(dout1_1) FROM=1369.9n TO=1370.1n

.meas tran Vdout1_2ck111 AVG v(dout1_2) FROM=1369.9n TO=1370.1n

.meas tran Vdout1_3ck111 AVG v(dout1_3) FROM=1369.9n TO=1370.1n

.meas tran Vdout1_4ck111 AVG v(dout1_4) FROM=1369.9n TO=1370.1n

.meas tran Vdout1_5ck111 AVG v(dout1_5) FROM=1369.9n TO=1370.1n

.meas tran Vdout1_6ck111 AVG v(dout1_6) FROM=1369.9n TO=1370.1n

.meas tran Vdout1_7ck111 AVG v(dout1_7) FROM=1369.9n TO=1370.1n

.meas tran Vdout1_8ck111 AVG v(dout1_8) FROM=1369.9n TO=1370.1n

.meas tran Vdout1_9ck111 AVG v(dout1_9) FROM=1369.9n TO=1370.1n

.meas tran Vdout1_10ck111 AVG v(dout1_10) FROM=1369.9n TO=1370.1n

.meas tran Vdout1_11ck111 AVG v(dout1_11) FROM=1369.9n TO=1370.1n

.meas tran Vdout1_12ck111 AVG v(dout1_12) FROM=1369.9n TO=1370.1n

.meas tran Vdout1_13ck111 AVG v(dout1_13) FROM=1369.9n TO=1370.1n

.meas tran Vdout1_14ck111 AVG v(dout1_14) FROM=1369.9n TO=1370.1n

.meas tran Vdout1_15ck111 AVG v(dout1_15) FROM=1369.9n TO=1370.1n

.meas tran Vdout1_16ck111 AVG v(dout1_16) FROM=1369.9n TO=1370.1n

.meas tran Vdout1_17ck111 AVG v(dout1_17) FROM=1369.9n TO=1370.1n

.meas tran Vdout1_18ck111 AVG v(dout1_18) FROM=1369.9n TO=1370.1n

.meas tran Vdout1_19ck111 AVG v(dout1_19) FROM=1369.9n TO=1370.1n

.meas tran Vdout1_20ck111 AVG v(dout1_20) FROM=1369.9n TO=1370.1n

.meas tran Vdout1_21ck111 AVG v(dout1_21) FROM=1369.9n TO=1370.1n

.meas tran Vdout1_22ck111 AVG v(dout1_22) FROM=1369.9n TO=1370.1n

.meas tran Vdout1_23ck111 AVG v(dout1_23) FROM=1369.9n TO=1370.1n

.meas tran Vdout1_24ck111 AVG v(dout1_24) FROM=1369.9n TO=1370.1n

.meas tran Vdout1_25ck111 AVG v(dout1_25) FROM=1369.9n TO=1370.1n

.meas tran Vdout1_26ck111 AVG v(dout1_26) FROM=1369.9n TO=1370.1n

.meas tran Vdout1_27ck111 AVG v(dout1_27) FROM=1369.9n TO=1370.1n

.meas tran Vdout1_28ck111 AVG v(dout1_28) FROM=1369.9n TO=1370.1n

.meas tran Vdout1_29ck111 AVG v(dout1_29) FROM=1369.9n TO=1370.1n

.meas tran Vdout1_30ck111 AVG v(dout1_30) FROM=1369.9n TO=1370.1n

.meas tran Vdout1_31ck111 AVG v(dout1_31) FROM=1369.9n TO=1370.1n

.meas tran Vdout1_32ck111 AVG v(dout1_32) FROM=1369.9n TO=1370.1n

.meas tran Vdout1_33ck111 AVG v(dout1_33) FROM=1369.9n TO=1370.1n

.meas tran Vdout1_34ck111 AVG v(dout1_34) FROM=1369.9n TO=1370.1n

.meas tran Vdout1_35ck111 AVG v(dout1_35) FROM=1369.9n TO=1370.1n

.meas tran Vdout1_36ck111 AVG v(dout1_36) FROM=1369.9n TO=1370.1n

.meas tran Vdout1_37ck111 AVG v(dout1_37) FROM=1369.9n TO=1370.1n

.meas tran Vdout1_38ck111 AVG v(dout1_38) FROM=1369.9n TO=1370.1n

.meas tran Vdout1_39ck111 AVG v(dout1_39) FROM=1369.9n TO=1370.1n

.meas tran Vdout1_40ck111 AVG v(dout1_40) FROM=1369.9n TO=1370.1n

.meas tran Vdout1_41ck111 AVG v(dout1_41) FROM=1369.9n TO=1370.1n

.meas tran Vdout1_42ck111 AVG v(dout1_42) FROM=1369.9n TO=1370.1n

.meas tran Vdout1_43ck111 AVG v(dout1_43) FROM=1369.9n TO=1370.1n

.meas tran Vdout1_44ck111 AVG v(dout1_44) FROM=1369.9n TO=1370.1n

.meas tran Vdout1_45ck111 AVG v(dout1_45) FROM=1369.9n TO=1370.1n

.meas tran Vdout1_46ck111 AVG v(dout1_46) FROM=1369.9n TO=1370.1n

.meas tran Vdout1_47ck111 AVG v(dout1_47) FROM=1369.9n TO=1370.1n

.meas tran Vdout1_48ck111 AVG v(dout1_48) FROM=1369.9n TO=1370.1n

.meas tran Vdout1_49ck111 AVG v(dout1_49) FROM=1369.9n TO=1370.1n

.meas tran Vdout1_50ck111 AVG v(dout1_50) FROM=1369.9n TO=1370.1n

.meas tran Vdout1_51ck111 AVG v(dout1_51) FROM=1369.9n TO=1370.1n

.meas tran Vdout1_52ck111 AVG v(dout1_52) FROM=1369.9n TO=1370.1n

.meas tran Vdout1_53ck111 AVG v(dout1_53) FROM=1369.9n TO=1370.1n

.meas tran Vdout1_54ck111 AVG v(dout1_54) FROM=1369.9n TO=1370.1n

.meas tran Vdout1_55ck111 AVG v(dout1_55) FROM=1369.9n TO=1370.1n

.meas tran Vdout1_56ck111 AVG v(dout1_56) FROM=1369.9n TO=1370.1n

.meas tran Vdout1_57ck111 AVG v(dout1_57) FROM=1369.9n TO=1370.1n

.meas tran Vdout1_58ck111 AVG v(dout1_58) FROM=1369.9n TO=1370.1n

.meas tran Vdout1_59ck111 AVG v(dout1_59) FROM=1369.9n TO=1370.1n

.meas tran Vdout1_60ck111 AVG v(dout1_60) FROM=1369.9n TO=1370.1n

.meas tran Vdout1_61ck111 AVG v(dout1_61) FROM=1369.9n TO=1370.1n

.meas tran Vdout1_62ck111 AVG v(dout1_62) FROM=1369.9n TO=1370.1n

.meas tran Vdout1_63ck111 AVG v(dout1_63) FROM=1369.9n TO=1370.1n

.meas tran Vdout1_64ck111 AVG v(dout1_64) FROM=1369.9n TO=1370.1n

.meas tran Vdout1_65ck111 AVG v(dout1_65) FROM=1369.9n TO=1370.1n

.meas tran Vdout1_66ck111 AVG v(dout1_66) FROM=1369.9n TO=1370.1n

.meas tran Vdout1_67ck111 AVG v(dout1_67) FROM=1369.9n TO=1370.1n

.meas tran Vdout1_68ck111 AVG v(dout1_68) FROM=1369.9n TO=1370.1n

.meas tran Vdout1_69ck111 AVG v(dout1_69) FROM=1369.9n TO=1370.1n

.meas tran Vdout1_70ck111 AVG v(dout1_70) FROM=1369.9n TO=1370.1n

.meas tran Vdout1_71ck111 AVG v(dout1_71) FROM=1369.9n TO=1370.1n

.meas tran Vdout1_72ck111 AVG v(dout1_72) FROM=1369.9n TO=1370.1n

.meas tran Vdout1_73ck111 AVG v(dout1_73) FROM=1369.9n TO=1370.1n

.meas tran Vdout1_74ck111 AVG v(dout1_74) FROM=1369.9n TO=1370.1n

.meas tran Vdout1_75ck111 AVG v(dout1_75) FROM=1369.9n TO=1370.1n

.meas tran Vdout1_76ck111 AVG v(dout1_76) FROM=1369.9n TO=1370.1n

.meas tran Vdout1_77ck111 AVG v(dout1_77) FROM=1369.9n TO=1370.1n

.meas tran Vdout1_78ck111 AVG v(dout1_78) FROM=1369.9n TO=1370.1n

.meas tran Vdout1_79ck111 AVG v(dout1_79) FROM=1369.9n TO=1370.1n

.meas tran Vdout0_0ck112 AVG v(dout0_0) FROM=1379.9n TO=1380.1n

.meas tran Vdout0_1ck112 AVG v(dout0_1) FROM=1379.9n TO=1380.1n

.meas tran Vdout0_2ck112 AVG v(dout0_2) FROM=1379.9n TO=1380.1n

.meas tran Vdout0_3ck112 AVG v(dout0_3) FROM=1379.9n TO=1380.1n

.meas tran Vdout0_4ck112 AVG v(dout0_4) FROM=1379.9n TO=1380.1n

.meas tran Vdout0_5ck112 AVG v(dout0_5) FROM=1379.9n TO=1380.1n

.meas tran Vdout0_6ck112 AVG v(dout0_6) FROM=1379.9n TO=1380.1n

.meas tran Vdout0_7ck112 AVG v(dout0_7) FROM=1379.9n TO=1380.1n

.meas tran Vdout0_8ck112 AVG v(dout0_8) FROM=1379.9n TO=1380.1n

.meas tran Vdout0_9ck112 AVG v(dout0_9) FROM=1379.9n TO=1380.1n

.meas tran Vdout0_10ck112 AVG v(dout0_10) FROM=1379.9n TO=1380.1n

.meas tran Vdout0_11ck112 AVG v(dout0_11) FROM=1379.9n TO=1380.1n

.meas tran Vdout0_12ck112 AVG v(dout0_12) FROM=1379.9n TO=1380.1n

.meas tran Vdout0_13ck112 AVG v(dout0_13) FROM=1379.9n TO=1380.1n

.meas tran Vdout0_14ck112 AVG v(dout0_14) FROM=1379.9n TO=1380.1n

.meas tran Vdout0_15ck112 AVG v(dout0_15) FROM=1379.9n TO=1380.1n

.meas tran Vdout0_16ck112 AVG v(dout0_16) FROM=1379.9n TO=1380.1n

.meas tran Vdout0_17ck112 AVG v(dout0_17) FROM=1379.9n TO=1380.1n

.meas tran Vdout0_18ck112 AVG v(dout0_18) FROM=1379.9n TO=1380.1n

.meas tran Vdout0_19ck112 AVG v(dout0_19) FROM=1379.9n TO=1380.1n

.meas tran Vdout0_20ck112 AVG v(dout0_20) FROM=1379.9n TO=1380.1n

.meas tran Vdout0_21ck112 AVG v(dout0_21) FROM=1379.9n TO=1380.1n

.meas tran Vdout0_22ck112 AVG v(dout0_22) FROM=1379.9n TO=1380.1n

.meas tran Vdout0_23ck112 AVG v(dout0_23) FROM=1379.9n TO=1380.1n

.meas tran Vdout0_24ck112 AVG v(dout0_24) FROM=1379.9n TO=1380.1n

.meas tran Vdout0_25ck112 AVG v(dout0_25) FROM=1379.9n TO=1380.1n

.meas tran Vdout0_26ck112 AVG v(dout0_26) FROM=1379.9n TO=1380.1n

.meas tran Vdout0_27ck112 AVG v(dout0_27) FROM=1379.9n TO=1380.1n

.meas tran Vdout0_28ck112 AVG v(dout0_28) FROM=1379.9n TO=1380.1n

.meas tran Vdout0_29ck112 AVG v(dout0_29) FROM=1379.9n TO=1380.1n

.meas tran Vdout0_30ck112 AVG v(dout0_30) FROM=1379.9n TO=1380.1n

.meas tran Vdout0_31ck112 AVG v(dout0_31) FROM=1379.9n TO=1380.1n

.meas tran Vdout0_32ck112 AVG v(dout0_32) FROM=1379.9n TO=1380.1n

.meas tran Vdout0_33ck112 AVG v(dout0_33) FROM=1379.9n TO=1380.1n

.meas tran Vdout0_34ck112 AVG v(dout0_34) FROM=1379.9n TO=1380.1n

.meas tran Vdout0_35ck112 AVG v(dout0_35) FROM=1379.9n TO=1380.1n

.meas tran Vdout0_36ck112 AVG v(dout0_36) FROM=1379.9n TO=1380.1n

.meas tran Vdout0_37ck112 AVG v(dout0_37) FROM=1379.9n TO=1380.1n

.meas tran Vdout0_38ck112 AVG v(dout0_38) FROM=1379.9n TO=1380.1n

.meas tran Vdout0_39ck112 AVG v(dout0_39) FROM=1379.9n TO=1380.1n

.meas tran Vdout0_40ck112 AVG v(dout0_40) FROM=1379.9n TO=1380.1n

.meas tran Vdout0_41ck112 AVG v(dout0_41) FROM=1379.9n TO=1380.1n

.meas tran Vdout0_42ck112 AVG v(dout0_42) FROM=1379.9n TO=1380.1n

.meas tran Vdout0_43ck112 AVG v(dout0_43) FROM=1379.9n TO=1380.1n

.meas tran Vdout0_44ck112 AVG v(dout0_44) FROM=1379.9n TO=1380.1n

.meas tran Vdout0_45ck112 AVG v(dout0_45) FROM=1379.9n TO=1380.1n

.meas tran Vdout0_46ck112 AVG v(dout0_46) FROM=1379.9n TO=1380.1n

.meas tran Vdout0_47ck112 AVG v(dout0_47) FROM=1379.9n TO=1380.1n

.meas tran Vdout0_48ck112 AVG v(dout0_48) FROM=1379.9n TO=1380.1n

.meas tran Vdout0_49ck112 AVG v(dout0_49) FROM=1379.9n TO=1380.1n

.meas tran Vdout0_50ck112 AVG v(dout0_50) FROM=1379.9n TO=1380.1n

.meas tran Vdout0_51ck112 AVG v(dout0_51) FROM=1379.9n TO=1380.1n

.meas tran Vdout0_52ck112 AVG v(dout0_52) FROM=1379.9n TO=1380.1n

.meas tran Vdout0_53ck112 AVG v(dout0_53) FROM=1379.9n TO=1380.1n

.meas tran Vdout0_54ck112 AVG v(dout0_54) FROM=1379.9n TO=1380.1n

.meas tran Vdout0_55ck112 AVG v(dout0_55) FROM=1379.9n TO=1380.1n

.meas tran Vdout0_56ck112 AVG v(dout0_56) FROM=1379.9n TO=1380.1n

.meas tran Vdout0_57ck112 AVG v(dout0_57) FROM=1379.9n TO=1380.1n

.meas tran Vdout0_58ck112 AVG v(dout0_58) FROM=1379.9n TO=1380.1n

.meas tran Vdout0_59ck112 AVG v(dout0_59) FROM=1379.9n TO=1380.1n

.meas tran Vdout0_60ck112 AVG v(dout0_60) FROM=1379.9n TO=1380.1n

.meas tran Vdout0_61ck112 AVG v(dout0_61) FROM=1379.9n TO=1380.1n

.meas tran Vdout0_62ck112 AVG v(dout0_62) FROM=1379.9n TO=1380.1n

.meas tran Vdout0_63ck112 AVG v(dout0_63) FROM=1379.9n TO=1380.1n

.meas tran Vdout0_64ck112 AVG v(dout0_64) FROM=1379.9n TO=1380.1n

.meas tran Vdout0_65ck112 AVG v(dout0_65) FROM=1379.9n TO=1380.1n

.meas tran Vdout0_66ck112 AVG v(dout0_66) FROM=1379.9n TO=1380.1n

.meas tran Vdout0_67ck112 AVG v(dout0_67) FROM=1379.9n TO=1380.1n

.meas tran Vdout0_68ck112 AVG v(dout0_68) FROM=1379.9n TO=1380.1n

.meas tran Vdout0_69ck112 AVG v(dout0_69) FROM=1379.9n TO=1380.1n

.meas tran Vdout0_70ck112 AVG v(dout0_70) FROM=1379.9n TO=1380.1n

.meas tran Vdout0_71ck112 AVG v(dout0_71) FROM=1379.9n TO=1380.1n

.meas tran Vdout0_72ck112 AVG v(dout0_72) FROM=1379.9n TO=1380.1n

.meas tran Vdout0_73ck112 AVG v(dout0_73) FROM=1379.9n TO=1380.1n

.meas tran Vdout0_74ck112 AVG v(dout0_74) FROM=1379.9n TO=1380.1n

.meas tran Vdout0_75ck112 AVG v(dout0_75) FROM=1379.9n TO=1380.1n

.meas tran Vdout0_76ck112 AVG v(dout0_76) FROM=1379.9n TO=1380.1n

.meas tran Vdout0_77ck112 AVG v(dout0_77) FROM=1379.9n TO=1380.1n

.meas tran Vdout0_78ck112 AVG v(dout0_78) FROM=1379.9n TO=1380.1n

.meas tran Vdout0_79ck112 AVG v(dout0_79) FROM=1379.9n TO=1380.1n

.meas tran Vdout1_0ck113 AVG v(dout1_0) FROM=1379.9n TO=1380.1n

.meas tran Vdout1_1ck113 AVG v(dout1_1) FROM=1379.9n TO=1380.1n

.meas tran Vdout1_2ck113 AVG v(dout1_2) FROM=1379.9n TO=1380.1n

.meas tran Vdout1_3ck113 AVG v(dout1_3) FROM=1379.9n TO=1380.1n

.meas tran Vdout1_4ck113 AVG v(dout1_4) FROM=1379.9n TO=1380.1n

.meas tran Vdout1_5ck113 AVG v(dout1_5) FROM=1379.9n TO=1380.1n

.meas tran Vdout1_6ck113 AVG v(dout1_6) FROM=1379.9n TO=1380.1n

.meas tran Vdout1_7ck113 AVG v(dout1_7) FROM=1379.9n TO=1380.1n

.meas tran Vdout1_8ck113 AVG v(dout1_8) FROM=1379.9n TO=1380.1n

.meas tran Vdout1_9ck113 AVG v(dout1_9) FROM=1379.9n TO=1380.1n

.meas tran Vdout1_10ck113 AVG v(dout1_10) FROM=1379.9n TO=1380.1n

.meas tran Vdout1_11ck113 AVG v(dout1_11) FROM=1379.9n TO=1380.1n

.meas tran Vdout1_12ck113 AVG v(dout1_12) FROM=1379.9n TO=1380.1n

.meas tran Vdout1_13ck113 AVG v(dout1_13) FROM=1379.9n TO=1380.1n

.meas tran Vdout1_14ck113 AVG v(dout1_14) FROM=1379.9n TO=1380.1n

.meas tran Vdout1_15ck113 AVG v(dout1_15) FROM=1379.9n TO=1380.1n

.meas tran Vdout1_16ck113 AVG v(dout1_16) FROM=1379.9n TO=1380.1n

.meas tran Vdout1_17ck113 AVG v(dout1_17) FROM=1379.9n TO=1380.1n

.meas tran Vdout1_18ck113 AVG v(dout1_18) FROM=1379.9n TO=1380.1n

.meas tran Vdout1_19ck113 AVG v(dout1_19) FROM=1379.9n TO=1380.1n

.meas tran Vdout1_20ck113 AVG v(dout1_20) FROM=1379.9n TO=1380.1n

.meas tran Vdout1_21ck113 AVG v(dout1_21) FROM=1379.9n TO=1380.1n

.meas tran Vdout1_22ck113 AVG v(dout1_22) FROM=1379.9n TO=1380.1n

.meas tran Vdout1_23ck113 AVG v(dout1_23) FROM=1379.9n TO=1380.1n

.meas tran Vdout1_24ck113 AVG v(dout1_24) FROM=1379.9n TO=1380.1n

.meas tran Vdout1_25ck113 AVG v(dout1_25) FROM=1379.9n TO=1380.1n

.meas tran Vdout1_26ck113 AVG v(dout1_26) FROM=1379.9n TO=1380.1n

.meas tran Vdout1_27ck113 AVG v(dout1_27) FROM=1379.9n TO=1380.1n

.meas tran Vdout1_28ck113 AVG v(dout1_28) FROM=1379.9n TO=1380.1n

.meas tran Vdout1_29ck113 AVG v(dout1_29) FROM=1379.9n TO=1380.1n

.meas tran Vdout1_30ck113 AVG v(dout1_30) FROM=1379.9n TO=1380.1n

.meas tran Vdout1_31ck113 AVG v(dout1_31) FROM=1379.9n TO=1380.1n

.meas tran Vdout1_32ck113 AVG v(dout1_32) FROM=1379.9n TO=1380.1n

.meas tran Vdout1_33ck113 AVG v(dout1_33) FROM=1379.9n TO=1380.1n

.meas tran Vdout1_34ck113 AVG v(dout1_34) FROM=1379.9n TO=1380.1n

.meas tran Vdout1_35ck113 AVG v(dout1_35) FROM=1379.9n TO=1380.1n

.meas tran Vdout1_36ck113 AVG v(dout1_36) FROM=1379.9n TO=1380.1n

.meas tran Vdout1_37ck113 AVG v(dout1_37) FROM=1379.9n TO=1380.1n

.meas tran Vdout1_38ck113 AVG v(dout1_38) FROM=1379.9n TO=1380.1n

.meas tran Vdout1_39ck113 AVG v(dout1_39) FROM=1379.9n TO=1380.1n

.meas tran Vdout1_40ck113 AVG v(dout1_40) FROM=1379.9n TO=1380.1n

.meas tran Vdout1_41ck113 AVG v(dout1_41) FROM=1379.9n TO=1380.1n

.meas tran Vdout1_42ck113 AVG v(dout1_42) FROM=1379.9n TO=1380.1n

.meas tran Vdout1_43ck113 AVG v(dout1_43) FROM=1379.9n TO=1380.1n

.meas tran Vdout1_44ck113 AVG v(dout1_44) FROM=1379.9n TO=1380.1n

.meas tran Vdout1_45ck113 AVG v(dout1_45) FROM=1379.9n TO=1380.1n

.meas tran Vdout1_46ck113 AVG v(dout1_46) FROM=1379.9n TO=1380.1n

.meas tran Vdout1_47ck113 AVG v(dout1_47) FROM=1379.9n TO=1380.1n

.meas tran Vdout1_48ck113 AVG v(dout1_48) FROM=1379.9n TO=1380.1n

.meas tran Vdout1_49ck113 AVG v(dout1_49) FROM=1379.9n TO=1380.1n

.meas tran Vdout1_50ck113 AVG v(dout1_50) FROM=1379.9n TO=1380.1n

.meas tran Vdout1_51ck113 AVG v(dout1_51) FROM=1379.9n TO=1380.1n

.meas tran Vdout1_52ck113 AVG v(dout1_52) FROM=1379.9n TO=1380.1n

.meas tran Vdout1_53ck113 AVG v(dout1_53) FROM=1379.9n TO=1380.1n

.meas tran Vdout1_54ck113 AVG v(dout1_54) FROM=1379.9n TO=1380.1n

.meas tran Vdout1_55ck113 AVG v(dout1_55) FROM=1379.9n TO=1380.1n

.meas tran Vdout1_56ck113 AVG v(dout1_56) FROM=1379.9n TO=1380.1n

.meas tran Vdout1_57ck113 AVG v(dout1_57) FROM=1379.9n TO=1380.1n

.meas tran Vdout1_58ck113 AVG v(dout1_58) FROM=1379.9n TO=1380.1n

.meas tran Vdout1_59ck113 AVG v(dout1_59) FROM=1379.9n TO=1380.1n

.meas tran Vdout1_60ck113 AVG v(dout1_60) FROM=1379.9n TO=1380.1n

.meas tran Vdout1_61ck113 AVG v(dout1_61) FROM=1379.9n TO=1380.1n

.meas tran Vdout1_62ck113 AVG v(dout1_62) FROM=1379.9n TO=1380.1n

.meas tran Vdout1_63ck113 AVG v(dout1_63) FROM=1379.9n TO=1380.1n

.meas tran Vdout1_64ck113 AVG v(dout1_64) FROM=1379.9n TO=1380.1n

.meas tran Vdout1_65ck113 AVG v(dout1_65) FROM=1379.9n TO=1380.1n

.meas tran Vdout1_66ck113 AVG v(dout1_66) FROM=1379.9n TO=1380.1n

.meas tran Vdout1_67ck113 AVG v(dout1_67) FROM=1379.9n TO=1380.1n

.meas tran Vdout1_68ck113 AVG v(dout1_68) FROM=1379.9n TO=1380.1n

.meas tran Vdout1_69ck113 AVG v(dout1_69) FROM=1379.9n TO=1380.1n

.meas tran Vdout1_70ck113 AVG v(dout1_70) FROM=1379.9n TO=1380.1n

.meas tran Vdout1_71ck113 AVG v(dout1_71) FROM=1379.9n TO=1380.1n

.meas tran Vdout1_72ck113 AVG v(dout1_72) FROM=1379.9n TO=1380.1n

.meas tran Vdout1_73ck113 AVG v(dout1_73) FROM=1379.9n TO=1380.1n

.meas tran Vdout1_74ck113 AVG v(dout1_74) FROM=1379.9n TO=1380.1n

.meas tran Vdout1_75ck113 AVG v(dout1_75) FROM=1379.9n TO=1380.1n

.meas tran Vdout1_76ck113 AVG v(dout1_76) FROM=1379.9n TO=1380.1n

.meas tran Vdout1_77ck113 AVG v(dout1_77) FROM=1379.9n TO=1380.1n

.meas tran Vdout1_78ck113 AVG v(dout1_78) FROM=1379.9n TO=1380.1n

.meas tran Vdout1_79ck113 AVG v(dout1_79) FROM=1379.9n TO=1380.1n

.meas tran Vdout1_0ck114 AVG v(dout1_0) FROM=1409.9n TO=1410.1n

.meas tran Vdout1_1ck114 AVG v(dout1_1) FROM=1409.9n TO=1410.1n

.meas tran Vdout1_2ck114 AVG v(dout1_2) FROM=1409.9n TO=1410.1n

.meas tran Vdout1_3ck114 AVG v(dout1_3) FROM=1409.9n TO=1410.1n

.meas tran Vdout1_4ck114 AVG v(dout1_4) FROM=1409.9n TO=1410.1n

.meas tran Vdout1_5ck114 AVG v(dout1_5) FROM=1409.9n TO=1410.1n

.meas tran Vdout1_6ck114 AVG v(dout1_6) FROM=1409.9n TO=1410.1n

.meas tran Vdout1_7ck114 AVG v(dout1_7) FROM=1409.9n TO=1410.1n

.meas tran Vdout1_8ck114 AVG v(dout1_8) FROM=1409.9n TO=1410.1n

.meas tran Vdout1_9ck114 AVG v(dout1_9) FROM=1409.9n TO=1410.1n

.meas tran Vdout1_10ck114 AVG v(dout1_10) FROM=1409.9n TO=1410.1n

.meas tran Vdout1_11ck114 AVG v(dout1_11) FROM=1409.9n TO=1410.1n

.meas tran Vdout1_12ck114 AVG v(dout1_12) FROM=1409.9n TO=1410.1n

.meas tran Vdout1_13ck114 AVG v(dout1_13) FROM=1409.9n TO=1410.1n

.meas tran Vdout1_14ck114 AVG v(dout1_14) FROM=1409.9n TO=1410.1n

.meas tran Vdout1_15ck114 AVG v(dout1_15) FROM=1409.9n TO=1410.1n

.meas tran Vdout1_16ck114 AVG v(dout1_16) FROM=1409.9n TO=1410.1n

.meas tran Vdout1_17ck114 AVG v(dout1_17) FROM=1409.9n TO=1410.1n

.meas tran Vdout1_18ck114 AVG v(dout1_18) FROM=1409.9n TO=1410.1n

.meas tran Vdout1_19ck114 AVG v(dout1_19) FROM=1409.9n TO=1410.1n

.meas tran Vdout1_20ck114 AVG v(dout1_20) FROM=1409.9n TO=1410.1n

.meas tran Vdout1_21ck114 AVG v(dout1_21) FROM=1409.9n TO=1410.1n

.meas tran Vdout1_22ck114 AVG v(dout1_22) FROM=1409.9n TO=1410.1n

.meas tran Vdout1_23ck114 AVG v(dout1_23) FROM=1409.9n TO=1410.1n

.meas tran Vdout1_24ck114 AVG v(dout1_24) FROM=1409.9n TO=1410.1n

.meas tran Vdout1_25ck114 AVG v(dout1_25) FROM=1409.9n TO=1410.1n

.meas tran Vdout1_26ck114 AVG v(dout1_26) FROM=1409.9n TO=1410.1n

.meas tran Vdout1_27ck114 AVG v(dout1_27) FROM=1409.9n TO=1410.1n

.meas tran Vdout1_28ck114 AVG v(dout1_28) FROM=1409.9n TO=1410.1n

.meas tran Vdout1_29ck114 AVG v(dout1_29) FROM=1409.9n TO=1410.1n

.meas tran Vdout1_30ck114 AVG v(dout1_30) FROM=1409.9n TO=1410.1n

.meas tran Vdout1_31ck114 AVG v(dout1_31) FROM=1409.9n TO=1410.1n

.meas tran Vdout1_32ck114 AVG v(dout1_32) FROM=1409.9n TO=1410.1n

.meas tran Vdout1_33ck114 AVG v(dout1_33) FROM=1409.9n TO=1410.1n

.meas tran Vdout1_34ck114 AVG v(dout1_34) FROM=1409.9n TO=1410.1n

.meas tran Vdout1_35ck114 AVG v(dout1_35) FROM=1409.9n TO=1410.1n

.meas tran Vdout1_36ck114 AVG v(dout1_36) FROM=1409.9n TO=1410.1n

.meas tran Vdout1_37ck114 AVG v(dout1_37) FROM=1409.9n TO=1410.1n

.meas tran Vdout1_38ck114 AVG v(dout1_38) FROM=1409.9n TO=1410.1n

.meas tran Vdout1_39ck114 AVG v(dout1_39) FROM=1409.9n TO=1410.1n

.meas tran Vdout1_40ck114 AVG v(dout1_40) FROM=1409.9n TO=1410.1n

.meas tran Vdout1_41ck114 AVG v(dout1_41) FROM=1409.9n TO=1410.1n

.meas tran Vdout1_42ck114 AVG v(dout1_42) FROM=1409.9n TO=1410.1n

.meas tran Vdout1_43ck114 AVG v(dout1_43) FROM=1409.9n TO=1410.1n

.meas tran Vdout1_44ck114 AVG v(dout1_44) FROM=1409.9n TO=1410.1n

.meas tran Vdout1_45ck114 AVG v(dout1_45) FROM=1409.9n TO=1410.1n

.meas tran Vdout1_46ck114 AVG v(dout1_46) FROM=1409.9n TO=1410.1n

.meas tran Vdout1_47ck114 AVG v(dout1_47) FROM=1409.9n TO=1410.1n

.meas tran Vdout1_48ck114 AVG v(dout1_48) FROM=1409.9n TO=1410.1n

.meas tran Vdout1_49ck114 AVG v(dout1_49) FROM=1409.9n TO=1410.1n

.meas tran Vdout1_50ck114 AVG v(dout1_50) FROM=1409.9n TO=1410.1n

.meas tran Vdout1_51ck114 AVG v(dout1_51) FROM=1409.9n TO=1410.1n

.meas tran Vdout1_52ck114 AVG v(dout1_52) FROM=1409.9n TO=1410.1n

.meas tran Vdout1_53ck114 AVG v(dout1_53) FROM=1409.9n TO=1410.1n

.meas tran Vdout1_54ck114 AVG v(dout1_54) FROM=1409.9n TO=1410.1n

.meas tran Vdout1_55ck114 AVG v(dout1_55) FROM=1409.9n TO=1410.1n

.meas tran Vdout1_56ck114 AVG v(dout1_56) FROM=1409.9n TO=1410.1n

.meas tran Vdout1_57ck114 AVG v(dout1_57) FROM=1409.9n TO=1410.1n

.meas tran Vdout1_58ck114 AVG v(dout1_58) FROM=1409.9n TO=1410.1n

.meas tran Vdout1_59ck114 AVG v(dout1_59) FROM=1409.9n TO=1410.1n

.meas tran Vdout1_60ck114 AVG v(dout1_60) FROM=1409.9n TO=1410.1n

.meas tran Vdout1_61ck114 AVG v(dout1_61) FROM=1409.9n TO=1410.1n

.meas tran Vdout1_62ck114 AVG v(dout1_62) FROM=1409.9n TO=1410.1n

.meas tran Vdout1_63ck114 AVG v(dout1_63) FROM=1409.9n TO=1410.1n

.meas tran Vdout1_64ck114 AVG v(dout1_64) FROM=1409.9n TO=1410.1n

.meas tran Vdout1_65ck114 AVG v(dout1_65) FROM=1409.9n TO=1410.1n

.meas tran Vdout1_66ck114 AVG v(dout1_66) FROM=1409.9n TO=1410.1n

.meas tran Vdout1_67ck114 AVG v(dout1_67) FROM=1409.9n TO=1410.1n

.meas tran Vdout1_68ck114 AVG v(dout1_68) FROM=1409.9n TO=1410.1n

.meas tran Vdout1_69ck114 AVG v(dout1_69) FROM=1409.9n TO=1410.1n

.meas tran Vdout1_70ck114 AVG v(dout1_70) FROM=1409.9n TO=1410.1n

.meas tran Vdout1_71ck114 AVG v(dout1_71) FROM=1409.9n TO=1410.1n

.meas tran Vdout1_72ck114 AVG v(dout1_72) FROM=1409.9n TO=1410.1n

.meas tran Vdout1_73ck114 AVG v(dout1_73) FROM=1409.9n TO=1410.1n

.meas tran Vdout1_74ck114 AVG v(dout1_74) FROM=1409.9n TO=1410.1n

.meas tran Vdout1_75ck114 AVG v(dout1_75) FROM=1409.9n TO=1410.1n

.meas tran Vdout1_76ck114 AVG v(dout1_76) FROM=1409.9n TO=1410.1n

.meas tran Vdout1_77ck114 AVG v(dout1_77) FROM=1409.9n TO=1410.1n

.meas tran Vdout1_78ck114 AVG v(dout1_78) FROM=1409.9n TO=1410.1n

.meas tran Vdout1_79ck114 AVG v(dout1_79) FROM=1409.9n TO=1410.1n

.meas tran Vdout1_0ck115 AVG v(dout1_0) FROM=1419.9n TO=1420.1n

.meas tran Vdout1_1ck115 AVG v(dout1_1) FROM=1419.9n TO=1420.1n

.meas tran Vdout1_2ck115 AVG v(dout1_2) FROM=1419.9n TO=1420.1n

.meas tran Vdout1_3ck115 AVG v(dout1_3) FROM=1419.9n TO=1420.1n

.meas tran Vdout1_4ck115 AVG v(dout1_4) FROM=1419.9n TO=1420.1n

.meas tran Vdout1_5ck115 AVG v(dout1_5) FROM=1419.9n TO=1420.1n

.meas tran Vdout1_6ck115 AVG v(dout1_6) FROM=1419.9n TO=1420.1n

.meas tran Vdout1_7ck115 AVG v(dout1_7) FROM=1419.9n TO=1420.1n

.meas tran Vdout1_8ck115 AVG v(dout1_8) FROM=1419.9n TO=1420.1n

.meas tran Vdout1_9ck115 AVG v(dout1_9) FROM=1419.9n TO=1420.1n

.meas tran Vdout1_10ck115 AVG v(dout1_10) FROM=1419.9n TO=1420.1n

.meas tran Vdout1_11ck115 AVG v(dout1_11) FROM=1419.9n TO=1420.1n

.meas tran Vdout1_12ck115 AVG v(dout1_12) FROM=1419.9n TO=1420.1n

.meas tran Vdout1_13ck115 AVG v(dout1_13) FROM=1419.9n TO=1420.1n

.meas tran Vdout1_14ck115 AVG v(dout1_14) FROM=1419.9n TO=1420.1n

.meas tran Vdout1_15ck115 AVG v(dout1_15) FROM=1419.9n TO=1420.1n

.meas tran Vdout1_16ck115 AVG v(dout1_16) FROM=1419.9n TO=1420.1n

.meas tran Vdout1_17ck115 AVG v(dout1_17) FROM=1419.9n TO=1420.1n

.meas tran Vdout1_18ck115 AVG v(dout1_18) FROM=1419.9n TO=1420.1n

.meas tran Vdout1_19ck115 AVG v(dout1_19) FROM=1419.9n TO=1420.1n

.meas tran Vdout1_20ck115 AVG v(dout1_20) FROM=1419.9n TO=1420.1n

.meas tran Vdout1_21ck115 AVG v(dout1_21) FROM=1419.9n TO=1420.1n

.meas tran Vdout1_22ck115 AVG v(dout1_22) FROM=1419.9n TO=1420.1n

.meas tran Vdout1_23ck115 AVG v(dout1_23) FROM=1419.9n TO=1420.1n

.meas tran Vdout1_24ck115 AVG v(dout1_24) FROM=1419.9n TO=1420.1n

.meas tran Vdout1_25ck115 AVG v(dout1_25) FROM=1419.9n TO=1420.1n

.meas tran Vdout1_26ck115 AVG v(dout1_26) FROM=1419.9n TO=1420.1n

.meas tran Vdout1_27ck115 AVG v(dout1_27) FROM=1419.9n TO=1420.1n

.meas tran Vdout1_28ck115 AVG v(dout1_28) FROM=1419.9n TO=1420.1n

.meas tran Vdout1_29ck115 AVG v(dout1_29) FROM=1419.9n TO=1420.1n

.meas tran Vdout1_30ck115 AVG v(dout1_30) FROM=1419.9n TO=1420.1n

.meas tran Vdout1_31ck115 AVG v(dout1_31) FROM=1419.9n TO=1420.1n

.meas tran Vdout1_32ck115 AVG v(dout1_32) FROM=1419.9n TO=1420.1n

.meas tran Vdout1_33ck115 AVG v(dout1_33) FROM=1419.9n TO=1420.1n

.meas tran Vdout1_34ck115 AVG v(dout1_34) FROM=1419.9n TO=1420.1n

.meas tran Vdout1_35ck115 AVG v(dout1_35) FROM=1419.9n TO=1420.1n

.meas tran Vdout1_36ck115 AVG v(dout1_36) FROM=1419.9n TO=1420.1n

.meas tran Vdout1_37ck115 AVG v(dout1_37) FROM=1419.9n TO=1420.1n

.meas tran Vdout1_38ck115 AVG v(dout1_38) FROM=1419.9n TO=1420.1n

.meas tran Vdout1_39ck115 AVG v(dout1_39) FROM=1419.9n TO=1420.1n

.meas tran Vdout1_40ck115 AVG v(dout1_40) FROM=1419.9n TO=1420.1n

.meas tran Vdout1_41ck115 AVG v(dout1_41) FROM=1419.9n TO=1420.1n

.meas tran Vdout1_42ck115 AVG v(dout1_42) FROM=1419.9n TO=1420.1n

.meas tran Vdout1_43ck115 AVG v(dout1_43) FROM=1419.9n TO=1420.1n

.meas tran Vdout1_44ck115 AVG v(dout1_44) FROM=1419.9n TO=1420.1n

.meas tran Vdout1_45ck115 AVG v(dout1_45) FROM=1419.9n TO=1420.1n

.meas tran Vdout1_46ck115 AVG v(dout1_46) FROM=1419.9n TO=1420.1n

.meas tran Vdout1_47ck115 AVG v(dout1_47) FROM=1419.9n TO=1420.1n

.meas tran Vdout1_48ck115 AVG v(dout1_48) FROM=1419.9n TO=1420.1n

.meas tran Vdout1_49ck115 AVG v(dout1_49) FROM=1419.9n TO=1420.1n

.meas tran Vdout1_50ck115 AVG v(dout1_50) FROM=1419.9n TO=1420.1n

.meas tran Vdout1_51ck115 AVG v(dout1_51) FROM=1419.9n TO=1420.1n

.meas tran Vdout1_52ck115 AVG v(dout1_52) FROM=1419.9n TO=1420.1n

.meas tran Vdout1_53ck115 AVG v(dout1_53) FROM=1419.9n TO=1420.1n

.meas tran Vdout1_54ck115 AVG v(dout1_54) FROM=1419.9n TO=1420.1n

.meas tran Vdout1_55ck115 AVG v(dout1_55) FROM=1419.9n TO=1420.1n

.meas tran Vdout1_56ck115 AVG v(dout1_56) FROM=1419.9n TO=1420.1n

.meas tran Vdout1_57ck115 AVG v(dout1_57) FROM=1419.9n TO=1420.1n

.meas tran Vdout1_58ck115 AVG v(dout1_58) FROM=1419.9n TO=1420.1n

.meas tran Vdout1_59ck115 AVG v(dout1_59) FROM=1419.9n TO=1420.1n

.meas tran Vdout1_60ck115 AVG v(dout1_60) FROM=1419.9n TO=1420.1n

.meas tran Vdout1_61ck115 AVG v(dout1_61) FROM=1419.9n TO=1420.1n

.meas tran Vdout1_62ck115 AVG v(dout1_62) FROM=1419.9n TO=1420.1n

.meas tran Vdout1_63ck115 AVG v(dout1_63) FROM=1419.9n TO=1420.1n

.meas tran Vdout1_64ck115 AVG v(dout1_64) FROM=1419.9n TO=1420.1n

.meas tran Vdout1_65ck115 AVG v(dout1_65) FROM=1419.9n TO=1420.1n

.meas tran Vdout1_66ck115 AVG v(dout1_66) FROM=1419.9n TO=1420.1n

.meas tran Vdout1_67ck115 AVG v(dout1_67) FROM=1419.9n TO=1420.1n

.meas tran Vdout1_68ck115 AVG v(dout1_68) FROM=1419.9n TO=1420.1n

.meas tran Vdout1_69ck115 AVG v(dout1_69) FROM=1419.9n TO=1420.1n

.meas tran Vdout1_70ck115 AVG v(dout1_70) FROM=1419.9n TO=1420.1n

.meas tran Vdout1_71ck115 AVG v(dout1_71) FROM=1419.9n TO=1420.1n

.meas tran Vdout1_72ck115 AVG v(dout1_72) FROM=1419.9n TO=1420.1n

.meas tran Vdout1_73ck115 AVG v(dout1_73) FROM=1419.9n TO=1420.1n

.meas tran Vdout1_74ck115 AVG v(dout1_74) FROM=1419.9n TO=1420.1n

.meas tran Vdout1_75ck115 AVG v(dout1_75) FROM=1419.9n TO=1420.1n

.meas tran Vdout1_76ck115 AVG v(dout1_76) FROM=1419.9n TO=1420.1n

.meas tran Vdout1_77ck115 AVG v(dout1_77) FROM=1419.9n TO=1420.1n

.meas tran Vdout1_78ck115 AVG v(dout1_78) FROM=1419.9n TO=1420.1n

.meas tran Vdout1_79ck115 AVG v(dout1_79) FROM=1419.9n TO=1420.1n

.meas tran Vdout1_0ck116 AVG v(dout1_0) FROM=1429.9n TO=1430.1n

.meas tran Vdout1_1ck116 AVG v(dout1_1) FROM=1429.9n TO=1430.1n

.meas tran Vdout1_2ck116 AVG v(dout1_2) FROM=1429.9n TO=1430.1n

.meas tran Vdout1_3ck116 AVG v(dout1_3) FROM=1429.9n TO=1430.1n

.meas tran Vdout1_4ck116 AVG v(dout1_4) FROM=1429.9n TO=1430.1n

.meas tran Vdout1_5ck116 AVG v(dout1_5) FROM=1429.9n TO=1430.1n

.meas tran Vdout1_6ck116 AVG v(dout1_6) FROM=1429.9n TO=1430.1n

.meas tran Vdout1_7ck116 AVG v(dout1_7) FROM=1429.9n TO=1430.1n

.meas tran Vdout1_8ck116 AVG v(dout1_8) FROM=1429.9n TO=1430.1n

.meas tran Vdout1_9ck116 AVG v(dout1_9) FROM=1429.9n TO=1430.1n

.meas tran Vdout1_10ck116 AVG v(dout1_10) FROM=1429.9n TO=1430.1n

.meas tran Vdout1_11ck116 AVG v(dout1_11) FROM=1429.9n TO=1430.1n

.meas tran Vdout1_12ck116 AVG v(dout1_12) FROM=1429.9n TO=1430.1n

.meas tran Vdout1_13ck116 AVG v(dout1_13) FROM=1429.9n TO=1430.1n

.meas tran Vdout1_14ck116 AVG v(dout1_14) FROM=1429.9n TO=1430.1n

.meas tran Vdout1_15ck116 AVG v(dout1_15) FROM=1429.9n TO=1430.1n

.meas tran Vdout1_16ck116 AVG v(dout1_16) FROM=1429.9n TO=1430.1n

.meas tran Vdout1_17ck116 AVG v(dout1_17) FROM=1429.9n TO=1430.1n

.meas tran Vdout1_18ck116 AVG v(dout1_18) FROM=1429.9n TO=1430.1n

.meas tran Vdout1_19ck116 AVG v(dout1_19) FROM=1429.9n TO=1430.1n

.meas tran Vdout1_20ck116 AVG v(dout1_20) FROM=1429.9n TO=1430.1n

.meas tran Vdout1_21ck116 AVG v(dout1_21) FROM=1429.9n TO=1430.1n

.meas tran Vdout1_22ck116 AVG v(dout1_22) FROM=1429.9n TO=1430.1n

.meas tran Vdout1_23ck116 AVG v(dout1_23) FROM=1429.9n TO=1430.1n

.meas tran Vdout1_24ck116 AVG v(dout1_24) FROM=1429.9n TO=1430.1n

.meas tran Vdout1_25ck116 AVG v(dout1_25) FROM=1429.9n TO=1430.1n

.meas tran Vdout1_26ck116 AVG v(dout1_26) FROM=1429.9n TO=1430.1n

.meas tran Vdout1_27ck116 AVG v(dout1_27) FROM=1429.9n TO=1430.1n

.meas tran Vdout1_28ck116 AVG v(dout1_28) FROM=1429.9n TO=1430.1n

.meas tran Vdout1_29ck116 AVG v(dout1_29) FROM=1429.9n TO=1430.1n

.meas tran Vdout1_30ck116 AVG v(dout1_30) FROM=1429.9n TO=1430.1n

.meas tran Vdout1_31ck116 AVG v(dout1_31) FROM=1429.9n TO=1430.1n

.meas tran Vdout1_32ck116 AVG v(dout1_32) FROM=1429.9n TO=1430.1n

.meas tran Vdout1_33ck116 AVG v(dout1_33) FROM=1429.9n TO=1430.1n

.meas tran Vdout1_34ck116 AVG v(dout1_34) FROM=1429.9n TO=1430.1n

.meas tran Vdout1_35ck116 AVG v(dout1_35) FROM=1429.9n TO=1430.1n

.meas tran Vdout1_36ck116 AVG v(dout1_36) FROM=1429.9n TO=1430.1n

.meas tran Vdout1_37ck116 AVG v(dout1_37) FROM=1429.9n TO=1430.1n

.meas tran Vdout1_38ck116 AVG v(dout1_38) FROM=1429.9n TO=1430.1n

.meas tran Vdout1_39ck116 AVG v(dout1_39) FROM=1429.9n TO=1430.1n

.meas tran Vdout1_40ck116 AVG v(dout1_40) FROM=1429.9n TO=1430.1n

.meas tran Vdout1_41ck116 AVG v(dout1_41) FROM=1429.9n TO=1430.1n

.meas tran Vdout1_42ck116 AVG v(dout1_42) FROM=1429.9n TO=1430.1n

.meas tran Vdout1_43ck116 AVG v(dout1_43) FROM=1429.9n TO=1430.1n

.meas tran Vdout1_44ck116 AVG v(dout1_44) FROM=1429.9n TO=1430.1n

.meas tran Vdout1_45ck116 AVG v(dout1_45) FROM=1429.9n TO=1430.1n

.meas tran Vdout1_46ck116 AVG v(dout1_46) FROM=1429.9n TO=1430.1n

.meas tran Vdout1_47ck116 AVG v(dout1_47) FROM=1429.9n TO=1430.1n

.meas tran Vdout1_48ck116 AVG v(dout1_48) FROM=1429.9n TO=1430.1n

.meas tran Vdout1_49ck116 AVG v(dout1_49) FROM=1429.9n TO=1430.1n

.meas tran Vdout1_50ck116 AVG v(dout1_50) FROM=1429.9n TO=1430.1n

.meas tran Vdout1_51ck116 AVG v(dout1_51) FROM=1429.9n TO=1430.1n

.meas tran Vdout1_52ck116 AVG v(dout1_52) FROM=1429.9n TO=1430.1n

.meas tran Vdout1_53ck116 AVG v(dout1_53) FROM=1429.9n TO=1430.1n

.meas tran Vdout1_54ck116 AVG v(dout1_54) FROM=1429.9n TO=1430.1n

.meas tran Vdout1_55ck116 AVG v(dout1_55) FROM=1429.9n TO=1430.1n

.meas tran Vdout1_56ck116 AVG v(dout1_56) FROM=1429.9n TO=1430.1n

.meas tran Vdout1_57ck116 AVG v(dout1_57) FROM=1429.9n TO=1430.1n

.meas tran Vdout1_58ck116 AVG v(dout1_58) FROM=1429.9n TO=1430.1n

.meas tran Vdout1_59ck116 AVG v(dout1_59) FROM=1429.9n TO=1430.1n

.meas tran Vdout1_60ck116 AVG v(dout1_60) FROM=1429.9n TO=1430.1n

.meas tran Vdout1_61ck116 AVG v(dout1_61) FROM=1429.9n TO=1430.1n

.meas tran Vdout1_62ck116 AVG v(dout1_62) FROM=1429.9n TO=1430.1n

.meas tran Vdout1_63ck116 AVG v(dout1_63) FROM=1429.9n TO=1430.1n

.meas tran Vdout1_64ck116 AVG v(dout1_64) FROM=1429.9n TO=1430.1n

.meas tran Vdout1_65ck116 AVG v(dout1_65) FROM=1429.9n TO=1430.1n

.meas tran Vdout1_66ck116 AVG v(dout1_66) FROM=1429.9n TO=1430.1n

.meas tran Vdout1_67ck116 AVG v(dout1_67) FROM=1429.9n TO=1430.1n

.meas tran Vdout1_68ck116 AVG v(dout1_68) FROM=1429.9n TO=1430.1n

.meas tran Vdout1_69ck116 AVG v(dout1_69) FROM=1429.9n TO=1430.1n

.meas tran Vdout1_70ck116 AVG v(dout1_70) FROM=1429.9n TO=1430.1n

.meas tran Vdout1_71ck116 AVG v(dout1_71) FROM=1429.9n TO=1430.1n

.meas tran Vdout1_72ck116 AVG v(dout1_72) FROM=1429.9n TO=1430.1n

.meas tran Vdout1_73ck116 AVG v(dout1_73) FROM=1429.9n TO=1430.1n

.meas tran Vdout1_74ck116 AVG v(dout1_74) FROM=1429.9n TO=1430.1n

.meas tran Vdout1_75ck116 AVG v(dout1_75) FROM=1429.9n TO=1430.1n

.meas tran Vdout1_76ck116 AVG v(dout1_76) FROM=1429.9n TO=1430.1n

.meas tran Vdout1_77ck116 AVG v(dout1_77) FROM=1429.9n TO=1430.1n

.meas tran Vdout1_78ck116 AVG v(dout1_78) FROM=1429.9n TO=1430.1n

.meas tran Vdout1_79ck116 AVG v(dout1_79) FROM=1429.9n TO=1430.1n

.meas tran Vdout0_0ck117 AVG v(dout0_0) FROM=1439.9n TO=1440.1n

.meas tran Vdout0_1ck117 AVG v(dout0_1) FROM=1439.9n TO=1440.1n

.meas tran Vdout0_2ck117 AVG v(dout0_2) FROM=1439.9n TO=1440.1n

.meas tran Vdout0_3ck117 AVG v(dout0_3) FROM=1439.9n TO=1440.1n

.meas tran Vdout0_4ck117 AVG v(dout0_4) FROM=1439.9n TO=1440.1n

.meas tran Vdout0_5ck117 AVG v(dout0_5) FROM=1439.9n TO=1440.1n

.meas tran Vdout0_6ck117 AVG v(dout0_6) FROM=1439.9n TO=1440.1n

.meas tran Vdout0_7ck117 AVG v(dout0_7) FROM=1439.9n TO=1440.1n

.meas tran Vdout0_8ck117 AVG v(dout0_8) FROM=1439.9n TO=1440.1n

.meas tran Vdout0_9ck117 AVG v(dout0_9) FROM=1439.9n TO=1440.1n

.meas tran Vdout0_10ck117 AVG v(dout0_10) FROM=1439.9n TO=1440.1n

.meas tran Vdout0_11ck117 AVG v(dout0_11) FROM=1439.9n TO=1440.1n

.meas tran Vdout0_12ck117 AVG v(dout0_12) FROM=1439.9n TO=1440.1n

.meas tran Vdout0_13ck117 AVG v(dout0_13) FROM=1439.9n TO=1440.1n

.meas tran Vdout0_14ck117 AVG v(dout0_14) FROM=1439.9n TO=1440.1n

.meas tran Vdout0_15ck117 AVG v(dout0_15) FROM=1439.9n TO=1440.1n

.meas tran Vdout0_16ck117 AVG v(dout0_16) FROM=1439.9n TO=1440.1n

.meas tran Vdout0_17ck117 AVG v(dout0_17) FROM=1439.9n TO=1440.1n

.meas tran Vdout0_18ck117 AVG v(dout0_18) FROM=1439.9n TO=1440.1n

.meas tran Vdout0_19ck117 AVG v(dout0_19) FROM=1439.9n TO=1440.1n

.meas tran Vdout0_20ck117 AVG v(dout0_20) FROM=1439.9n TO=1440.1n

.meas tran Vdout0_21ck117 AVG v(dout0_21) FROM=1439.9n TO=1440.1n

.meas tran Vdout0_22ck117 AVG v(dout0_22) FROM=1439.9n TO=1440.1n

.meas tran Vdout0_23ck117 AVG v(dout0_23) FROM=1439.9n TO=1440.1n

.meas tran Vdout0_24ck117 AVG v(dout0_24) FROM=1439.9n TO=1440.1n

.meas tran Vdout0_25ck117 AVG v(dout0_25) FROM=1439.9n TO=1440.1n

.meas tran Vdout0_26ck117 AVG v(dout0_26) FROM=1439.9n TO=1440.1n

.meas tran Vdout0_27ck117 AVG v(dout0_27) FROM=1439.9n TO=1440.1n

.meas tran Vdout0_28ck117 AVG v(dout0_28) FROM=1439.9n TO=1440.1n

.meas tran Vdout0_29ck117 AVG v(dout0_29) FROM=1439.9n TO=1440.1n

.meas tran Vdout0_30ck117 AVG v(dout0_30) FROM=1439.9n TO=1440.1n

.meas tran Vdout0_31ck117 AVG v(dout0_31) FROM=1439.9n TO=1440.1n

.meas tran Vdout0_32ck117 AVG v(dout0_32) FROM=1439.9n TO=1440.1n

.meas tran Vdout0_33ck117 AVG v(dout0_33) FROM=1439.9n TO=1440.1n

.meas tran Vdout0_34ck117 AVG v(dout0_34) FROM=1439.9n TO=1440.1n

.meas tran Vdout0_35ck117 AVG v(dout0_35) FROM=1439.9n TO=1440.1n

.meas tran Vdout0_36ck117 AVG v(dout0_36) FROM=1439.9n TO=1440.1n

.meas tran Vdout0_37ck117 AVG v(dout0_37) FROM=1439.9n TO=1440.1n

.meas tran Vdout0_38ck117 AVG v(dout0_38) FROM=1439.9n TO=1440.1n

.meas tran Vdout0_39ck117 AVG v(dout0_39) FROM=1439.9n TO=1440.1n

.meas tran Vdout0_40ck117 AVG v(dout0_40) FROM=1439.9n TO=1440.1n

.meas tran Vdout0_41ck117 AVG v(dout0_41) FROM=1439.9n TO=1440.1n

.meas tran Vdout0_42ck117 AVG v(dout0_42) FROM=1439.9n TO=1440.1n

.meas tran Vdout0_43ck117 AVG v(dout0_43) FROM=1439.9n TO=1440.1n

.meas tran Vdout0_44ck117 AVG v(dout0_44) FROM=1439.9n TO=1440.1n

.meas tran Vdout0_45ck117 AVG v(dout0_45) FROM=1439.9n TO=1440.1n

.meas tran Vdout0_46ck117 AVG v(dout0_46) FROM=1439.9n TO=1440.1n

.meas tran Vdout0_47ck117 AVG v(dout0_47) FROM=1439.9n TO=1440.1n

.meas tran Vdout0_48ck117 AVG v(dout0_48) FROM=1439.9n TO=1440.1n

.meas tran Vdout0_49ck117 AVG v(dout0_49) FROM=1439.9n TO=1440.1n

.meas tran Vdout0_50ck117 AVG v(dout0_50) FROM=1439.9n TO=1440.1n

.meas tran Vdout0_51ck117 AVG v(dout0_51) FROM=1439.9n TO=1440.1n

.meas tran Vdout0_52ck117 AVG v(dout0_52) FROM=1439.9n TO=1440.1n

.meas tran Vdout0_53ck117 AVG v(dout0_53) FROM=1439.9n TO=1440.1n

.meas tran Vdout0_54ck117 AVG v(dout0_54) FROM=1439.9n TO=1440.1n

.meas tran Vdout0_55ck117 AVG v(dout0_55) FROM=1439.9n TO=1440.1n

.meas tran Vdout0_56ck117 AVG v(dout0_56) FROM=1439.9n TO=1440.1n

.meas tran Vdout0_57ck117 AVG v(dout0_57) FROM=1439.9n TO=1440.1n

.meas tran Vdout0_58ck117 AVG v(dout0_58) FROM=1439.9n TO=1440.1n

.meas tran Vdout0_59ck117 AVG v(dout0_59) FROM=1439.9n TO=1440.1n

.meas tran Vdout0_60ck117 AVG v(dout0_60) FROM=1439.9n TO=1440.1n

.meas tran Vdout0_61ck117 AVG v(dout0_61) FROM=1439.9n TO=1440.1n

.meas tran Vdout0_62ck117 AVG v(dout0_62) FROM=1439.9n TO=1440.1n

.meas tran Vdout0_63ck117 AVG v(dout0_63) FROM=1439.9n TO=1440.1n

.meas tran Vdout0_64ck117 AVG v(dout0_64) FROM=1439.9n TO=1440.1n

.meas tran Vdout0_65ck117 AVG v(dout0_65) FROM=1439.9n TO=1440.1n

.meas tran Vdout0_66ck117 AVG v(dout0_66) FROM=1439.9n TO=1440.1n

.meas tran Vdout0_67ck117 AVG v(dout0_67) FROM=1439.9n TO=1440.1n

.meas tran Vdout0_68ck117 AVG v(dout0_68) FROM=1439.9n TO=1440.1n

.meas tran Vdout0_69ck117 AVG v(dout0_69) FROM=1439.9n TO=1440.1n

.meas tran Vdout0_70ck117 AVG v(dout0_70) FROM=1439.9n TO=1440.1n

.meas tran Vdout0_71ck117 AVG v(dout0_71) FROM=1439.9n TO=1440.1n

.meas tran Vdout0_72ck117 AVG v(dout0_72) FROM=1439.9n TO=1440.1n

.meas tran Vdout0_73ck117 AVG v(dout0_73) FROM=1439.9n TO=1440.1n

.meas tran Vdout0_74ck117 AVG v(dout0_74) FROM=1439.9n TO=1440.1n

.meas tran Vdout0_75ck117 AVG v(dout0_75) FROM=1439.9n TO=1440.1n

.meas tran Vdout0_76ck117 AVG v(dout0_76) FROM=1439.9n TO=1440.1n

.meas tran Vdout0_77ck117 AVG v(dout0_77) FROM=1439.9n TO=1440.1n

.meas tran Vdout0_78ck117 AVG v(dout0_78) FROM=1439.9n TO=1440.1n

.meas tran Vdout0_79ck117 AVG v(dout0_79) FROM=1439.9n TO=1440.1n

.meas tran Vdout1_0ck118 AVG v(dout1_0) FROM=1449.9n TO=1450.1n

.meas tran Vdout1_1ck118 AVG v(dout1_1) FROM=1449.9n TO=1450.1n

.meas tran Vdout1_2ck118 AVG v(dout1_2) FROM=1449.9n TO=1450.1n

.meas tran Vdout1_3ck118 AVG v(dout1_3) FROM=1449.9n TO=1450.1n

.meas tran Vdout1_4ck118 AVG v(dout1_4) FROM=1449.9n TO=1450.1n

.meas tran Vdout1_5ck118 AVG v(dout1_5) FROM=1449.9n TO=1450.1n

.meas tran Vdout1_6ck118 AVG v(dout1_6) FROM=1449.9n TO=1450.1n

.meas tran Vdout1_7ck118 AVG v(dout1_7) FROM=1449.9n TO=1450.1n

.meas tran Vdout1_8ck118 AVG v(dout1_8) FROM=1449.9n TO=1450.1n

.meas tran Vdout1_9ck118 AVG v(dout1_9) FROM=1449.9n TO=1450.1n

.meas tran Vdout1_10ck118 AVG v(dout1_10) FROM=1449.9n TO=1450.1n

.meas tran Vdout1_11ck118 AVG v(dout1_11) FROM=1449.9n TO=1450.1n

.meas tran Vdout1_12ck118 AVG v(dout1_12) FROM=1449.9n TO=1450.1n

.meas tran Vdout1_13ck118 AVG v(dout1_13) FROM=1449.9n TO=1450.1n

.meas tran Vdout1_14ck118 AVG v(dout1_14) FROM=1449.9n TO=1450.1n

.meas tran Vdout1_15ck118 AVG v(dout1_15) FROM=1449.9n TO=1450.1n

.meas tran Vdout1_16ck118 AVG v(dout1_16) FROM=1449.9n TO=1450.1n

.meas tran Vdout1_17ck118 AVG v(dout1_17) FROM=1449.9n TO=1450.1n

.meas tran Vdout1_18ck118 AVG v(dout1_18) FROM=1449.9n TO=1450.1n

.meas tran Vdout1_19ck118 AVG v(dout1_19) FROM=1449.9n TO=1450.1n

.meas tran Vdout1_20ck118 AVG v(dout1_20) FROM=1449.9n TO=1450.1n

.meas tran Vdout1_21ck118 AVG v(dout1_21) FROM=1449.9n TO=1450.1n

.meas tran Vdout1_22ck118 AVG v(dout1_22) FROM=1449.9n TO=1450.1n

.meas tran Vdout1_23ck118 AVG v(dout1_23) FROM=1449.9n TO=1450.1n

.meas tran Vdout1_24ck118 AVG v(dout1_24) FROM=1449.9n TO=1450.1n

.meas tran Vdout1_25ck118 AVG v(dout1_25) FROM=1449.9n TO=1450.1n

.meas tran Vdout1_26ck118 AVG v(dout1_26) FROM=1449.9n TO=1450.1n

.meas tran Vdout1_27ck118 AVG v(dout1_27) FROM=1449.9n TO=1450.1n

.meas tran Vdout1_28ck118 AVG v(dout1_28) FROM=1449.9n TO=1450.1n

.meas tran Vdout1_29ck118 AVG v(dout1_29) FROM=1449.9n TO=1450.1n

.meas tran Vdout1_30ck118 AVG v(dout1_30) FROM=1449.9n TO=1450.1n

.meas tran Vdout1_31ck118 AVG v(dout1_31) FROM=1449.9n TO=1450.1n

.meas tran Vdout1_32ck118 AVG v(dout1_32) FROM=1449.9n TO=1450.1n

.meas tran Vdout1_33ck118 AVG v(dout1_33) FROM=1449.9n TO=1450.1n

.meas tran Vdout1_34ck118 AVG v(dout1_34) FROM=1449.9n TO=1450.1n

.meas tran Vdout1_35ck118 AVG v(dout1_35) FROM=1449.9n TO=1450.1n

.meas tran Vdout1_36ck118 AVG v(dout1_36) FROM=1449.9n TO=1450.1n

.meas tran Vdout1_37ck118 AVG v(dout1_37) FROM=1449.9n TO=1450.1n

.meas tran Vdout1_38ck118 AVG v(dout1_38) FROM=1449.9n TO=1450.1n

.meas tran Vdout1_39ck118 AVG v(dout1_39) FROM=1449.9n TO=1450.1n

.meas tran Vdout1_40ck118 AVG v(dout1_40) FROM=1449.9n TO=1450.1n

.meas tran Vdout1_41ck118 AVG v(dout1_41) FROM=1449.9n TO=1450.1n

.meas tran Vdout1_42ck118 AVG v(dout1_42) FROM=1449.9n TO=1450.1n

.meas tran Vdout1_43ck118 AVG v(dout1_43) FROM=1449.9n TO=1450.1n

.meas tran Vdout1_44ck118 AVG v(dout1_44) FROM=1449.9n TO=1450.1n

.meas tran Vdout1_45ck118 AVG v(dout1_45) FROM=1449.9n TO=1450.1n

.meas tran Vdout1_46ck118 AVG v(dout1_46) FROM=1449.9n TO=1450.1n

.meas tran Vdout1_47ck118 AVG v(dout1_47) FROM=1449.9n TO=1450.1n

.meas tran Vdout1_48ck118 AVG v(dout1_48) FROM=1449.9n TO=1450.1n

.meas tran Vdout1_49ck118 AVG v(dout1_49) FROM=1449.9n TO=1450.1n

.meas tran Vdout1_50ck118 AVG v(dout1_50) FROM=1449.9n TO=1450.1n

.meas tran Vdout1_51ck118 AVG v(dout1_51) FROM=1449.9n TO=1450.1n

.meas tran Vdout1_52ck118 AVG v(dout1_52) FROM=1449.9n TO=1450.1n

.meas tran Vdout1_53ck118 AVG v(dout1_53) FROM=1449.9n TO=1450.1n

.meas tran Vdout1_54ck118 AVG v(dout1_54) FROM=1449.9n TO=1450.1n

.meas tran Vdout1_55ck118 AVG v(dout1_55) FROM=1449.9n TO=1450.1n

.meas tran Vdout1_56ck118 AVG v(dout1_56) FROM=1449.9n TO=1450.1n

.meas tran Vdout1_57ck118 AVG v(dout1_57) FROM=1449.9n TO=1450.1n

.meas tran Vdout1_58ck118 AVG v(dout1_58) FROM=1449.9n TO=1450.1n

.meas tran Vdout1_59ck118 AVG v(dout1_59) FROM=1449.9n TO=1450.1n

.meas tran Vdout1_60ck118 AVG v(dout1_60) FROM=1449.9n TO=1450.1n

.meas tran Vdout1_61ck118 AVG v(dout1_61) FROM=1449.9n TO=1450.1n

.meas tran Vdout1_62ck118 AVG v(dout1_62) FROM=1449.9n TO=1450.1n

.meas tran Vdout1_63ck118 AVG v(dout1_63) FROM=1449.9n TO=1450.1n

.meas tran Vdout1_64ck118 AVG v(dout1_64) FROM=1449.9n TO=1450.1n

.meas tran Vdout1_65ck118 AVG v(dout1_65) FROM=1449.9n TO=1450.1n

.meas tran Vdout1_66ck118 AVG v(dout1_66) FROM=1449.9n TO=1450.1n

.meas tran Vdout1_67ck118 AVG v(dout1_67) FROM=1449.9n TO=1450.1n

.meas tran Vdout1_68ck118 AVG v(dout1_68) FROM=1449.9n TO=1450.1n

.meas tran Vdout1_69ck118 AVG v(dout1_69) FROM=1449.9n TO=1450.1n

.meas tran Vdout1_70ck118 AVG v(dout1_70) FROM=1449.9n TO=1450.1n

.meas tran Vdout1_71ck118 AVG v(dout1_71) FROM=1449.9n TO=1450.1n

.meas tran Vdout1_72ck118 AVG v(dout1_72) FROM=1449.9n TO=1450.1n

.meas tran Vdout1_73ck118 AVG v(dout1_73) FROM=1449.9n TO=1450.1n

.meas tran Vdout1_74ck118 AVG v(dout1_74) FROM=1449.9n TO=1450.1n

.meas tran Vdout1_75ck118 AVG v(dout1_75) FROM=1449.9n TO=1450.1n

.meas tran Vdout1_76ck118 AVG v(dout1_76) FROM=1449.9n TO=1450.1n

.meas tran Vdout1_77ck118 AVG v(dout1_77) FROM=1449.9n TO=1450.1n

.meas tran Vdout1_78ck118 AVG v(dout1_78) FROM=1449.9n TO=1450.1n

.meas tran Vdout1_79ck118 AVG v(dout1_79) FROM=1449.9n TO=1450.1n

.meas tran Vdout1_0ck119 AVG v(dout1_0) FROM=1469.9n TO=1470.1n

.meas tran Vdout1_1ck119 AVG v(dout1_1) FROM=1469.9n TO=1470.1n

.meas tran Vdout1_2ck119 AVG v(dout1_2) FROM=1469.9n TO=1470.1n

.meas tran Vdout1_3ck119 AVG v(dout1_3) FROM=1469.9n TO=1470.1n

.meas tran Vdout1_4ck119 AVG v(dout1_4) FROM=1469.9n TO=1470.1n

.meas tran Vdout1_5ck119 AVG v(dout1_5) FROM=1469.9n TO=1470.1n

.meas tran Vdout1_6ck119 AVG v(dout1_6) FROM=1469.9n TO=1470.1n

.meas tran Vdout1_7ck119 AVG v(dout1_7) FROM=1469.9n TO=1470.1n

.meas tran Vdout1_8ck119 AVG v(dout1_8) FROM=1469.9n TO=1470.1n

.meas tran Vdout1_9ck119 AVG v(dout1_9) FROM=1469.9n TO=1470.1n

.meas tran Vdout1_10ck119 AVG v(dout1_10) FROM=1469.9n TO=1470.1n

.meas tran Vdout1_11ck119 AVG v(dout1_11) FROM=1469.9n TO=1470.1n

.meas tran Vdout1_12ck119 AVG v(dout1_12) FROM=1469.9n TO=1470.1n

.meas tran Vdout1_13ck119 AVG v(dout1_13) FROM=1469.9n TO=1470.1n

.meas tran Vdout1_14ck119 AVG v(dout1_14) FROM=1469.9n TO=1470.1n

.meas tran Vdout1_15ck119 AVG v(dout1_15) FROM=1469.9n TO=1470.1n

.meas tran Vdout1_16ck119 AVG v(dout1_16) FROM=1469.9n TO=1470.1n

.meas tran Vdout1_17ck119 AVG v(dout1_17) FROM=1469.9n TO=1470.1n

.meas tran Vdout1_18ck119 AVG v(dout1_18) FROM=1469.9n TO=1470.1n

.meas tran Vdout1_19ck119 AVG v(dout1_19) FROM=1469.9n TO=1470.1n

.meas tran Vdout1_20ck119 AVG v(dout1_20) FROM=1469.9n TO=1470.1n

.meas tran Vdout1_21ck119 AVG v(dout1_21) FROM=1469.9n TO=1470.1n

.meas tran Vdout1_22ck119 AVG v(dout1_22) FROM=1469.9n TO=1470.1n

.meas tran Vdout1_23ck119 AVG v(dout1_23) FROM=1469.9n TO=1470.1n

.meas tran Vdout1_24ck119 AVG v(dout1_24) FROM=1469.9n TO=1470.1n

.meas tran Vdout1_25ck119 AVG v(dout1_25) FROM=1469.9n TO=1470.1n

.meas tran Vdout1_26ck119 AVG v(dout1_26) FROM=1469.9n TO=1470.1n

.meas tran Vdout1_27ck119 AVG v(dout1_27) FROM=1469.9n TO=1470.1n

.meas tran Vdout1_28ck119 AVG v(dout1_28) FROM=1469.9n TO=1470.1n

.meas tran Vdout1_29ck119 AVG v(dout1_29) FROM=1469.9n TO=1470.1n

.meas tran Vdout1_30ck119 AVG v(dout1_30) FROM=1469.9n TO=1470.1n

.meas tran Vdout1_31ck119 AVG v(dout1_31) FROM=1469.9n TO=1470.1n

.meas tran Vdout1_32ck119 AVG v(dout1_32) FROM=1469.9n TO=1470.1n

.meas tran Vdout1_33ck119 AVG v(dout1_33) FROM=1469.9n TO=1470.1n

.meas tran Vdout1_34ck119 AVG v(dout1_34) FROM=1469.9n TO=1470.1n

.meas tran Vdout1_35ck119 AVG v(dout1_35) FROM=1469.9n TO=1470.1n

.meas tran Vdout1_36ck119 AVG v(dout1_36) FROM=1469.9n TO=1470.1n

.meas tran Vdout1_37ck119 AVG v(dout1_37) FROM=1469.9n TO=1470.1n

.meas tran Vdout1_38ck119 AVG v(dout1_38) FROM=1469.9n TO=1470.1n

.meas tran Vdout1_39ck119 AVG v(dout1_39) FROM=1469.9n TO=1470.1n

.meas tran Vdout1_40ck119 AVG v(dout1_40) FROM=1469.9n TO=1470.1n

.meas tran Vdout1_41ck119 AVG v(dout1_41) FROM=1469.9n TO=1470.1n

.meas tran Vdout1_42ck119 AVG v(dout1_42) FROM=1469.9n TO=1470.1n

.meas tran Vdout1_43ck119 AVG v(dout1_43) FROM=1469.9n TO=1470.1n

.meas tran Vdout1_44ck119 AVG v(dout1_44) FROM=1469.9n TO=1470.1n

.meas tran Vdout1_45ck119 AVG v(dout1_45) FROM=1469.9n TO=1470.1n

.meas tran Vdout1_46ck119 AVG v(dout1_46) FROM=1469.9n TO=1470.1n

.meas tran Vdout1_47ck119 AVG v(dout1_47) FROM=1469.9n TO=1470.1n

.meas tran Vdout1_48ck119 AVG v(dout1_48) FROM=1469.9n TO=1470.1n

.meas tran Vdout1_49ck119 AVG v(dout1_49) FROM=1469.9n TO=1470.1n

.meas tran Vdout1_50ck119 AVG v(dout1_50) FROM=1469.9n TO=1470.1n

.meas tran Vdout1_51ck119 AVG v(dout1_51) FROM=1469.9n TO=1470.1n

.meas tran Vdout1_52ck119 AVG v(dout1_52) FROM=1469.9n TO=1470.1n

.meas tran Vdout1_53ck119 AVG v(dout1_53) FROM=1469.9n TO=1470.1n

.meas tran Vdout1_54ck119 AVG v(dout1_54) FROM=1469.9n TO=1470.1n

.meas tran Vdout1_55ck119 AVG v(dout1_55) FROM=1469.9n TO=1470.1n

.meas tran Vdout1_56ck119 AVG v(dout1_56) FROM=1469.9n TO=1470.1n

.meas tran Vdout1_57ck119 AVG v(dout1_57) FROM=1469.9n TO=1470.1n

.meas tran Vdout1_58ck119 AVG v(dout1_58) FROM=1469.9n TO=1470.1n

.meas tran Vdout1_59ck119 AVG v(dout1_59) FROM=1469.9n TO=1470.1n

.meas tran Vdout1_60ck119 AVG v(dout1_60) FROM=1469.9n TO=1470.1n

.meas tran Vdout1_61ck119 AVG v(dout1_61) FROM=1469.9n TO=1470.1n

.meas tran Vdout1_62ck119 AVG v(dout1_62) FROM=1469.9n TO=1470.1n

.meas tran Vdout1_63ck119 AVG v(dout1_63) FROM=1469.9n TO=1470.1n

.meas tran Vdout1_64ck119 AVG v(dout1_64) FROM=1469.9n TO=1470.1n

.meas tran Vdout1_65ck119 AVG v(dout1_65) FROM=1469.9n TO=1470.1n

.meas tran Vdout1_66ck119 AVG v(dout1_66) FROM=1469.9n TO=1470.1n

.meas tran Vdout1_67ck119 AVG v(dout1_67) FROM=1469.9n TO=1470.1n

.meas tran Vdout1_68ck119 AVG v(dout1_68) FROM=1469.9n TO=1470.1n

.meas tran Vdout1_69ck119 AVG v(dout1_69) FROM=1469.9n TO=1470.1n

.meas tran Vdout1_70ck119 AVG v(dout1_70) FROM=1469.9n TO=1470.1n

.meas tran Vdout1_71ck119 AVG v(dout1_71) FROM=1469.9n TO=1470.1n

.meas tran Vdout1_72ck119 AVG v(dout1_72) FROM=1469.9n TO=1470.1n

.meas tran Vdout1_73ck119 AVG v(dout1_73) FROM=1469.9n TO=1470.1n

.meas tran Vdout1_74ck119 AVG v(dout1_74) FROM=1469.9n TO=1470.1n

.meas tran Vdout1_75ck119 AVG v(dout1_75) FROM=1469.9n TO=1470.1n

.meas tran Vdout1_76ck119 AVG v(dout1_76) FROM=1469.9n TO=1470.1n

.meas tran Vdout1_77ck119 AVG v(dout1_77) FROM=1469.9n TO=1470.1n

.meas tran Vdout1_78ck119 AVG v(dout1_78) FROM=1469.9n TO=1470.1n

.meas tran Vdout1_79ck119 AVG v(dout1_79) FROM=1469.9n TO=1470.1n

.meas tran Vdout0_0ck120 AVG v(dout0_0) FROM=1489.9n TO=1490.1n

.meas tran Vdout0_1ck120 AVG v(dout0_1) FROM=1489.9n TO=1490.1n

.meas tran Vdout0_2ck120 AVG v(dout0_2) FROM=1489.9n TO=1490.1n

.meas tran Vdout0_3ck120 AVG v(dout0_3) FROM=1489.9n TO=1490.1n

.meas tran Vdout0_4ck120 AVG v(dout0_4) FROM=1489.9n TO=1490.1n

.meas tran Vdout0_5ck120 AVG v(dout0_5) FROM=1489.9n TO=1490.1n

.meas tran Vdout0_6ck120 AVG v(dout0_6) FROM=1489.9n TO=1490.1n

.meas tran Vdout0_7ck120 AVG v(dout0_7) FROM=1489.9n TO=1490.1n

.meas tran Vdout0_8ck120 AVG v(dout0_8) FROM=1489.9n TO=1490.1n

.meas tran Vdout0_9ck120 AVG v(dout0_9) FROM=1489.9n TO=1490.1n

.meas tran Vdout0_10ck120 AVG v(dout0_10) FROM=1489.9n TO=1490.1n

.meas tran Vdout0_11ck120 AVG v(dout0_11) FROM=1489.9n TO=1490.1n

.meas tran Vdout0_12ck120 AVG v(dout0_12) FROM=1489.9n TO=1490.1n

.meas tran Vdout0_13ck120 AVG v(dout0_13) FROM=1489.9n TO=1490.1n

.meas tran Vdout0_14ck120 AVG v(dout0_14) FROM=1489.9n TO=1490.1n

.meas tran Vdout0_15ck120 AVG v(dout0_15) FROM=1489.9n TO=1490.1n

.meas tran Vdout0_16ck120 AVG v(dout0_16) FROM=1489.9n TO=1490.1n

.meas tran Vdout0_17ck120 AVG v(dout0_17) FROM=1489.9n TO=1490.1n

.meas tran Vdout0_18ck120 AVG v(dout0_18) FROM=1489.9n TO=1490.1n

.meas tran Vdout0_19ck120 AVG v(dout0_19) FROM=1489.9n TO=1490.1n

.meas tran Vdout0_20ck120 AVG v(dout0_20) FROM=1489.9n TO=1490.1n

.meas tran Vdout0_21ck120 AVG v(dout0_21) FROM=1489.9n TO=1490.1n

.meas tran Vdout0_22ck120 AVG v(dout0_22) FROM=1489.9n TO=1490.1n

.meas tran Vdout0_23ck120 AVG v(dout0_23) FROM=1489.9n TO=1490.1n

.meas tran Vdout0_24ck120 AVG v(dout0_24) FROM=1489.9n TO=1490.1n

.meas tran Vdout0_25ck120 AVG v(dout0_25) FROM=1489.9n TO=1490.1n

.meas tran Vdout0_26ck120 AVG v(dout0_26) FROM=1489.9n TO=1490.1n

.meas tran Vdout0_27ck120 AVG v(dout0_27) FROM=1489.9n TO=1490.1n

.meas tran Vdout0_28ck120 AVG v(dout0_28) FROM=1489.9n TO=1490.1n

.meas tran Vdout0_29ck120 AVG v(dout0_29) FROM=1489.9n TO=1490.1n

.meas tran Vdout0_30ck120 AVG v(dout0_30) FROM=1489.9n TO=1490.1n

.meas tran Vdout0_31ck120 AVG v(dout0_31) FROM=1489.9n TO=1490.1n

.meas tran Vdout0_32ck120 AVG v(dout0_32) FROM=1489.9n TO=1490.1n

.meas tran Vdout0_33ck120 AVG v(dout0_33) FROM=1489.9n TO=1490.1n

.meas tran Vdout0_34ck120 AVG v(dout0_34) FROM=1489.9n TO=1490.1n

.meas tran Vdout0_35ck120 AVG v(dout0_35) FROM=1489.9n TO=1490.1n

.meas tran Vdout0_36ck120 AVG v(dout0_36) FROM=1489.9n TO=1490.1n

.meas tran Vdout0_37ck120 AVG v(dout0_37) FROM=1489.9n TO=1490.1n

.meas tran Vdout0_38ck120 AVG v(dout0_38) FROM=1489.9n TO=1490.1n

.meas tran Vdout0_39ck120 AVG v(dout0_39) FROM=1489.9n TO=1490.1n

.meas tran Vdout0_40ck120 AVG v(dout0_40) FROM=1489.9n TO=1490.1n

.meas tran Vdout0_41ck120 AVG v(dout0_41) FROM=1489.9n TO=1490.1n

.meas tran Vdout0_42ck120 AVG v(dout0_42) FROM=1489.9n TO=1490.1n

.meas tran Vdout0_43ck120 AVG v(dout0_43) FROM=1489.9n TO=1490.1n

.meas tran Vdout0_44ck120 AVG v(dout0_44) FROM=1489.9n TO=1490.1n

.meas tran Vdout0_45ck120 AVG v(dout0_45) FROM=1489.9n TO=1490.1n

.meas tran Vdout0_46ck120 AVG v(dout0_46) FROM=1489.9n TO=1490.1n

.meas tran Vdout0_47ck120 AVG v(dout0_47) FROM=1489.9n TO=1490.1n

.meas tran Vdout0_48ck120 AVG v(dout0_48) FROM=1489.9n TO=1490.1n

.meas tran Vdout0_49ck120 AVG v(dout0_49) FROM=1489.9n TO=1490.1n

.meas tran Vdout0_50ck120 AVG v(dout0_50) FROM=1489.9n TO=1490.1n

.meas tran Vdout0_51ck120 AVG v(dout0_51) FROM=1489.9n TO=1490.1n

.meas tran Vdout0_52ck120 AVG v(dout0_52) FROM=1489.9n TO=1490.1n

.meas tran Vdout0_53ck120 AVG v(dout0_53) FROM=1489.9n TO=1490.1n

.meas tran Vdout0_54ck120 AVG v(dout0_54) FROM=1489.9n TO=1490.1n

.meas tran Vdout0_55ck120 AVG v(dout0_55) FROM=1489.9n TO=1490.1n

.meas tran Vdout0_56ck120 AVG v(dout0_56) FROM=1489.9n TO=1490.1n

.meas tran Vdout0_57ck120 AVG v(dout0_57) FROM=1489.9n TO=1490.1n

.meas tran Vdout0_58ck120 AVG v(dout0_58) FROM=1489.9n TO=1490.1n

.meas tran Vdout0_59ck120 AVG v(dout0_59) FROM=1489.9n TO=1490.1n

.meas tran Vdout0_60ck120 AVG v(dout0_60) FROM=1489.9n TO=1490.1n

.meas tran Vdout0_61ck120 AVG v(dout0_61) FROM=1489.9n TO=1490.1n

.meas tran Vdout0_62ck120 AVG v(dout0_62) FROM=1489.9n TO=1490.1n

.meas tran Vdout0_63ck120 AVG v(dout0_63) FROM=1489.9n TO=1490.1n

.meas tran Vdout0_64ck120 AVG v(dout0_64) FROM=1489.9n TO=1490.1n

.meas tran Vdout0_65ck120 AVG v(dout0_65) FROM=1489.9n TO=1490.1n

.meas tran Vdout0_66ck120 AVG v(dout0_66) FROM=1489.9n TO=1490.1n

.meas tran Vdout0_67ck120 AVG v(dout0_67) FROM=1489.9n TO=1490.1n

.meas tran Vdout0_68ck120 AVG v(dout0_68) FROM=1489.9n TO=1490.1n

.meas tran Vdout0_69ck120 AVG v(dout0_69) FROM=1489.9n TO=1490.1n

.meas tran Vdout0_70ck120 AVG v(dout0_70) FROM=1489.9n TO=1490.1n

.meas tran Vdout0_71ck120 AVG v(dout0_71) FROM=1489.9n TO=1490.1n

.meas tran Vdout0_72ck120 AVG v(dout0_72) FROM=1489.9n TO=1490.1n

.meas tran Vdout0_73ck120 AVG v(dout0_73) FROM=1489.9n TO=1490.1n

.meas tran Vdout0_74ck120 AVG v(dout0_74) FROM=1489.9n TO=1490.1n

.meas tran Vdout0_75ck120 AVG v(dout0_75) FROM=1489.9n TO=1490.1n

.meas tran Vdout0_76ck120 AVG v(dout0_76) FROM=1489.9n TO=1490.1n

.meas tran Vdout0_77ck120 AVG v(dout0_77) FROM=1489.9n TO=1490.1n

.meas tran Vdout0_78ck120 AVG v(dout0_78) FROM=1489.9n TO=1490.1n

.meas tran Vdout0_79ck120 AVG v(dout0_79) FROM=1489.9n TO=1490.1n

.meas tran Vdout1_0ck121 AVG v(dout1_0) FROM=1489.9n TO=1490.1n

.meas tran Vdout1_1ck121 AVG v(dout1_1) FROM=1489.9n TO=1490.1n

.meas tran Vdout1_2ck121 AVG v(dout1_2) FROM=1489.9n TO=1490.1n

.meas tran Vdout1_3ck121 AVG v(dout1_3) FROM=1489.9n TO=1490.1n

.meas tran Vdout1_4ck121 AVG v(dout1_4) FROM=1489.9n TO=1490.1n

.meas tran Vdout1_5ck121 AVG v(dout1_5) FROM=1489.9n TO=1490.1n

.meas tran Vdout1_6ck121 AVG v(dout1_6) FROM=1489.9n TO=1490.1n

.meas tran Vdout1_7ck121 AVG v(dout1_7) FROM=1489.9n TO=1490.1n

.meas tran Vdout1_8ck121 AVG v(dout1_8) FROM=1489.9n TO=1490.1n

.meas tran Vdout1_9ck121 AVG v(dout1_9) FROM=1489.9n TO=1490.1n

.meas tran Vdout1_10ck121 AVG v(dout1_10) FROM=1489.9n TO=1490.1n

.meas tran Vdout1_11ck121 AVG v(dout1_11) FROM=1489.9n TO=1490.1n

.meas tran Vdout1_12ck121 AVG v(dout1_12) FROM=1489.9n TO=1490.1n

.meas tran Vdout1_13ck121 AVG v(dout1_13) FROM=1489.9n TO=1490.1n

.meas tran Vdout1_14ck121 AVG v(dout1_14) FROM=1489.9n TO=1490.1n

.meas tran Vdout1_15ck121 AVG v(dout1_15) FROM=1489.9n TO=1490.1n

.meas tran Vdout1_16ck121 AVG v(dout1_16) FROM=1489.9n TO=1490.1n

.meas tran Vdout1_17ck121 AVG v(dout1_17) FROM=1489.9n TO=1490.1n

.meas tran Vdout1_18ck121 AVG v(dout1_18) FROM=1489.9n TO=1490.1n

.meas tran Vdout1_19ck121 AVG v(dout1_19) FROM=1489.9n TO=1490.1n

.meas tran Vdout1_20ck121 AVG v(dout1_20) FROM=1489.9n TO=1490.1n

.meas tran Vdout1_21ck121 AVG v(dout1_21) FROM=1489.9n TO=1490.1n

.meas tran Vdout1_22ck121 AVG v(dout1_22) FROM=1489.9n TO=1490.1n

.meas tran Vdout1_23ck121 AVG v(dout1_23) FROM=1489.9n TO=1490.1n

.meas tran Vdout1_24ck121 AVG v(dout1_24) FROM=1489.9n TO=1490.1n

.meas tran Vdout1_25ck121 AVG v(dout1_25) FROM=1489.9n TO=1490.1n

.meas tran Vdout1_26ck121 AVG v(dout1_26) FROM=1489.9n TO=1490.1n

.meas tran Vdout1_27ck121 AVG v(dout1_27) FROM=1489.9n TO=1490.1n

.meas tran Vdout1_28ck121 AVG v(dout1_28) FROM=1489.9n TO=1490.1n

.meas tran Vdout1_29ck121 AVG v(dout1_29) FROM=1489.9n TO=1490.1n

.meas tran Vdout1_30ck121 AVG v(dout1_30) FROM=1489.9n TO=1490.1n

.meas tran Vdout1_31ck121 AVG v(dout1_31) FROM=1489.9n TO=1490.1n

.meas tran Vdout1_32ck121 AVG v(dout1_32) FROM=1489.9n TO=1490.1n

.meas tran Vdout1_33ck121 AVG v(dout1_33) FROM=1489.9n TO=1490.1n

.meas tran Vdout1_34ck121 AVG v(dout1_34) FROM=1489.9n TO=1490.1n

.meas tran Vdout1_35ck121 AVG v(dout1_35) FROM=1489.9n TO=1490.1n

.meas tran Vdout1_36ck121 AVG v(dout1_36) FROM=1489.9n TO=1490.1n

.meas tran Vdout1_37ck121 AVG v(dout1_37) FROM=1489.9n TO=1490.1n

.meas tran Vdout1_38ck121 AVG v(dout1_38) FROM=1489.9n TO=1490.1n

.meas tran Vdout1_39ck121 AVG v(dout1_39) FROM=1489.9n TO=1490.1n

.meas tran Vdout1_40ck121 AVG v(dout1_40) FROM=1489.9n TO=1490.1n

.meas tran Vdout1_41ck121 AVG v(dout1_41) FROM=1489.9n TO=1490.1n

.meas tran Vdout1_42ck121 AVG v(dout1_42) FROM=1489.9n TO=1490.1n

.meas tran Vdout1_43ck121 AVG v(dout1_43) FROM=1489.9n TO=1490.1n

.meas tran Vdout1_44ck121 AVG v(dout1_44) FROM=1489.9n TO=1490.1n

.meas tran Vdout1_45ck121 AVG v(dout1_45) FROM=1489.9n TO=1490.1n

.meas tran Vdout1_46ck121 AVG v(dout1_46) FROM=1489.9n TO=1490.1n

.meas tran Vdout1_47ck121 AVG v(dout1_47) FROM=1489.9n TO=1490.1n

.meas tran Vdout1_48ck121 AVG v(dout1_48) FROM=1489.9n TO=1490.1n

.meas tran Vdout1_49ck121 AVG v(dout1_49) FROM=1489.9n TO=1490.1n

.meas tran Vdout1_50ck121 AVG v(dout1_50) FROM=1489.9n TO=1490.1n

.meas tran Vdout1_51ck121 AVG v(dout1_51) FROM=1489.9n TO=1490.1n

.meas tran Vdout1_52ck121 AVG v(dout1_52) FROM=1489.9n TO=1490.1n

.meas tran Vdout1_53ck121 AVG v(dout1_53) FROM=1489.9n TO=1490.1n

.meas tran Vdout1_54ck121 AVG v(dout1_54) FROM=1489.9n TO=1490.1n

.meas tran Vdout1_55ck121 AVG v(dout1_55) FROM=1489.9n TO=1490.1n

.meas tran Vdout1_56ck121 AVG v(dout1_56) FROM=1489.9n TO=1490.1n

.meas tran Vdout1_57ck121 AVG v(dout1_57) FROM=1489.9n TO=1490.1n

.meas tran Vdout1_58ck121 AVG v(dout1_58) FROM=1489.9n TO=1490.1n

.meas tran Vdout1_59ck121 AVG v(dout1_59) FROM=1489.9n TO=1490.1n

.meas tran Vdout1_60ck121 AVG v(dout1_60) FROM=1489.9n TO=1490.1n

.meas tran Vdout1_61ck121 AVG v(dout1_61) FROM=1489.9n TO=1490.1n

.meas tran Vdout1_62ck121 AVG v(dout1_62) FROM=1489.9n TO=1490.1n

.meas tran Vdout1_63ck121 AVG v(dout1_63) FROM=1489.9n TO=1490.1n

.meas tran Vdout1_64ck121 AVG v(dout1_64) FROM=1489.9n TO=1490.1n

.meas tran Vdout1_65ck121 AVG v(dout1_65) FROM=1489.9n TO=1490.1n

.meas tran Vdout1_66ck121 AVG v(dout1_66) FROM=1489.9n TO=1490.1n

.meas tran Vdout1_67ck121 AVG v(dout1_67) FROM=1489.9n TO=1490.1n

.meas tran Vdout1_68ck121 AVG v(dout1_68) FROM=1489.9n TO=1490.1n

.meas tran Vdout1_69ck121 AVG v(dout1_69) FROM=1489.9n TO=1490.1n

.meas tran Vdout1_70ck121 AVG v(dout1_70) FROM=1489.9n TO=1490.1n

.meas tran Vdout1_71ck121 AVG v(dout1_71) FROM=1489.9n TO=1490.1n

.meas tran Vdout1_72ck121 AVG v(dout1_72) FROM=1489.9n TO=1490.1n

.meas tran Vdout1_73ck121 AVG v(dout1_73) FROM=1489.9n TO=1490.1n

.meas tran Vdout1_74ck121 AVG v(dout1_74) FROM=1489.9n TO=1490.1n

.meas tran Vdout1_75ck121 AVG v(dout1_75) FROM=1489.9n TO=1490.1n

.meas tran Vdout1_76ck121 AVG v(dout1_76) FROM=1489.9n TO=1490.1n

.meas tran Vdout1_77ck121 AVG v(dout1_77) FROM=1489.9n TO=1490.1n

.meas tran Vdout1_78ck121 AVG v(dout1_78) FROM=1489.9n TO=1490.1n

.meas tran Vdout1_79ck121 AVG v(dout1_79) FROM=1489.9n TO=1490.1n

.meas tran Vdout1_0ck122 AVG v(dout1_0) FROM=1509.9n TO=1510.1n

.meas tran Vdout1_1ck122 AVG v(dout1_1) FROM=1509.9n TO=1510.1n

.meas tran Vdout1_2ck122 AVG v(dout1_2) FROM=1509.9n TO=1510.1n

.meas tran Vdout1_3ck122 AVG v(dout1_3) FROM=1509.9n TO=1510.1n

.meas tran Vdout1_4ck122 AVG v(dout1_4) FROM=1509.9n TO=1510.1n

.meas tran Vdout1_5ck122 AVG v(dout1_5) FROM=1509.9n TO=1510.1n

.meas tran Vdout1_6ck122 AVG v(dout1_6) FROM=1509.9n TO=1510.1n

.meas tran Vdout1_7ck122 AVG v(dout1_7) FROM=1509.9n TO=1510.1n

.meas tran Vdout1_8ck122 AVG v(dout1_8) FROM=1509.9n TO=1510.1n

.meas tran Vdout1_9ck122 AVG v(dout1_9) FROM=1509.9n TO=1510.1n

.meas tran Vdout1_10ck122 AVG v(dout1_10) FROM=1509.9n TO=1510.1n

.meas tran Vdout1_11ck122 AVG v(dout1_11) FROM=1509.9n TO=1510.1n

.meas tran Vdout1_12ck122 AVG v(dout1_12) FROM=1509.9n TO=1510.1n

.meas tran Vdout1_13ck122 AVG v(dout1_13) FROM=1509.9n TO=1510.1n

.meas tran Vdout1_14ck122 AVG v(dout1_14) FROM=1509.9n TO=1510.1n

.meas tran Vdout1_15ck122 AVG v(dout1_15) FROM=1509.9n TO=1510.1n

.meas tran Vdout1_16ck122 AVG v(dout1_16) FROM=1509.9n TO=1510.1n

.meas tran Vdout1_17ck122 AVG v(dout1_17) FROM=1509.9n TO=1510.1n

.meas tran Vdout1_18ck122 AVG v(dout1_18) FROM=1509.9n TO=1510.1n

.meas tran Vdout1_19ck122 AVG v(dout1_19) FROM=1509.9n TO=1510.1n

.meas tran Vdout1_20ck122 AVG v(dout1_20) FROM=1509.9n TO=1510.1n

.meas tran Vdout1_21ck122 AVG v(dout1_21) FROM=1509.9n TO=1510.1n

.meas tran Vdout1_22ck122 AVG v(dout1_22) FROM=1509.9n TO=1510.1n

.meas tran Vdout1_23ck122 AVG v(dout1_23) FROM=1509.9n TO=1510.1n

.meas tran Vdout1_24ck122 AVG v(dout1_24) FROM=1509.9n TO=1510.1n

.meas tran Vdout1_25ck122 AVG v(dout1_25) FROM=1509.9n TO=1510.1n

.meas tran Vdout1_26ck122 AVG v(dout1_26) FROM=1509.9n TO=1510.1n

.meas tran Vdout1_27ck122 AVG v(dout1_27) FROM=1509.9n TO=1510.1n

.meas tran Vdout1_28ck122 AVG v(dout1_28) FROM=1509.9n TO=1510.1n

.meas tran Vdout1_29ck122 AVG v(dout1_29) FROM=1509.9n TO=1510.1n

.meas tran Vdout1_30ck122 AVG v(dout1_30) FROM=1509.9n TO=1510.1n

.meas tran Vdout1_31ck122 AVG v(dout1_31) FROM=1509.9n TO=1510.1n

.meas tran Vdout1_32ck122 AVG v(dout1_32) FROM=1509.9n TO=1510.1n

.meas tran Vdout1_33ck122 AVG v(dout1_33) FROM=1509.9n TO=1510.1n

.meas tran Vdout1_34ck122 AVG v(dout1_34) FROM=1509.9n TO=1510.1n

.meas tran Vdout1_35ck122 AVG v(dout1_35) FROM=1509.9n TO=1510.1n

.meas tran Vdout1_36ck122 AVG v(dout1_36) FROM=1509.9n TO=1510.1n

.meas tran Vdout1_37ck122 AVG v(dout1_37) FROM=1509.9n TO=1510.1n

.meas tran Vdout1_38ck122 AVG v(dout1_38) FROM=1509.9n TO=1510.1n

.meas tran Vdout1_39ck122 AVG v(dout1_39) FROM=1509.9n TO=1510.1n

.meas tran Vdout1_40ck122 AVG v(dout1_40) FROM=1509.9n TO=1510.1n

.meas tran Vdout1_41ck122 AVG v(dout1_41) FROM=1509.9n TO=1510.1n

.meas tran Vdout1_42ck122 AVG v(dout1_42) FROM=1509.9n TO=1510.1n

.meas tran Vdout1_43ck122 AVG v(dout1_43) FROM=1509.9n TO=1510.1n

.meas tran Vdout1_44ck122 AVG v(dout1_44) FROM=1509.9n TO=1510.1n

.meas tran Vdout1_45ck122 AVG v(dout1_45) FROM=1509.9n TO=1510.1n

.meas tran Vdout1_46ck122 AVG v(dout1_46) FROM=1509.9n TO=1510.1n

.meas tran Vdout1_47ck122 AVG v(dout1_47) FROM=1509.9n TO=1510.1n

.meas tran Vdout1_48ck122 AVG v(dout1_48) FROM=1509.9n TO=1510.1n

.meas tran Vdout1_49ck122 AVG v(dout1_49) FROM=1509.9n TO=1510.1n

.meas tran Vdout1_50ck122 AVG v(dout1_50) FROM=1509.9n TO=1510.1n

.meas tran Vdout1_51ck122 AVG v(dout1_51) FROM=1509.9n TO=1510.1n

.meas tran Vdout1_52ck122 AVG v(dout1_52) FROM=1509.9n TO=1510.1n

.meas tran Vdout1_53ck122 AVG v(dout1_53) FROM=1509.9n TO=1510.1n

.meas tran Vdout1_54ck122 AVG v(dout1_54) FROM=1509.9n TO=1510.1n

.meas tran Vdout1_55ck122 AVG v(dout1_55) FROM=1509.9n TO=1510.1n

.meas tran Vdout1_56ck122 AVG v(dout1_56) FROM=1509.9n TO=1510.1n

.meas tran Vdout1_57ck122 AVG v(dout1_57) FROM=1509.9n TO=1510.1n

.meas tran Vdout1_58ck122 AVG v(dout1_58) FROM=1509.9n TO=1510.1n

.meas tran Vdout1_59ck122 AVG v(dout1_59) FROM=1509.9n TO=1510.1n

.meas tran Vdout1_60ck122 AVG v(dout1_60) FROM=1509.9n TO=1510.1n

.meas tran Vdout1_61ck122 AVG v(dout1_61) FROM=1509.9n TO=1510.1n

.meas tran Vdout1_62ck122 AVG v(dout1_62) FROM=1509.9n TO=1510.1n

.meas tran Vdout1_63ck122 AVG v(dout1_63) FROM=1509.9n TO=1510.1n

.meas tran Vdout1_64ck122 AVG v(dout1_64) FROM=1509.9n TO=1510.1n

.meas tran Vdout1_65ck122 AVG v(dout1_65) FROM=1509.9n TO=1510.1n

.meas tran Vdout1_66ck122 AVG v(dout1_66) FROM=1509.9n TO=1510.1n

.meas tran Vdout1_67ck122 AVG v(dout1_67) FROM=1509.9n TO=1510.1n

.meas tran Vdout1_68ck122 AVG v(dout1_68) FROM=1509.9n TO=1510.1n

.meas tran Vdout1_69ck122 AVG v(dout1_69) FROM=1509.9n TO=1510.1n

.meas tran Vdout1_70ck122 AVG v(dout1_70) FROM=1509.9n TO=1510.1n

.meas tran Vdout1_71ck122 AVG v(dout1_71) FROM=1509.9n TO=1510.1n

.meas tran Vdout1_72ck122 AVG v(dout1_72) FROM=1509.9n TO=1510.1n

.meas tran Vdout1_73ck122 AVG v(dout1_73) FROM=1509.9n TO=1510.1n

.meas tran Vdout1_74ck122 AVG v(dout1_74) FROM=1509.9n TO=1510.1n

.meas tran Vdout1_75ck122 AVG v(dout1_75) FROM=1509.9n TO=1510.1n

.meas tran Vdout1_76ck122 AVG v(dout1_76) FROM=1509.9n TO=1510.1n

.meas tran Vdout1_77ck122 AVG v(dout1_77) FROM=1509.9n TO=1510.1n

.meas tran Vdout1_78ck122 AVG v(dout1_78) FROM=1509.9n TO=1510.1n

.meas tran Vdout1_79ck122 AVG v(dout1_79) FROM=1509.9n TO=1510.1n

.meas tran Vdout1_0ck123 AVG v(dout1_0) FROM=1519.9n TO=1520.1n

.meas tran Vdout1_1ck123 AVG v(dout1_1) FROM=1519.9n TO=1520.1n

.meas tran Vdout1_2ck123 AVG v(dout1_2) FROM=1519.9n TO=1520.1n

.meas tran Vdout1_3ck123 AVG v(dout1_3) FROM=1519.9n TO=1520.1n

.meas tran Vdout1_4ck123 AVG v(dout1_4) FROM=1519.9n TO=1520.1n

.meas tran Vdout1_5ck123 AVG v(dout1_5) FROM=1519.9n TO=1520.1n

.meas tran Vdout1_6ck123 AVG v(dout1_6) FROM=1519.9n TO=1520.1n

.meas tran Vdout1_7ck123 AVG v(dout1_7) FROM=1519.9n TO=1520.1n

.meas tran Vdout1_8ck123 AVG v(dout1_8) FROM=1519.9n TO=1520.1n

.meas tran Vdout1_9ck123 AVG v(dout1_9) FROM=1519.9n TO=1520.1n

.meas tran Vdout1_10ck123 AVG v(dout1_10) FROM=1519.9n TO=1520.1n

.meas tran Vdout1_11ck123 AVG v(dout1_11) FROM=1519.9n TO=1520.1n

.meas tran Vdout1_12ck123 AVG v(dout1_12) FROM=1519.9n TO=1520.1n

.meas tran Vdout1_13ck123 AVG v(dout1_13) FROM=1519.9n TO=1520.1n

.meas tran Vdout1_14ck123 AVG v(dout1_14) FROM=1519.9n TO=1520.1n

.meas tran Vdout1_15ck123 AVG v(dout1_15) FROM=1519.9n TO=1520.1n

.meas tran Vdout1_16ck123 AVG v(dout1_16) FROM=1519.9n TO=1520.1n

.meas tran Vdout1_17ck123 AVG v(dout1_17) FROM=1519.9n TO=1520.1n

.meas tran Vdout1_18ck123 AVG v(dout1_18) FROM=1519.9n TO=1520.1n

.meas tran Vdout1_19ck123 AVG v(dout1_19) FROM=1519.9n TO=1520.1n

.meas tran Vdout1_20ck123 AVG v(dout1_20) FROM=1519.9n TO=1520.1n

.meas tran Vdout1_21ck123 AVG v(dout1_21) FROM=1519.9n TO=1520.1n

.meas tran Vdout1_22ck123 AVG v(dout1_22) FROM=1519.9n TO=1520.1n

.meas tran Vdout1_23ck123 AVG v(dout1_23) FROM=1519.9n TO=1520.1n

.meas tran Vdout1_24ck123 AVG v(dout1_24) FROM=1519.9n TO=1520.1n

.meas tran Vdout1_25ck123 AVG v(dout1_25) FROM=1519.9n TO=1520.1n

.meas tran Vdout1_26ck123 AVG v(dout1_26) FROM=1519.9n TO=1520.1n

.meas tran Vdout1_27ck123 AVG v(dout1_27) FROM=1519.9n TO=1520.1n

.meas tran Vdout1_28ck123 AVG v(dout1_28) FROM=1519.9n TO=1520.1n

.meas tran Vdout1_29ck123 AVG v(dout1_29) FROM=1519.9n TO=1520.1n

.meas tran Vdout1_30ck123 AVG v(dout1_30) FROM=1519.9n TO=1520.1n

.meas tran Vdout1_31ck123 AVG v(dout1_31) FROM=1519.9n TO=1520.1n

.meas tran Vdout1_32ck123 AVG v(dout1_32) FROM=1519.9n TO=1520.1n

.meas tran Vdout1_33ck123 AVG v(dout1_33) FROM=1519.9n TO=1520.1n

.meas tran Vdout1_34ck123 AVG v(dout1_34) FROM=1519.9n TO=1520.1n

.meas tran Vdout1_35ck123 AVG v(dout1_35) FROM=1519.9n TO=1520.1n

.meas tran Vdout1_36ck123 AVG v(dout1_36) FROM=1519.9n TO=1520.1n

.meas tran Vdout1_37ck123 AVG v(dout1_37) FROM=1519.9n TO=1520.1n

.meas tran Vdout1_38ck123 AVG v(dout1_38) FROM=1519.9n TO=1520.1n

.meas tran Vdout1_39ck123 AVG v(dout1_39) FROM=1519.9n TO=1520.1n

.meas tran Vdout1_40ck123 AVG v(dout1_40) FROM=1519.9n TO=1520.1n

.meas tran Vdout1_41ck123 AVG v(dout1_41) FROM=1519.9n TO=1520.1n

.meas tran Vdout1_42ck123 AVG v(dout1_42) FROM=1519.9n TO=1520.1n

.meas tran Vdout1_43ck123 AVG v(dout1_43) FROM=1519.9n TO=1520.1n

.meas tran Vdout1_44ck123 AVG v(dout1_44) FROM=1519.9n TO=1520.1n

.meas tran Vdout1_45ck123 AVG v(dout1_45) FROM=1519.9n TO=1520.1n

.meas tran Vdout1_46ck123 AVG v(dout1_46) FROM=1519.9n TO=1520.1n

.meas tran Vdout1_47ck123 AVG v(dout1_47) FROM=1519.9n TO=1520.1n

.meas tran Vdout1_48ck123 AVG v(dout1_48) FROM=1519.9n TO=1520.1n

.meas tran Vdout1_49ck123 AVG v(dout1_49) FROM=1519.9n TO=1520.1n

.meas tran Vdout1_50ck123 AVG v(dout1_50) FROM=1519.9n TO=1520.1n

.meas tran Vdout1_51ck123 AVG v(dout1_51) FROM=1519.9n TO=1520.1n

.meas tran Vdout1_52ck123 AVG v(dout1_52) FROM=1519.9n TO=1520.1n

.meas tran Vdout1_53ck123 AVG v(dout1_53) FROM=1519.9n TO=1520.1n

.meas tran Vdout1_54ck123 AVG v(dout1_54) FROM=1519.9n TO=1520.1n

.meas tran Vdout1_55ck123 AVG v(dout1_55) FROM=1519.9n TO=1520.1n

.meas tran Vdout1_56ck123 AVG v(dout1_56) FROM=1519.9n TO=1520.1n

.meas tran Vdout1_57ck123 AVG v(dout1_57) FROM=1519.9n TO=1520.1n

.meas tran Vdout1_58ck123 AVG v(dout1_58) FROM=1519.9n TO=1520.1n

.meas tran Vdout1_59ck123 AVG v(dout1_59) FROM=1519.9n TO=1520.1n

.meas tran Vdout1_60ck123 AVG v(dout1_60) FROM=1519.9n TO=1520.1n

.meas tran Vdout1_61ck123 AVG v(dout1_61) FROM=1519.9n TO=1520.1n

.meas tran Vdout1_62ck123 AVG v(dout1_62) FROM=1519.9n TO=1520.1n

.meas tran Vdout1_63ck123 AVG v(dout1_63) FROM=1519.9n TO=1520.1n

.meas tran Vdout1_64ck123 AVG v(dout1_64) FROM=1519.9n TO=1520.1n

.meas tran Vdout1_65ck123 AVG v(dout1_65) FROM=1519.9n TO=1520.1n

.meas tran Vdout1_66ck123 AVG v(dout1_66) FROM=1519.9n TO=1520.1n

.meas tran Vdout1_67ck123 AVG v(dout1_67) FROM=1519.9n TO=1520.1n

.meas tran Vdout1_68ck123 AVG v(dout1_68) FROM=1519.9n TO=1520.1n

.meas tran Vdout1_69ck123 AVG v(dout1_69) FROM=1519.9n TO=1520.1n

.meas tran Vdout1_70ck123 AVG v(dout1_70) FROM=1519.9n TO=1520.1n

.meas tran Vdout1_71ck123 AVG v(dout1_71) FROM=1519.9n TO=1520.1n

.meas tran Vdout1_72ck123 AVG v(dout1_72) FROM=1519.9n TO=1520.1n

.meas tran Vdout1_73ck123 AVG v(dout1_73) FROM=1519.9n TO=1520.1n

.meas tran Vdout1_74ck123 AVG v(dout1_74) FROM=1519.9n TO=1520.1n

.meas tran Vdout1_75ck123 AVG v(dout1_75) FROM=1519.9n TO=1520.1n

.meas tran Vdout1_76ck123 AVG v(dout1_76) FROM=1519.9n TO=1520.1n

.meas tran Vdout1_77ck123 AVG v(dout1_77) FROM=1519.9n TO=1520.1n

.meas tran Vdout1_78ck123 AVG v(dout1_78) FROM=1519.9n TO=1520.1n

.meas tran Vdout1_79ck123 AVG v(dout1_79) FROM=1519.9n TO=1520.1n

.meas tran Vdout1_0ck124 AVG v(dout1_0) FROM=1529.9n TO=1530.1n

.meas tran Vdout1_1ck124 AVG v(dout1_1) FROM=1529.9n TO=1530.1n

.meas tran Vdout1_2ck124 AVG v(dout1_2) FROM=1529.9n TO=1530.1n

.meas tran Vdout1_3ck124 AVG v(dout1_3) FROM=1529.9n TO=1530.1n

.meas tran Vdout1_4ck124 AVG v(dout1_4) FROM=1529.9n TO=1530.1n

.meas tran Vdout1_5ck124 AVG v(dout1_5) FROM=1529.9n TO=1530.1n

.meas tran Vdout1_6ck124 AVG v(dout1_6) FROM=1529.9n TO=1530.1n

.meas tran Vdout1_7ck124 AVG v(dout1_7) FROM=1529.9n TO=1530.1n

.meas tran Vdout1_8ck124 AVG v(dout1_8) FROM=1529.9n TO=1530.1n

.meas tran Vdout1_9ck124 AVG v(dout1_9) FROM=1529.9n TO=1530.1n

.meas tran Vdout1_10ck124 AVG v(dout1_10) FROM=1529.9n TO=1530.1n

.meas tran Vdout1_11ck124 AVG v(dout1_11) FROM=1529.9n TO=1530.1n

.meas tran Vdout1_12ck124 AVG v(dout1_12) FROM=1529.9n TO=1530.1n

.meas tran Vdout1_13ck124 AVG v(dout1_13) FROM=1529.9n TO=1530.1n

.meas tran Vdout1_14ck124 AVG v(dout1_14) FROM=1529.9n TO=1530.1n

.meas tran Vdout1_15ck124 AVG v(dout1_15) FROM=1529.9n TO=1530.1n

.meas tran Vdout1_16ck124 AVG v(dout1_16) FROM=1529.9n TO=1530.1n

.meas tran Vdout1_17ck124 AVG v(dout1_17) FROM=1529.9n TO=1530.1n

.meas tran Vdout1_18ck124 AVG v(dout1_18) FROM=1529.9n TO=1530.1n

.meas tran Vdout1_19ck124 AVG v(dout1_19) FROM=1529.9n TO=1530.1n

.meas tran Vdout1_20ck124 AVG v(dout1_20) FROM=1529.9n TO=1530.1n

.meas tran Vdout1_21ck124 AVG v(dout1_21) FROM=1529.9n TO=1530.1n

.meas tran Vdout1_22ck124 AVG v(dout1_22) FROM=1529.9n TO=1530.1n

.meas tran Vdout1_23ck124 AVG v(dout1_23) FROM=1529.9n TO=1530.1n

.meas tran Vdout1_24ck124 AVG v(dout1_24) FROM=1529.9n TO=1530.1n

.meas tran Vdout1_25ck124 AVG v(dout1_25) FROM=1529.9n TO=1530.1n

.meas tran Vdout1_26ck124 AVG v(dout1_26) FROM=1529.9n TO=1530.1n

.meas tran Vdout1_27ck124 AVG v(dout1_27) FROM=1529.9n TO=1530.1n

.meas tran Vdout1_28ck124 AVG v(dout1_28) FROM=1529.9n TO=1530.1n

.meas tran Vdout1_29ck124 AVG v(dout1_29) FROM=1529.9n TO=1530.1n

.meas tran Vdout1_30ck124 AVG v(dout1_30) FROM=1529.9n TO=1530.1n

.meas tran Vdout1_31ck124 AVG v(dout1_31) FROM=1529.9n TO=1530.1n

.meas tran Vdout1_32ck124 AVG v(dout1_32) FROM=1529.9n TO=1530.1n

.meas tran Vdout1_33ck124 AVG v(dout1_33) FROM=1529.9n TO=1530.1n

.meas tran Vdout1_34ck124 AVG v(dout1_34) FROM=1529.9n TO=1530.1n

.meas tran Vdout1_35ck124 AVG v(dout1_35) FROM=1529.9n TO=1530.1n

.meas tran Vdout1_36ck124 AVG v(dout1_36) FROM=1529.9n TO=1530.1n

.meas tran Vdout1_37ck124 AVG v(dout1_37) FROM=1529.9n TO=1530.1n

.meas tran Vdout1_38ck124 AVG v(dout1_38) FROM=1529.9n TO=1530.1n

.meas tran Vdout1_39ck124 AVG v(dout1_39) FROM=1529.9n TO=1530.1n

.meas tran Vdout1_40ck124 AVG v(dout1_40) FROM=1529.9n TO=1530.1n

.meas tran Vdout1_41ck124 AVG v(dout1_41) FROM=1529.9n TO=1530.1n

.meas tran Vdout1_42ck124 AVG v(dout1_42) FROM=1529.9n TO=1530.1n

.meas tran Vdout1_43ck124 AVG v(dout1_43) FROM=1529.9n TO=1530.1n

.meas tran Vdout1_44ck124 AVG v(dout1_44) FROM=1529.9n TO=1530.1n

.meas tran Vdout1_45ck124 AVG v(dout1_45) FROM=1529.9n TO=1530.1n

.meas tran Vdout1_46ck124 AVG v(dout1_46) FROM=1529.9n TO=1530.1n

.meas tran Vdout1_47ck124 AVG v(dout1_47) FROM=1529.9n TO=1530.1n

.meas tran Vdout1_48ck124 AVG v(dout1_48) FROM=1529.9n TO=1530.1n

.meas tran Vdout1_49ck124 AVG v(dout1_49) FROM=1529.9n TO=1530.1n

.meas tran Vdout1_50ck124 AVG v(dout1_50) FROM=1529.9n TO=1530.1n

.meas tran Vdout1_51ck124 AVG v(dout1_51) FROM=1529.9n TO=1530.1n

.meas tran Vdout1_52ck124 AVG v(dout1_52) FROM=1529.9n TO=1530.1n

.meas tran Vdout1_53ck124 AVG v(dout1_53) FROM=1529.9n TO=1530.1n

.meas tran Vdout1_54ck124 AVG v(dout1_54) FROM=1529.9n TO=1530.1n

.meas tran Vdout1_55ck124 AVG v(dout1_55) FROM=1529.9n TO=1530.1n

.meas tran Vdout1_56ck124 AVG v(dout1_56) FROM=1529.9n TO=1530.1n

.meas tran Vdout1_57ck124 AVG v(dout1_57) FROM=1529.9n TO=1530.1n

.meas tran Vdout1_58ck124 AVG v(dout1_58) FROM=1529.9n TO=1530.1n

.meas tran Vdout1_59ck124 AVG v(dout1_59) FROM=1529.9n TO=1530.1n

.meas tran Vdout1_60ck124 AVG v(dout1_60) FROM=1529.9n TO=1530.1n

.meas tran Vdout1_61ck124 AVG v(dout1_61) FROM=1529.9n TO=1530.1n

.meas tran Vdout1_62ck124 AVG v(dout1_62) FROM=1529.9n TO=1530.1n

.meas tran Vdout1_63ck124 AVG v(dout1_63) FROM=1529.9n TO=1530.1n

.meas tran Vdout1_64ck124 AVG v(dout1_64) FROM=1529.9n TO=1530.1n

.meas tran Vdout1_65ck124 AVG v(dout1_65) FROM=1529.9n TO=1530.1n

.meas tran Vdout1_66ck124 AVG v(dout1_66) FROM=1529.9n TO=1530.1n

.meas tran Vdout1_67ck124 AVG v(dout1_67) FROM=1529.9n TO=1530.1n

.meas tran Vdout1_68ck124 AVG v(dout1_68) FROM=1529.9n TO=1530.1n

.meas tran Vdout1_69ck124 AVG v(dout1_69) FROM=1529.9n TO=1530.1n

.meas tran Vdout1_70ck124 AVG v(dout1_70) FROM=1529.9n TO=1530.1n

.meas tran Vdout1_71ck124 AVG v(dout1_71) FROM=1529.9n TO=1530.1n

.meas tran Vdout1_72ck124 AVG v(dout1_72) FROM=1529.9n TO=1530.1n

.meas tran Vdout1_73ck124 AVG v(dout1_73) FROM=1529.9n TO=1530.1n

.meas tran Vdout1_74ck124 AVG v(dout1_74) FROM=1529.9n TO=1530.1n

.meas tran Vdout1_75ck124 AVG v(dout1_75) FROM=1529.9n TO=1530.1n

.meas tran Vdout1_76ck124 AVG v(dout1_76) FROM=1529.9n TO=1530.1n

.meas tran Vdout1_77ck124 AVG v(dout1_77) FROM=1529.9n TO=1530.1n

.meas tran Vdout1_78ck124 AVG v(dout1_78) FROM=1529.9n TO=1530.1n

.meas tran Vdout1_79ck124 AVG v(dout1_79) FROM=1529.9n TO=1530.1n

.meas tran Vdout0_0ck125 AVG v(dout0_0) FROM=1539.9n TO=1540.1n

.meas tran Vdout0_1ck125 AVG v(dout0_1) FROM=1539.9n TO=1540.1n

.meas tran Vdout0_2ck125 AVG v(dout0_2) FROM=1539.9n TO=1540.1n

.meas tran Vdout0_3ck125 AVG v(dout0_3) FROM=1539.9n TO=1540.1n

.meas tran Vdout0_4ck125 AVG v(dout0_4) FROM=1539.9n TO=1540.1n

.meas tran Vdout0_5ck125 AVG v(dout0_5) FROM=1539.9n TO=1540.1n

.meas tran Vdout0_6ck125 AVG v(dout0_6) FROM=1539.9n TO=1540.1n

.meas tran Vdout0_7ck125 AVG v(dout0_7) FROM=1539.9n TO=1540.1n

.meas tran Vdout0_8ck125 AVG v(dout0_8) FROM=1539.9n TO=1540.1n

.meas tran Vdout0_9ck125 AVG v(dout0_9) FROM=1539.9n TO=1540.1n

.meas tran Vdout0_10ck125 AVG v(dout0_10) FROM=1539.9n TO=1540.1n

.meas tran Vdout0_11ck125 AVG v(dout0_11) FROM=1539.9n TO=1540.1n

.meas tran Vdout0_12ck125 AVG v(dout0_12) FROM=1539.9n TO=1540.1n

.meas tran Vdout0_13ck125 AVG v(dout0_13) FROM=1539.9n TO=1540.1n

.meas tran Vdout0_14ck125 AVG v(dout0_14) FROM=1539.9n TO=1540.1n

.meas tran Vdout0_15ck125 AVG v(dout0_15) FROM=1539.9n TO=1540.1n

.meas tran Vdout0_16ck125 AVG v(dout0_16) FROM=1539.9n TO=1540.1n

.meas tran Vdout0_17ck125 AVG v(dout0_17) FROM=1539.9n TO=1540.1n

.meas tran Vdout0_18ck125 AVG v(dout0_18) FROM=1539.9n TO=1540.1n

.meas tran Vdout0_19ck125 AVG v(dout0_19) FROM=1539.9n TO=1540.1n

.meas tran Vdout0_20ck125 AVG v(dout0_20) FROM=1539.9n TO=1540.1n

.meas tran Vdout0_21ck125 AVG v(dout0_21) FROM=1539.9n TO=1540.1n

.meas tran Vdout0_22ck125 AVG v(dout0_22) FROM=1539.9n TO=1540.1n

.meas tran Vdout0_23ck125 AVG v(dout0_23) FROM=1539.9n TO=1540.1n

.meas tran Vdout0_24ck125 AVG v(dout0_24) FROM=1539.9n TO=1540.1n

.meas tran Vdout0_25ck125 AVG v(dout0_25) FROM=1539.9n TO=1540.1n

.meas tran Vdout0_26ck125 AVG v(dout0_26) FROM=1539.9n TO=1540.1n

.meas tran Vdout0_27ck125 AVG v(dout0_27) FROM=1539.9n TO=1540.1n

.meas tran Vdout0_28ck125 AVG v(dout0_28) FROM=1539.9n TO=1540.1n

.meas tran Vdout0_29ck125 AVG v(dout0_29) FROM=1539.9n TO=1540.1n

.meas tran Vdout0_30ck125 AVG v(dout0_30) FROM=1539.9n TO=1540.1n

.meas tran Vdout0_31ck125 AVG v(dout0_31) FROM=1539.9n TO=1540.1n

.meas tran Vdout0_32ck125 AVG v(dout0_32) FROM=1539.9n TO=1540.1n

.meas tran Vdout0_33ck125 AVG v(dout0_33) FROM=1539.9n TO=1540.1n

.meas tran Vdout0_34ck125 AVG v(dout0_34) FROM=1539.9n TO=1540.1n

.meas tran Vdout0_35ck125 AVG v(dout0_35) FROM=1539.9n TO=1540.1n

.meas tran Vdout0_36ck125 AVG v(dout0_36) FROM=1539.9n TO=1540.1n

.meas tran Vdout0_37ck125 AVG v(dout0_37) FROM=1539.9n TO=1540.1n

.meas tran Vdout0_38ck125 AVG v(dout0_38) FROM=1539.9n TO=1540.1n

.meas tran Vdout0_39ck125 AVG v(dout0_39) FROM=1539.9n TO=1540.1n

.meas tran Vdout0_40ck125 AVG v(dout0_40) FROM=1539.9n TO=1540.1n

.meas tran Vdout0_41ck125 AVG v(dout0_41) FROM=1539.9n TO=1540.1n

.meas tran Vdout0_42ck125 AVG v(dout0_42) FROM=1539.9n TO=1540.1n

.meas tran Vdout0_43ck125 AVG v(dout0_43) FROM=1539.9n TO=1540.1n

.meas tran Vdout0_44ck125 AVG v(dout0_44) FROM=1539.9n TO=1540.1n

.meas tran Vdout0_45ck125 AVG v(dout0_45) FROM=1539.9n TO=1540.1n

.meas tran Vdout0_46ck125 AVG v(dout0_46) FROM=1539.9n TO=1540.1n

.meas tran Vdout0_47ck125 AVG v(dout0_47) FROM=1539.9n TO=1540.1n

.meas tran Vdout0_48ck125 AVG v(dout0_48) FROM=1539.9n TO=1540.1n

.meas tran Vdout0_49ck125 AVG v(dout0_49) FROM=1539.9n TO=1540.1n

.meas tran Vdout0_50ck125 AVG v(dout0_50) FROM=1539.9n TO=1540.1n

.meas tran Vdout0_51ck125 AVG v(dout0_51) FROM=1539.9n TO=1540.1n

.meas tran Vdout0_52ck125 AVG v(dout0_52) FROM=1539.9n TO=1540.1n

.meas tran Vdout0_53ck125 AVG v(dout0_53) FROM=1539.9n TO=1540.1n

.meas tran Vdout0_54ck125 AVG v(dout0_54) FROM=1539.9n TO=1540.1n

.meas tran Vdout0_55ck125 AVG v(dout0_55) FROM=1539.9n TO=1540.1n

.meas tran Vdout0_56ck125 AVG v(dout0_56) FROM=1539.9n TO=1540.1n

.meas tran Vdout0_57ck125 AVG v(dout0_57) FROM=1539.9n TO=1540.1n

.meas tran Vdout0_58ck125 AVG v(dout0_58) FROM=1539.9n TO=1540.1n

.meas tran Vdout0_59ck125 AVG v(dout0_59) FROM=1539.9n TO=1540.1n

.meas tran Vdout0_60ck125 AVG v(dout0_60) FROM=1539.9n TO=1540.1n

.meas tran Vdout0_61ck125 AVG v(dout0_61) FROM=1539.9n TO=1540.1n

.meas tran Vdout0_62ck125 AVG v(dout0_62) FROM=1539.9n TO=1540.1n

.meas tran Vdout0_63ck125 AVG v(dout0_63) FROM=1539.9n TO=1540.1n

.meas tran Vdout0_64ck125 AVG v(dout0_64) FROM=1539.9n TO=1540.1n

.meas tran Vdout0_65ck125 AVG v(dout0_65) FROM=1539.9n TO=1540.1n

.meas tran Vdout0_66ck125 AVG v(dout0_66) FROM=1539.9n TO=1540.1n

.meas tran Vdout0_67ck125 AVG v(dout0_67) FROM=1539.9n TO=1540.1n

.meas tran Vdout0_68ck125 AVG v(dout0_68) FROM=1539.9n TO=1540.1n

.meas tran Vdout0_69ck125 AVG v(dout0_69) FROM=1539.9n TO=1540.1n

.meas tran Vdout0_70ck125 AVG v(dout0_70) FROM=1539.9n TO=1540.1n

.meas tran Vdout0_71ck125 AVG v(dout0_71) FROM=1539.9n TO=1540.1n

.meas tran Vdout0_72ck125 AVG v(dout0_72) FROM=1539.9n TO=1540.1n

.meas tran Vdout0_73ck125 AVG v(dout0_73) FROM=1539.9n TO=1540.1n

.meas tran Vdout0_74ck125 AVG v(dout0_74) FROM=1539.9n TO=1540.1n

.meas tran Vdout0_75ck125 AVG v(dout0_75) FROM=1539.9n TO=1540.1n

.meas tran Vdout0_76ck125 AVG v(dout0_76) FROM=1539.9n TO=1540.1n

.meas tran Vdout0_77ck125 AVG v(dout0_77) FROM=1539.9n TO=1540.1n

.meas tran Vdout0_78ck125 AVG v(dout0_78) FROM=1539.9n TO=1540.1n

.meas tran Vdout0_79ck125 AVG v(dout0_79) FROM=1539.9n TO=1540.1n

.meas tran Vdout1_0ck126 AVG v(dout1_0) FROM=1559.9n TO=1560.1n

.meas tran Vdout1_1ck126 AVG v(dout1_1) FROM=1559.9n TO=1560.1n

.meas tran Vdout1_2ck126 AVG v(dout1_2) FROM=1559.9n TO=1560.1n

.meas tran Vdout1_3ck126 AVG v(dout1_3) FROM=1559.9n TO=1560.1n

.meas tran Vdout1_4ck126 AVG v(dout1_4) FROM=1559.9n TO=1560.1n

.meas tran Vdout1_5ck126 AVG v(dout1_5) FROM=1559.9n TO=1560.1n

.meas tran Vdout1_6ck126 AVG v(dout1_6) FROM=1559.9n TO=1560.1n

.meas tran Vdout1_7ck126 AVG v(dout1_7) FROM=1559.9n TO=1560.1n

.meas tran Vdout1_8ck126 AVG v(dout1_8) FROM=1559.9n TO=1560.1n

.meas tran Vdout1_9ck126 AVG v(dout1_9) FROM=1559.9n TO=1560.1n

.meas tran Vdout1_10ck126 AVG v(dout1_10) FROM=1559.9n TO=1560.1n

.meas tran Vdout1_11ck126 AVG v(dout1_11) FROM=1559.9n TO=1560.1n

.meas tran Vdout1_12ck126 AVG v(dout1_12) FROM=1559.9n TO=1560.1n

.meas tran Vdout1_13ck126 AVG v(dout1_13) FROM=1559.9n TO=1560.1n

.meas tran Vdout1_14ck126 AVG v(dout1_14) FROM=1559.9n TO=1560.1n

.meas tran Vdout1_15ck126 AVG v(dout1_15) FROM=1559.9n TO=1560.1n

.meas tran Vdout1_16ck126 AVG v(dout1_16) FROM=1559.9n TO=1560.1n

.meas tran Vdout1_17ck126 AVG v(dout1_17) FROM=1559.9n TO=1560.1n

.meas tran Vdout1_18ck126 AVG v(dout1_18) FROM=1559.9n TO=1560.1n

.meas tran Vdout1_19ck126 AVG v(dout1_19) FROM=1559.9n TO=1560.1n

.meas tran Vdout1_20ck126 AVG v(dout1_20) FROM=1559.9n TO=1560.1n

.meas tran Vdout1_21ck126 AVG v(dout1_21) FROM=1559.9n TO=1560.1n

.meas tran Vdout1_22ck126 AVG v(dout1_22) FROM=1559.9n TO=1560.1n

.meas tran Vdout1_23ck126 AVG v(dout1_23) FROM=1559.9n TO=1560.1n

.meas tran Vdout1_24ck126 AVG v(dout1_24) FROM=1559.9n TO=1560.1n

.meas tran Vdout1_25ck126 AVG v(dout1_25) FROM=1559.9n TO=1560.1n

.meas tran Vdout1_26ck126 AVG v(dout1_26) FROM=1559.9n TO=1560.1n

.meas tran Vdout1_27ck126 AVG v(dout1_27) FROM=1559.9n TO=1560.1n

.meas tran Vdout1_28ck126 AVG v(dout1_28) FROM=1559.9n TO=1560.1n

.meas tran Vdout1_29ck126 AVG v(dout1_29) FROM=1559.9n TO=1560.1n

.meas tran Vdout1_30ck126 AVG v(dout1_30) FROM=1559.9n TO=1560.1n

.meas tran Vdout1_31ck126 AVG v(dout1_31) FROM=1559.9n TO=1560.1n

.meas tran Vdout1_32ck126 AVG v(dout1_32) FROM=1559.9n TO=1560.1n

.meas tran Vdout1_33ck126 AVG v(dout1_33) FROM=1559.9n TO=1560.1n

.meas tran Vdout1_34ck126 AVG v(dout1_34) FROM=1559.9n TO=1560.1n

.meas tran Vdout1_35ck126 AVG v(dout1_35) FROM=1559.9n TO=1560.1n

.meas tran Vdout1_36ck126 AVG v(dout1_36) FROM=1559.9n TO=1560.1n

.meas tran Vdout1_37ck126 AVG v(dout1_37) FROM=1559.9n TO=1560.1n

.meas tran Vdout1_38ck126 AVG v(dout1_38) FROM=1559.9n TO=1560.1n

.meas tran Vdout1_39ck126 AVG v(dout1_39) FROM=1559.9n TO=1560.1n

.meas tran Vdout1_40ck126 AVG v(dout1_40) FROM=1559.9n TO=1560.1n

.meas tran Vdout1_41ck126 AVG v(dout1_41) FROM=1559.9n TO=1560.1n

.meas tran Vdout1_42ck126 AVG v(dout1_42) FROM=1559.9n TO=1560.1n

.meas tran Vdout1_43ck126 AVG v(dout1_43) FROM=1559.9n TO=1560.1n

.meas tran Vdout1_44ck126 AVG v(dout1_44) FROM=1559.9n TO=1560.1n

.meas tran Vdout1_45ck126 AVG v(dout1_45) FROM=1559.9n TO=1560.1n

.meas tran Vdout1_46ck126 AVG v(dout1_46) FROM=1559.9n TO=1560.1n

.meas tran Vdout1_47ck126 AVG v(dout1_47) FROM=1559.9n TO=1560.1n

.meas tran Vdout1_48ck126 AVG v(dout1_48) FROM=1559.9n TO=1560.1n

.meas tran Vdout1_49ck126 AVG v(dout1_49) FROM=1559.9n TO=1560.1n

.meas tran Vdout1_50ck126 AVG v(dout1_50) FROM=1559.9n TO=1560.1n

.meas tran Vdout1_51ck126 AVG v(dout1_51) FROM=1559.9n TO=1560.1n

.meas tran Vdout1_52ck126 AVG v(dout1_52) FROM=1559.9n TO=1560.1n

.meas tran Vdout1_53ck126 AVG v(dout1_53) FROM=1559.9n TO=1560.1n

.meas tran Vdout1_54ck126 AVG v(dout1_54) FROM=1559.9n TO=1560.1n

.meas tran Vdout1_55ck126 AVG v(dout1_55) FROM=1559.9n TO=1560.1n

.meas tran Vdout1_56ck126 AVG v(dout1_56) FROM=1559.9n TO=1560.1n

.meas tran Vdout1_57ck126 AVG v(dout1_57) FROM=1559.9n TO=1560.1n

.meas tran Vdout1_58ck126 AVG v(dout1_58) FROM=1559.9n TO=1560.1n

.meas tran Vdout1_59ck126 AVG v(dout1_59) FROM=1559.9n TO=1560.1n

.meas tran Vdout1_60ck126 AVG v(dout1_60) FROM=1559.9n TO=1560.1n

.meas tran Vdout1_61ck126 AVG v(dout1_61) FROM=1559.9n TO=1560.1n

.meas tran Vdout1_62ck126 AVG v(dout1_62) FROM=1559.9n TO=1560.1n

.meas tran Vdout1_63ck126 AVG v(dout1_63) FROM=1559.9n TO=1560.1n

.meas tran Vdout1_64ck126 AVG v(dout1_64) FROM=1559.9n TO=1560.1n

.meas tran Vdout1_65ck126 AVG v(dout1_65) FROM=1559.9n TO=1560.1n

.meas tran Vdout1_66ck126 AVG v(dout1_66) FROM=1559.9n TO=1560.1n

.meas tran Vdout1_67ck126 AVG v(dout1_67) FROM=1559.9n TO=1560.1n

.meas tran Vdout1_68ck126 AVG v(dout1_68) FROM=1559.9n TO=1560.1n

.meas tran Vdout1_69ck126 AVG v(dout1_69) FROM=1559.9n TO=1560.1n

.meas tran Vdout1_70ck126 AVG v(dout1_70) FROM=1559.9n TO=1560.1n

.meas tran Vdout1_71ck126 AVG v(dout1_71) FROM=1559.9n TO=1560.1n

.meas tran Vdout1_72ck126 AVG v(dout1_72) FROM=1559.9n TO=1560.1n

.meas tran Vdout1_73ck126 AVG v(dout1_73) FROM=1559.9n TO=1560.1n

.meas tran Vdout1_74ck126 AVG v(dout1_74) FROM=1559.9n TO=1560.1n

.meas tran Vdout1_75ck126 AVG v(dout1_75) FROM=1559.9n TO=1560.1n

.meas tran Vdout1_76ck126 AVG v(dout1_76) FROM=1559.9n TO=1560.1n

.meas tran Vdout1_77ck126 AVG v(dout1_77) FROM=1559.9n TO=1560.1n

.meas tran Vdout1_78ck126 AVG v(dout1_78) FROM=1559.9n TO=1560.1n

.meas tran Vdout1_79ck126 AVG v(dout1_79) FROM=1559.9n TO=1560.1n

.meas tran Vdout1_0ck127 AVG v(dout1_0) FROM=1569.9n TO=1570.1n

.meas tran Vdout1_1ck127 AVG v(dout1_1) FROM=1569.9n TO=1570.1n

.meas tran Vdout1_2ck127 AVG v(dout1_2) FROM=1569.9n TO=1570.1n

.meas tran Vdout1_3ck127 AVG v(dout1_3) FROM=1569.9n TO=1570.1n

.meas tran Vdout1_4ck127 AVG v(dout1_4) FROM=1569.9n TO=1570.1n

.meas tran Vdout1_5ck127 AVG v(dout1_5) FROM=1569.9n TO=1570.1n

.meas tran Vdout1_6ck127 AVG v(dout1_6) FROM=1569.9n TO=1570.1n

.meas tran Vdout1_7ck127 AVG v(dout1_7) FROM=1569.9n TO=1570.1n

.meas tran Vdout1_8ck127 AVG v(dout1_8) FROM=1569.9n TO=1570.1n

.meas tran Vdout1_9ck127 AVG v(dout1_9) FROM=1569.9n TO=1570.1n

.meas tran Vdout1_10ck127 AVG v(dout1_10) FROM=1569.9n TO=1570.1n

.meas tran Vdout1_11ck127 AVG v(dout1_11) FROM=1569.9n TO=1570.1n

.meas tran Vdout1_12ck127 AVG v(dout1_12) FROM=1569.9n TO=1570.1n

.meas tran Vdout1_13ck127 AVG v(dout1_13) FROM=1569.9n TO=1570.1n

.meas tran Vdout1_14ck127 AVG v(dout1_14) FROM=1569.9n TO=1570.1n

.meas tran Vdout1_15ck127 AVG v(dout1_15) FROM=1569.9n TO=1570.1n

.meas tran Vdout1_16ck127 AVG v(dout1_16) FROM=1569.9n TO=1570.1n

.meas tran Vdout1_17ck127 AVG v(dout1_17) FROM=1569.9n TO=1570.1n

.meas tran Vdout1_18ck127 AVG v(dout1_18) FROM=1569.9n TO=1570.1n

.meas tran Vdout1_19ck127 AVG v(dout1_19) FROM=1569.9n TO=1570.1n

.meas tran Vdout1_20ck127 AVG v(dout1_20) FROM=1569.9n TO=1570.1n

.meas tran Vdout1_21ck127 AVG v(dout1_21) FROM=1569.9n TO=1570.1n

.meas tran Vdout1_22ck127 AVG v(dout1_22) FROM=1569.9n TO=1570.1n

.meas tran Vdout1_23ck127 AVG v(dout1_23) FROM=1569.9n TO=1570.1n

.meas tran Vdout1_24ck127 AVG v(dout1_24) FROM=1569.9n TO=1570.1n

.meas tran Vdout1_25ck127 AVG v(dout1_25) FROM=1569.9n TO=1570.1n

.meas tran Vdout1_26ck127 AVG v(dout1_26) FROM=1569.9n TO=1570.1n

.meas tran Vdout1_27ck127 AVG v(dout1_27) FROM=1569.9n TO=1570.1n

.meas tran Vdout1_28ck127 AVG v(dout1_28) FROM=1569.9n TO=1570.1n

.meas tran Vdout1_29ck127 AVG v(dout1_29) FROM=1569.9n TO=1570.1n

.meas tran Vdout1_30ck127 AVG v(dout1_30) FROM=1569.9n TO=1570.1n

.meas tran Vdout1_31ck127 AVG v(dout1_31) FROM=1569.9n TO=1570.1n

.meas tran Vdout1_32ck127 AVG v(dout1_32) FROM=1569.9n TO=1570.1n

.meas tran Vdout1_33ck127 AVG v(dout1_33) FROM=1569.9n TO=1570.1n

.meas tran Vdout1_34ck127 AVG v(dout1_34) FROM=1569.9n TO=1570.1n

.meas tran Vdout1_35ck127 AVG v(dout1_35) FROM=1569.9n TO=1570.1n

.meas tran Vdout1_36ck127 AVG v(dout1_36) FROM=1569.9n TO=1570.1n

.meas tran Vdout1_37ck127 AVG v(dout1_37) FROM=1569.9n TO=1570.1n

.meas tran Vdout1_38ck127 AVG v(dout1_38) FROM=1569.9n TO=1570.1n

.meas tran Vdout1_39ck127 AVG v(dout1_39) FROM=1569.9n TO=1570.1n

.meas tran Vdout1_40ck127 AVG v(dout1_40) FROM=1569.9n TO=1570.1n

.meas tran Vdout1_41ck127 AVG v(dout1_41) FROM=1569.9n TO=1570.1n

.meas tran Vdout1_42ck127 AVG v(dout1_42) FROM=1569.9n TO=1570.1n

.meas tran Vdout1_43ck127 AVG v(dout1_43) FROM=1569.9n TO=1570.1n

.meas tran Vdout1_44ck127 AVG v(dout1_44) FROM=1569.9n TO=1570.1n

.meas tran Vdout1_45ck127 AVG v(dout1_45) FROM=1569.9n TO=1570.1n

.meas tran Vdout1_46ck127 AVG v(dout1_46) FROM=1569.9n TO=1570.1n

.meas tran Vdout1_47ck127 AVG v(dout1_47) FROM=1569.9n TO=1570.1n

.meas tran Vdout1_48ck127 AVG v(dout1_48) FROM=1569.9n TO=1570.1n

.meas tran Vdout1_49ck127 AVG v(dout1_49) FROM=1569.9n TO=1570.1n

.meas tran Vdout1_50ck127 AVG v(dout1_50) FROM=1569.9n TO=1570.1n

.meas tran Vdout1_51ck127 AVG v(dout1_51) FROM=1569.9n TO=1570.1n

.meas tran Vdout1_52ck127 AVG v(dout1_52) FROM=1569.9n TO=1570.1n

.meas tran Vdout1_53ck127 AVG v(dout1_53) FROM=1569.9n TO=1570.1n

.meas tran Vdout1_54ck127 AVG v(dout1_54) FROM=1569.9n TO=1570.1n

.meas tran Vdout1_55ck127 AVG v(dout1_55) FROM=1569.9n TO=1570.1n

.meas tran Vdout1_56ck127 AVG v(dout1_56) FROM=1569.9n TO=1570.1n

.meas tran Vdout1_57ck127 AVG v(dout1_57) FROM=1569.9n TO=1570.1n

.meas tran Vdout1_58ck127 AVG v(dout1_58) FROM=1569.9n TO=1570.1n

.meas tran Vdout1_59ck127 AVG v(dout1_59) FROM=1569.9n TO=1570.1n

.meas tran Vdout1_60ck127 AVG v(dout1_60) FROM=1569.9n TO=1570.1n

.meas tran Vdout1_61ck127 AVG v(dout1_61) FROM=1569.9n TO=1570.1n

.meas tran Vdout1_62ck127 AVG v(dout1_62) FROM=1569.9n TO=1570.1n

.meas tran Vdout1_63ck127 AVG v(dout1_63) FROM=1569.9n TO=1570.1n

.meas tran Vdout1_64ck127 AVG v(dout1_64) FROM=1569.9n TO=1570.1n

.meas tran Vdout1_65ck127 AVG v(dout1_65) FROM=1569.9n TO=1570.1n

.meas tran Vdout1_66ck127 AVG v(dout1_66) FROM=1569.9n TO=1570.1n

.meas tran Vdout1_67ck127 AVG v(dout1_67) FROM=1569.9n TO=1570.1n

.meas tran Vdout1_68ck127 AVG v(dout1_68) FROM=1569.9n TO=1570.1n

.meas tran Vdout1_69ck127 AVG v(dout1_69) FROM=1569.9n TO=1570.1n

.meas tran Vdout1_70ck127 AVG v(dout1_70) FROM=1569.9n TO=1570.1n

.meas tran Vdout1_71ck127 AVG v(dout1_71) FROM=1569.9n TO=1570.1n

.meas tran Vdout1_72ck127 AVG v(dout1_72) FROM=1569.9n TO=1570.1n

.meas tran Vdout1_73ck127 AVG v(dout1_73) FROM=1569.9n TO=1570.1n

.meas tran Vdout1_74ck127 AVG v(dout1_74) FROM=1569.9n TO=1570.1n

.meas tran Vdout1_75ck127 AVG v(dout1_75) FROM=1569.9n TO=1570.1n

.meas tran Vdout1_76ck127 AVG v(dout1_76) FROM=1569.9n TO=1570.1n

.meas tran Vdout1_77ck127 AVG v(dout1_77) FROM=1569.9n TO=1570.1n

.meas tran Vdout1_78ck127 AVG v(dout1_78) FROM=1569.9n TO=1570.1n

.meas tran Vdout1_79ck127 AVG v(dout1_79) FROM=1569.9n TO=1570.1n

.meas tran Vdout0_0ck128 AVG v(dout0_0) FROM=1579.9n TO=1580.1n

.meas tran Vdout0_1ck128 AVG v(dout0_1) FROM=1579.9n TO=1580.1n

.meas tran Vdout0_2ck128 AVG v(dout0_2) FROM=1579.9n TO=1580.1n

.meas tran Vdout0_3ck128 AVG v(dout0_3) FROM=1579.9n TO=1580.1n

.meas tran Vdout0_4ck128 AVG v(dout0_4) FROM=1579.9n TO=1580.1n

.meas tran Vdout0_5ck128 AVG v(dout0_5) FROM=1579.9n TO=1580.1n

.meas tran Vdout0_6ck128 AVG v(dout0_6) FROM=1579.9n TO=1580.1n

.meas tran Vdout0_7ck128 AVG v(dout0_7) FROM=1579.9n TO=1580.1n

.meas tran Vdout0_8ck128 AVG v(dout0_8) FROM=1579.9n TO=1580.1n

.meas tran Vdout0_9ck128 AVG v(dout0_9) FROM=1579.9n TO=1580.1n

.meas tran Vdout0_10ck128 AVG v(dout0_10) FROM=1579.9n TO=1580.1n

.meas tran Vdout0_11ck128 AVG v(dout0_11) FROM=1579.9n TO=1580.1n

.meas tran Vdout0_12ck128 AVG v(dout0_12) FROM=1579.9n TO=1580.1n

.meas tran Vdout0_13ck128 AVG v(dout0_13) FROM=1579.9n TO=1580.1n

.meas tran Vdout0_14ck128 AVG v(dout0_14) FROM=1579.9n TO=1580.1n

.meas tran Vdout0_15ck128 AVG v(dout0_15) FROM=1579.9n TO=1580.1n

.meas tran Vdout0_16ck128 AVG v(dout0_16) FROM=1579.9n TO=1580.1n

.meas tran Vdout0_17ck128 AVG v(dout0_17) FROM=1579.9n TO=1580.1n

.meas tran Vdout0_18ck128 AVG v(dout0_18) FROM=1579.9n TO=1580.1n

.meas tran Vdout0_19ck128 AVG v(dout0_19) FROM=1579.9n TO=1580.1n

.meas tran Vdout0_20ck128 AVG v(dout0_20) FROM=1579.9n TO=1580.1n

.meas tran Vdout0_21ck128 AVG v(dout0_21) FROM=1579.9n TO=1580.1n

.meas tran Vdout0_22ck128 AVG v(dout0_22) FROM=1579.9n TO=1580.1n

.meas tran Vdout0_23ck128 AVG v(dout0_23) FROM=1579.9n TO=1580.1n

.meas tran Vdout0_24ck128 AVG v(dout0_24) FROM=1579.9n TO=1580.1n

.meas tran Vdout0_25ck128 AVG v(dout0_25) FROM=1579.9n TO=1580.1n

.meas tran Vdout0_26ck128 AVG v(dout0_26) FROM=1579.9n TO=1580.1n

.meas tran Vdout0_27ck128 AVG v(dout0_27) FROM=1579.9n TO=1580.1n

.meas tran Vdout0_28ck128 AVG v(dout0_28) FROM=1579.9n TO=1580.1n

.meas tran Vdout0_29ck128 AVG v(dout0_29) FROM=1579.9n TO=1580.1n

.meas tran Vdout0_30ck128 AVG v(dout0_30) FROM=1579.9n TO=1580.1n

.meas tran Vdout0_31ck128 AVG v(dout0_31) FROM=1579.9n TO=1580.1n

.meas tran Vdout0_32ck128 AVG v(dout0_32) FROM=1579.9n TO=1580.1n

.meas tran Vdout0_33ck128 AVG v(dout0_33) FROM=1579.9n TO=1580.1n

.meas tran Vdout0_34ck128 AVG v(dout0_34) FROM=1579.9n TO=1580.1n

.meas tran Vdout0_35ck128 AVG v(dout0_35) FROM=1579.9n TO=1580.1n

.meas tran Vdout0_36ck128 AVG v(dout0_36) FROM=1579.9n TO=1580.1n

.meas tran Vdout0_37ck128 AVG v(dout0_37) FROM=1579.9n TO=1580.1n

.meas tran Vdout0_38ck128 AVG v(dout0_38) FROM=1579.9n TO=1580.1n

.meas tran Vdout0_39ck128 AVG v(dout0_39) FROM=1579.9n TO=1580.1n

.meas tran Vdout0_40ck128 AVG v(dout0_40) FROM=1579.9n TO=1580.1n

.meas tran Vdout0_41ck128 AVG v(dout0_41) FROM=1579.9n TO=1580.1n

.meas tran Vdout0_42ck128 AVG v(dout0_42) FROM=1579.9n TO=1580.1n

.meas tran Vdout0_43ck128 AVG v(dout0_43) FROM=1579.9n TO=1580.1n

.meas tran Vdout0_44ck128 AVG v(dout0_44) FROM=1579.9n TO=1580.1n

.meas tran Vdout0_45ck128 AVG v(dout0_45) FROM=1579.9n TO=1580.1n

.meas tran Vdout0_46ck128 AVG v(dout0_46) FROM=1579.9n TO=1580.1n

.meas tran Vdout0_47ck128 AVG v(dout0_47) FROM=1579.9n TO=1580.1n

.meas tran Vdout0_48ck128 AVG v(dout0_48) FROM=1579.9n TO=1580.1n

.meas tran Vdout0_49ck128 AVG v(dout0_49) FROM=1579.9n TO=1580.1n

.meas tran Vdout0_50ck128 AVG v(dout0_50) FROM=1579.9n TO=1580.1n

.meas tran Vdout0_51ck128 AVG v(dout0_51) FROM=1579.9n TO=1580.1n

.meas tran Vdout0_52ck128 AVG v(dout0_52) FROM=1579.9n TO=1580.1n

.meas tran Vdout0_53ck128 AVG v(dout0_53) FROM=1579.9n TO=1580.1n

.meas tran Vdout0_54ck128 AVG v(dout0_54) FROM=1579.9n TO=1580.1n

.meas tran Vdout0_55ck128 AVG v(dout0_55) FROM=1579.9n TO=1580.1n

.meas tran Vdout0_56ck128 AVG v(dout0_56) FROM=1579.9n TO=1580.1n

.meas tran Vdout0_57ck128 AVG v(dout0_57) FROM=1579.9n TO=1580.1n

.meas tran Vdout0_58ck128 AVG v(dout0_58) FROM=1579.9n TO=1580.1n

.meas tran Vdout0_59ck128 AVG v(dout0_59) FROM=1579.9n TO=1580.1n

.meas tran Vdout0_60ck128 AVG v(dout0_60) FROM=1579.9n TO=1580.1n

.meas tran Vdout0_61ck128 AVG v(dout0_61) FROM=1579.9n TO=1580.1n

.meas tran Vdout0_62ck128 AVG v(dout0_62) FROM=1579.9n TO=1580.1n

.meas tran Vdout0_63ck128 AVG v(dout0_63) FROM=1579.9n TO=1580.1n

.meas tran Vdout0_64ck128 AVG v(dout0_64) FROM=1579.9n TO=1580.1n

.meas tran Vdout0_65ck128 AVG v(dout0_65) FROM=1579.9n TO=1580.1n

.meas tran Vdout0_66ck128 AVG v(dout0_66) FROM=1579.9n TO=1580.1n

.meas tran Vdout0_67ck128 AVG v(dout0_67) FROM=1579.9n TO=1580.1n

.meas tran Vdout0_68ck128 AVG v(dout0_68) FROM=1579.9n TO=1580.1n

.meas tran Vdout0_69ck128 AVG v(dout0_69) FROM=1579.9n TO=1580.1n

.meas tran Vdout0_70ck128 AVG v(dout0_70) FROM=1579.9n TO=1580.1n

.meas tran Vdout0_71ck128 AVG v(dout0_71) FROM=1579.9n TO=1580.1n

.meas tran Vdout0_72ck128 AVG v(dout0_72) FROM=1579.9n TO=1580.1n

.meas tran Vdout0_73ck128 AVG v(dout0_73) FROM=1579.9n TO=1580.1n

.meas tran Vdout0_74ck128 AVG v(dout0_74) FROM=1579.9n TO=1580.1n

.meas tran Vdout0_75ck128 AVG v(dout0_75) FROM=1579.9n TO=1580.1n

.meas tran Vdout0_76ck128 AVG v(dout0_76) FROM=1579.9n TO=1580.1n

.meas tran Vdout0_77ck128 AVG v(dout0_77) FROM=1579.9n TO=1580.1n

.meas tran Vdout0_78ck128 AVG v(dout0_78) FROM=1579.9n TO=1580.1n

.meas tran Vdout0_79ck128 AVG v(dout0_79) FROM=1579.9n TO=1580.1n

.meas tran Vdout1_0ck129 AVG v(dout1_0) FROM=1579.9n TO=1580.1n

.meas tran Vdout1_1ck129 AVG v(dout1_1) FROM=1579.9n TO=1580.1n

.meas tran Vdout1_2ck129 AVG v(dout1_2) FROM=1579.9n TO=1580.1n

.meas tran Vdout1_3ck129 AVG v(dout1_3) FROM=1579.9n TO=1580.1n

.meas tran Vdout1_4ck129 AVG v(dout1_4) FROM=1579.9n TO=1580.1n

.meas tran Vdout1_5ck129 AVG v(dout1_5) FROM=1579.9n TO=1580.1n

.meas tran Vdout1_6ck129 AVG v(dout1_6) FROM=1579.9n TO=1580.1n

.meas tran Vdout1_7ck129 AVG v(dout1_7) FROM=1579.9n TO=1580.1n

.meas tran Vdout1_8ck129 AVG v(dout1_8) FROM=1579.9n TO=1580.1n

.meas tran Vdout1_9ck129 AVG v(dout1_9) FROM=1579.9n TO=1580.1n

.meas tran Vdout1_10ck129 AVG v(dout1_10) FROM=1579.9n TO=1580.1n

.meas tran Vdout1_11ck129 AVG v(dout1_11) FROM=1579.9n TO=1580.1n

.meas tran Vdout1_12ck129 AVG v(dout1_12) FROM=1579.9n TO=1580.1n

.meas tran Vdout1_13ck129 AVG v(dout1_13) FROM=1579.9n TO=1580.1n

.meas tran Vdout1_14ck129 AVG v(dout1_14) FROM=1579.9n TO=1580.1n

.meas tran Vdout1_15ck129 AVG v(dout1_15) FROM=1579.9n TO=1580.1n

.meas tran Vdout1_16ck129 AVG v(dout1_16) FROM=1579.9n TO=1580.1n

.meas tran Vdout1_17ck129 AVG v(dout1_17) FROM=1579.9n TO=1580.1n

.meas tran Vdout1_18ck129 AVG v(dout1_18) FROM=1579.9n TO=1580.1n

.meas tran Vdout1_19ck129 AVG v(dout1_19) FROM=1579.9n TO=1580.1n

.meas tran Vdout1_20ck129 AVG v(dout1_20) FROM=1579.9n TO=1580.1n

.meas tran Vdout1_21ck129 AVG v(dout1_21) FROM=1579.9n TO=1580.1n

.meas tran Vdout1_22ck129 AVG v(dout1_22) FROM=1579.9n TO=1580.1n

.meas tran Vdout1_23ck129 AVG v(dout1_23) FROM=1579.9n TO=1580.1n

.meas tran Vdout1_24ck129 AVG v(dout1_24) FROM=1579.9n TO=1580.1n

.meas tran Vdout1_25ck129 AVG v(dout1_25) FROM=1579.9n TO=1580.1n

.meas tran Vdout1_26ck129 AVG v(dout1_26) FROM=1579.9n TO=1580.1n

.meas tran Vdout1_27ck129 AVG v(dout1_27) FROM=1579.9n TO=1580.1n

.meas tran Vdout1_28ck129 AVG v(dout1_28) FROM=1579.9n TO=1580.1n

.meas tran Vdout1_29ck129 AVG v(dout1_29) FROM=1579.9n TO=1580.1n

.meas tran Vdout1_30ck129 AVG v(dout1_30) FROM=1579.9n TO=1580.1n

.meas tran Vdout1_31ck129 AVG v(dout1_31) FROM=1579.9n TO=1580.1n

.meas tran Vdout1_32ck129 AVG v(dout1_32) FROM=1579.9n TO=1580.1n

.meas tran Vdout1_33ck129 AVG v(dout1_33) FROM=1579.9n TO=1580.1n

.meas tran Vdout1_34ck129 AVG v(dout1_34) FROM=1579.9n TO=1580.1n

.meas tran Vdout1_35ck129 AVG v(dout1_35) FROM=1579.9n TO=1580.1n

.meas tran Vdout1_36ck129 AVG v(dout1_36) FROM=1579.9n TO=1580.1n

.meas tran Vdout1_37ck129 AVG v(dout1_37) FROM=1579.9n TO=1580.1n

.meas tran Vdout1_38ck129 AVG v(dout1_38) FROM=1579.9n TO=1580.1n

.meas tran Vdout1_39ck129 AVG v(dout1_39) FROM=1579.9n TO=1580.1n

.meas tran Vdout1_40ck129 AVG v(dout1_40) FROM=1579.9n TO=1580.1n

.meas tran Vdout1_41ck129 AVG v(dout1_41) FROM=1579.9n TO=1580.1n

.meas tran Vdout1_42ck129 AVG v(dout1_42) FROM=1579.9n TO=1580.1n

.meas tran Vdout1_43ck129 AVG v(dout1_43) FROM=1579.9n TO=1580.1n

.meas tran Vdout1_44ck129 AVG v(dout1_44) FROM=1579.9n TO=1580.1n

.meas tran Vdout1_45ck129 AVG v(dout1_45) FROM=1579.9n TO=1580.1n

.meas tran Vdout1_46ck129 AVG v(dout1_46) FROM=1579.9n TO=1580.1n

.meas tran Vdout1_47ck129 AVG v(dout1_47) FROM=1579.9n TO=1580.1n

.meas tran Vdout1_48ck129 AVG v(dout1_48) FROM=1579.9n TO=1580.1n

.meas tran Vdout1_49ck129 AVG v(dout1_49) FROM=1579.9n TO=1580.1n

.meas tran Vdout1_50ck129 AVG v(dout1_50) FROM=1579.9n TO=1580.1n

.meas tran Vdout1_51ck129 AVG v(dout1_51) FROM=1579.9n TO=1580.1n

.meas tran Vdout1_52ck129 AVG v(dout1_52) FROM=1579.9n TO=1580.1n

.meas tran Vdout1_53ck129 AVG v(dout1_53) FROM=1579.9n TO=1580.1n

.meas tran Vdout1_54ck129 AVG v(dout1_54) FROM=1579.9n TO=1580.1n

.meas tran Vdout1_55ck129 AVG v(dout1_55) FROM=1579.9n TO=1580.1n

.meas tran Vdout1_56ck129 AVG v(dout1_56) FROM=1579.9n TO=1580.1n

.meas tran Vdout1_57ck129 AVG v(dout1_57) FROM=1579.9n TO=1580.1n

.meas tran Vdout1_58ck129 AVG v(dout1_58) FROM=1579.9n TO=1580.1n

.meas tran Vdout1_59ck129 AVG v(dout1_59) FROM=1579.9n TO=1580.1n

.meas tran Vdout1_60ck129 AVG v(dout1_60) FROM=1579.9n TO=1580.1n

.meas tran Vdout1_61ck129 AVG v(dout1_61) FROM=1579.9n TO=1580.1n

.meas tran Vdout1_62ck129 AVG v(dout1_62) FROM=1579.9n TO=1580.1n

.meas tran Vdout1_63ck129 AVG v(dout1_63) FROM=1579.9n TO=1580.1n

.meas tran Vdout1_64ck129 AVG v(dout1_64) FROM=1579.9n TO=1580.1n

.meas tran Vdout1_65ck129 AVG v(dout1_65) FROM=1579.9n TO=1580.1n

.meas tran Vdout1_66ck129 AVG v(dout1_66) FROM=1579.9n TO=1580.1n

.meas tran Vdout1_67ck129 AVG v(dout1_67) FROM=1579.9n TO=1580.1n

.meas tran Vdout1_68ck129 AVG v(dout1_68) FROM=1579.9n TO=1580.1n

.meas tran Vdout1_69ck129 AVG v(dout1_69) FROM=1579.9n TO=1580.1n

.meas tran Vdout1_70ck129 AVG v(dout1_70) FROM=1579.9n TO=1580.1n

.meas tran Vdout1_71ck129 AVG v(dout1_71) FROM=1579.9n TO=1580.1n

.meas tran Vdout1_72ck129 AVG v(dout1_72) FROM=1579.9n TO=1580.1n

.meas tran Vdout1_73ck129 AVG v(dout1_73) FROM=1579.9n TO=1580.1n

.meas tran Vdout1_74ck129 AVG v(dout1_74) FROM=1579.9n TO=1580.1n

.meas tran Vdout1_75ck129 AVG v(dout1_75) FROM=1579.9n TO=1580.1n

.meas tran Vdout1_76ck129 AVG v(dout1_76) FROM=1579.9n TO=1580.1n

.meas tran Vdout1_77ck129 AVG v(dout1_77) FROM=1579.9n TO=1580.1n

.meas tran Vdout1_78ck129 AVG v(dout1_78) FROM=1579.9n TO=1580.1n

.meas tran Vdout1_79ck129 AVG v(dout1_79) FROM=1579.9n TO=1580.1n

.meas tran Vdout1_0ck130 AVG v(dout1_0) FROM=1589.9n TO=1590.1n

.meas tran Vdout1_1ck130 AVG v(dout1_1) FROM=1589.9n TO=1590.1n

.meas tran Vdout1_2ck130 AVG v(dout1_2) FROM=1589.9n TO=1590.1n

.meas tran Vdout1_3ck130 AVG v(dout1_3) FROM=1589.9n TO=1590.1n

.meas tran Vdout1_4ck130 AVG v(dout1_4) FROM=1589.9n TO=1590.1n

.meas tran Vdout1_5ck130 AVG v(dout1_5) FROM=1589.9n TO=1590.1n

.meas tran Vdout1_6ck130 AVG v(dout1_6) FROM=1589.9n TO=1590.1n

.meas tran Vdout1_7ck130 AVG v(dout1_7) FROM=1589.9n TO=1590.1n

.meas tran Vdout1_8ck130 AVG v(dout1_8) FROM=1589.9n TO=1590.1n

.meas tran Vdout1_9ck130 AVG v(dout1_9) FROM=1589.9n TO=1590.1n

.meas tran Vdout1_10ck130 AVG v(dout1_10) FROM=1589.9n TO=1590.1n

.meas tran Vdout1_11ck130 AVG v(dout1_11) FROM=1589.9n TO=1590.1n

.meas tran Vdout1_12ck130 AVG v(dout1_12) FROM=1589.9n TO=1590.1n

.meas tran Vdout1_13ck130 AVG v(dout1_13) FROM=1589.9n TO=1590.1n

.meas tran Vdout1_14ck130 AVG v(dout1_14) FROM=1589.9n TO=1590.1n

.meas tran Vdout1_15ck130 AVG v(dout1_15) FROM=1589.9n TO=1590.1n

.meas tran Vdout1_16ck130 AVG v(dout1_16) FROM=1589.9n TO=1590.1n

.meas tran Vdout1_17ck130 AVG v(dout1_17) FROM=1589.9n TO=1590.1n

.meas tran Vdout1_18ck130 AVG v(dout1_18) FROM=1589.9n TO=1590.1n

.meas tran Vdout1_19ck130 AVG v(dout1_19) FROM=1589.9n TO=1590.1n

.meas tran Vdout1_20ck130 AVG v(dout1_20) FROM=1589.9n TO=1590.1n

.meas tran Vdout1_21ck130 AVG v(dout1_21) FROM=1589.9n TO=1590.1n

.meas tran Vdout1_22ck130 AVG v(dout1_22) FROM=1589.9n TO=1590.1n

.meas tran Vdout1_23ck130 AVG v(dout1_23) FROM=1589.9n TO=1590.1n

.meas tran Vdout1_24ck130 AVG v(dout1_24) FROM=1589.9n TO=1590.1n

.meas tran Vdout1_25ck130 AVG v(dout1_25) FROM=1589.9n TO=1590.1n

.meas tran Vdout1_26ck130 AVG v(dout1_26) FROM=1589.9n TO=1590.1n

.meas tran Vdout1_27ck130 AVG v(dout1_27) FROM=1589.9n TO=1590.1n

.meas tran Vdout1_28ck130 AVG v(dout1_28) FROM=1589.9n TO=1590.1n

.meas tran Vdout1_29ck130 AVG v(dout1_29) FROM=1589.9n TO=1590.1n

.meas tran Vdout1_30ck130 AVG v(dout1_30) FROM=1589.9n TO=1590.1n

.meas tran Vdout1_31ck130 AVG v(dout1_31) FROM=1589.9n TO=1590.1n

.meas tran Vdout1_32ck130 AVG v(dout1_32) FROM=1589.9n TO=1590.1n

.meas tran Vdout1_33ck130 AVG v(dout1_33) FROM=1589.9n TO=1590.1n

.meas tran Vdout1_34ck130 AVG v(dout1_34) FROM=1589.9n TO=1590.1n

.meas tran Vdout1_35ck130 AVG v(dout1_35) FROM=1589.9n TO=1590.1n

.meas tran Vdout1_36ck130 AVG v(dout1_36) FROM=1589.9n TO=1590.1n

.meas tran Vdout1_37ck130 AVG v(dout1_37) FROM=1589.9n TO=1590.1n

.meas tran Vdout1_38ck130 AVG v(dout1_38) FROM=1589.9n TO=1590.1n

.meas tran Vdout1_39ck130 AVG v(dout1_39) FROM=1589.9n TO=1590.1n

.meas tran Vdout1_40ck130 AVG v(dout1_40) FROM=1589.9n TO=1590.1n

.meas tran Vdout1_41ck130 AVG v(dout1_41) FROM=1589.9n TO=1590.1n

.meas tran Vdout1_42ck130 AVG v(dout1_42) FROM=1589.9n TO=1590.1n

.meas tran Vdout1_43ck130 AVG v(dout1_43) FROM=1589.9n TO=1590.1n

.meas tran Vdout1_44ck130 AVG v(dout1_44) FROM=1589.9n TO=1590.1n

.meas tran Vdout1_45ck130 AVG v(dout1_45) FROM=1589.9n TO=1590.1n

.meas tran Vdout1_46ck130 AVG v(dout1_46) FROM=1589.9n TO=1590.1n

.meas tran Vdout1_47ck130 AVG v(dout1_47) FROM=1589.9n TO=1590.1n

.meas tran Vdout1_48ck130 AVG v(dout1_48) FROM=1589.9n TO=1590.1n

.meas tran Vdout1_49ck130 AVG v(dout1_49) FROM=1589.9n TO=1590.1n

.meas tran Vdout1_50ck130 AVG v(dout1_50) FROM=1589.9n TO=1590.1n

.meas tran Vdout1_51ck130 AVG v(dout1_51) FROM=1589.9n TO=1590.1n

.meas tran Vdout1_52ck130 AVG v(dout1_52) FROM=1589.9n TO=1590.1n

.meas tran Vdout1_53ck130 AVG v(dout1_53) FROM=1589.9n TO=1590.1n

.meas tran Vdout1_54ck130 AVG v(dout1_54) FROM=1589.9n TO=1590.1n

.meas tran Vdout1_55ck130 AVG v(dout1_55) FROM=1589.9n TO=1590.1n

.meas tran Vdout1_56ck130 AVG v(dout1_56) FROM=1589.9n TO=1590.1n

.meas tran Vdout1_57ck130 AVG v(dout1_57) FROM=1589.9n TO=1590.1n

.meas tran Vdout1_58ck130 AVG v(dout1_58) FROM=1589.9n TO=1590.1n

.meas tran Vdout1_59ck130 AVG v(dout1_59) FROM=1589.9n TO=1590.1n

.meas tran Vdout1_60ck130 AVG v(dout1_60) FROM=1589.9n TO=1590.1n

.meas tran Vdout1_61ck130 AVG v(dout1_61) FROM=1589.9n TO=1590.1n

.meas tran Vdout1_62ck130 AVG v(dout1_62) FROM=1589.9n TO=1590.1n

.meas tran Vdout1_63ck130 AVG v(dout1_63) FROM=1589.9n TO=1590.1n

.meas tran Vdout1_64ck130 AVG v(dout1_64) FROM=1589.9n TO=1590.1n

.meas tran Vdout1_65ck130 AVG v(dout1_65) FROM=1589.9n TO=1590.1n

.meas tran Vdout1_66ck130 AVG v(dout1_66) FROM=1589.9n TO=1590.1n

.meas tran Vdout1_67ck130 AVG v(dout1_67) FROM=1589.9n TO=1590.1n

.meas tran Vdout1_68ck130 AVG v(dout1_68) FROM=1589.9n TO=1590.1n

.meas tran Vdout1_69ck130 AVG v(dout1_69) FROM=1589.9n TO=1590.1n

.meas tran Vdout1_70ck130 AVG v(dout1_70) FROM=1589.9n TO=1590.1n

.meas tran Vdout1_71ck130 AVG v(dout1_71) FROM=1589.9n TO=1590.1n

.meas tran Vdout1_72ck130 AVG v(dout1_72) FROM=1589.9n TO=1590.1n

.meas tran Vdout1_73ck130 AVG v(dout1_73) FROM=1589.9n TO=1590.1n

.meas tran Vdout1_74ck130 AVG v(dout1_74) FROM=1589.9n TO=1590.1n

.meas tran Vdout1_75ck130 AVG v(dout1_75) FROM=1589.9n TO=1590.1n

.meas tran Vdout1_76ck130 AVG v(dout1_76) FROM=1589.9n TO=1590.1n

.meas tran Vdout1_77ck130 AVG v(dout1_77) FROM=1589.9n TO=1590.1n

.meas tran Vdout1_78ck130 AVG v(dout1_78) FROM=1589.9n TO=1590.1n

.meas tran Vdout1_79ck130 AVG v(dout1_79) FROM=1589.9n TO=1590.1n

.meas tran Vdout1_0ck131 AVG v(dout1_0) FROM=1599.9n TO=1600.1n

.meas tran Vdout1_1ck131 AVG v(dout1_1) FROM=1599.9n TO=1600.1n

.meas tran Vdout1_2ck131 AVG v(dout1_2) FROM=1599.9n TO=1600.1n

.meas tran Vdout1_3ck131 AVG v(dout1_3) FROM=1599.9n TO=1600.1n

.meas tran Vdout1_4ck131 AVG v(dout1_4) FROM=1599.9n TO=1600.1n

.meas tran Vdout1_5ck131 AVG v(dout1_5) FROM=1599.9n TO=1600.1n

.meas tran Vdout1_6ck131 AVG v(dout1_6) FROM=1599.9n TO=1600.1n

.meas tran Vdout1_7ck131 AVG v(dout1_7) FROM=1599.9n TO=1600.1n

.meas tran Vdout1_8ck131 AVG v(dout1_8) FROM=1599.9n TO=1600.1n

.meas tran Vdout1_9ck131 AVG v(dout1_9) FROM=1599.9n TO=1600.1n

.meas tran Vdout1_10ck131 AVG v(dout1_10) FROM=1599.9n TO=1600.1n

.meas tran Vdout1_11ck131 AVG v(dout1_11) FROM=1599.9n TO=1600.1n

.meas tran Vdout1_12ck131 AVG v(dout1_12) FROM=1599.9n TO=1600.1n

.meas tran Vdout1_13ck131 AVG v(dout1_13) FROM=1599.9n TO=1600.1n

.meas tran Vdout1_14ck131 AVG v(dout1_14) FROM=1599.9n TO=1600.1n

.meas tran Vdout1_15ck131 AVG v(dout1_15) FROM=1599.9n TO=1600.1n

.meas tran Vdout1_16ck131 AVG v(dout1_16) FROM=1599.9n TO=1600.1n

.meas tran Vdout1_17ck131 AVG v(dout1_17) FROM=1599.9n TO=1600.1n

.meas tran Vdout1_18ck131 AVG v(dout1_18) FROM=1599.9n TO=1600.1n

.meas tran Vdout1_19ck131 AVG v(dout1_19) FROM=1599.9n TO=1600.1n

.meas tran Vdout1_20ck131 AVG v(dout1_20) FROM=1599.9n TO=1600.1n

.meas tran Vdout1_21ck131 AVG v(dout1_21) FROM=1599.9n TO=1600.1n

.meas tran Vdout1_22ck131 AVG v(dout1_22) FROM=1599.9n TO=1600.1n

.meas tran Vdout1_23ck131 AVG v(dout1_23) FROM=1599.9n TO=1600.1n

.meas tran Vdout1_24ck131 AVG v(dout1_24) FROM=1599.9n TO=1600.1n

.meas tran Vdout1_25ck131 AVG v(dout1_25) FROM=1599.9n TO=1600.1n

.meas tran Vdout1_26ck131 AVG v(dout1_26) FROM=1599.9n TO=1600.1n

.meas tran Vdout1_27ck131 AVG v(dout1_27) FROM=1599.9n TO=1600.1n

.meas tran Vdout1_28ck131 AVG v(dout1_28) FROM=1599.9n TO=1600.1n

.meas tran Vdout1_29ck131 AVG v(dout1_29) FROM=1599.9n TO=1600.1n

.meas tran Vdout1_30ck131 AVG v(dout1_30) FROM=1599.9n TO=1600.1n

.meas tran Vdout1_31ck131 AVG v(dout1_31) FROM=1599.9n TO=1600.1n

.meas tran Vdout1_32ck131 AVG v(dout1_32) FROM=1599.9n TO=1600.1n

.meas tran Vdout1_33ck131 AVG v(dout1_33) FROM=1599.9n TO=1600.1n

.meas tran Vdout1_34ck131 AVG v(dout1_34) FROM=1599.9n TO=1600.1n

.meas tran Vdout1_35ck131 AVG v(dout1_35) FROM=1599.9n TO=1600.1n

.meas tran Vdout1_36ck131 AVG v(dout1_36) FROM=1599.9n TO=1600.1n

.meas tran Vdout1_37ck131 AVG v(dout1_37) FROM=1599.9n TO=1600.1n

.meas tran Vdout1_38ck131 AVG v(dout1_38) FROM=1599.9n TO=1600.1n

.meas tran Vdout1_39ck131 AVG v(dout1_39) FROM=1599.9n TO=1600.1n

.meas tran Vdout1_40ck131 AVG v(dout1_40) FROM=1599.9n TO=1600.1n

.meas tran Vdout1_41ck131 AVG v(dout1_41) FROM=1599.9n TO=1600.1n

.meas tran Vdout1_42ck131 AVG v(dout1_42) FROM=1599.9n TO=1600.1n

.meas tran Vdout1_43ck131 AVG v(dout1_43) FROM=1599.9n TO=1600.1n

.meas tran Vdout1_44ck131 AVG v(dout1_44) FROM=1599.9n TO=1600.1n

.meas tran Vdout1_45ck131 AVG v(dout1_45) FROM=1599.9n TO=1600.1n

.meas tran Vdout1_46ck131 AVG v(dout1_46) FROM=1599.9n TO=1600.1n

.meas tran Vdout1_47ck131 AVG v(dout1_47) FROM=1599.9n TO=1600.1n

.meas tran Vdout1_48ck131 AVG v(dout1_48) FROM=1599.9n TO=1600.1n

.meas tran Vdout1_49ck131 AVG v(dout1_49) FROM=1599.9n TO=1600.1n

.meas tran Vdout1_50ck131 AVG v(dout1_50) FROM=1599.9n TO=1600.1n

.meas tran Vdout1_51ck131 AVG v(dout1_51) FROM=1599.9n TO=1600.1n

.meas tran Vdout1_52ck131 AVG v(dout1_52) FROM=1599.9n TO=1600.1n

.meas tran Vdout1_53ck131 AVG v(dout1_53) FROM=1599.9n TO=1600.1n

.meas tran Vdout1_54ck131 AVG v(dout1_54) FROM=1599.9n TO=1600.1n

.meas tran Vdout1_55ck131 AVG v(dout1_55) FROM=1599.9n TO=1600.1n

.meas tran Vdout1_56ck131 AVG v(dout1_56) FROM=1599.9n TO=1600.1n

.meas tran Vdout1_57ck131 AVG v(dout1_57) FROM=1599.9n TO=1600.1n

.meas tran Vdout1_58ck131 AVG v(dout1_58) FROM=1599.9n TO=1600.1n

.meas tran Vdout1_59ck131 AVG v(dout1_59) FROM=1599.9n TO=1600.1n

.meas tran Vdout1_60ck131 AVG v(dout1_60) FROM=1599.9n TO=1600.1n

.meas tran Vdout1_61ck131 AVG v(dout1_61) FROM=1599.9n TO=1600.1n

.meas tran Vdout1_62ck131 AVG v(dout1_62) FROM=1599.9n TO=1600.1n

.meas tran Vdout1_63ck131 AVG v(dout1_63) FROM=1599.9n TO=1600.1n

.meas tran Vdout1_64ck131 AVG v(dout1_64) FROM=1599.9n TO=1600.1n

.meas tran Vdout1_65ck131 AVG v(dout1_65) FROM=1599.9n TO=1600.1n

.meas tran Vdout1_66ck131 AVG v(dout1_66) FROM=1599.9n TO=1600.1n

.meas tran Vdout1_67ck131 AVG v(dout1_67) FROM=1599.9n TO=1600.1n

.meas tran Vdout1_68ck131 AVG v(dout1_68) FROM=1599.9n TO=1600.1n

.meas tran Vdout1_69ck131 AVG v(dout1_69) FROM=1599.9n TO=1600.1n

.meas tran Vdout1_70ck131 AVG v(dout1_70) FROM=1599.9n TO=1600.1n

.meas tran Vdout1_71ck131 AVG v(dout1_71) FROM=1599.9n TO=1600.1n

.meas tran Vdout1_72ck131 AVG v(dout1_72) FROM=1599.9n TO=1600.1n

.meas tran Vdout1_73ck131 AVG v(dout1_73) FROM=1599.9n TO=1600.1n

.meas tran Vdout1_74ck131 AVG v(dout1_74) FROM=1599.9n TO=1600.1n

.meas tran Vdout1_75ck131 AVG v(dout1_75) FROM=1599.9n TO=1600.1n

.meas tran Vdout1_76ck131 AVG v(dout1_76) FROM=1599.9n TO=1600.1n

.meas tran Vdout1_77ck131 AVG v(dout1_77) FROM=1599.9n TO=1600.1n

.meas tran Vdout1_78ck131 AVG v(dout1_78) FROM=1599.9n TO=1600.1n

.meas tran Vdout1_79ck131 AVG v(dout1_79) FROM=1599.9n TO=1600.1n

.meas tran Vdout1_0ck132 AVG v(dout1_0) FROM=1609.9n TO=1610.1n

.meas tran Vdout1_1ck132 AVG v(dout1_1) FROM=1609.9n TO=1610.1n

.meas tran Vdout1_2ck132 AVG v(dout1_2) FROM=1609.9n TO=1610.1n

.meas tran Vdout1_3ck132 AVG v(dout1_3) FROM=1609.9n TO=1610.1n

.meas tran Vdout1_4ck132 AVG v(dout1_4) FROM=1609.9n TO=1610.1n

.meas tran Vdout1_5ck132 AVG v(dout1_5) FROM=1609.9n TO=1610.1n

.meas tran Vdout1_6ck132 AVG v(dout1_6) FROM=1609.9n TO=1610.1n

.meas tran Vdout1_7ck132 AVG v(dout1_7) FROM=1609.9n TO=1610.1n

.meas tran Vdout1_8ck132 AVG v(dout1_8) FROM=1609.9n TO=1610.1n

.meas tran Vdout1_9ck132 AVG v(dout1_9) FROM=1609.9n TO=1610.1n

.meas tran Vdout1_10ck132 AVG v(dout1_10) FROM=1609.9n TO=1610.1n

.meas tran Vdout1_11ck132 AVG v(dout1_11) FROM=1609.9n TO=1610.1n

.meas tran Vdout1_12ck132 AVG v(dout1_12) FROM=1609.9n TO=1610.1n

.meas tran Vdout1_13ck132 AVG v(dout1_13) FROM=1609.9n TO=1610.1n

.meas tran Vdout1_14ck132 AVG v(dout1_14) FROM=1609.9n TO=1610.1n

.meas tran Vdout1_15ck132 AVG v(dout1_15) FROM=1609.9n TO=1610.1n

.meas tran Vdout1_16ck132 AVG v(dout1_16) FROM=1609.9n TO=1610.1n

.meas tran Vdout1_17ck132 AVG v(dout1_17) FROM=1609.9n TO=1610.1n

.meas tran Vdout1_18ck132 AVG v(dout1_18) FROM=1609.9n TO=1610.1n

.meas tran Vdout1_19ck132 AVG v(dout1_19) FROM=1609.9n TO=1610.1n

.meas tran Vdout1_20ck132 AVG v(dout1_20) FROM=1609.9n TO=1610.1n

.meas tran Vdout1_21ck132 AVG v(dout1_21) FROM=1609.9n TO=1610.1n

.meas tran Vdout1_22ck132 AVG v(dout1_22) FROM=1609.9n TO=1610.1n

.meas tran Vdout1_23ck132 AVG v(dout1_23) FROM=1609.9n TO=1610.1n

.meas tran Vdout1_24ck132 AVG v(dout1_24) FROM=1609.9n TO=1610.1n

.meas tran Vdout1_25ck132 AVG v(dout1_25) FROM=1609.9n TO=1610.1n

.meas tran Vdout1_26ck132 AVG v(dout1_26) FROM=1609.9n TO=1610.1n

.meas tran Vdout1_27ck132 AVG v(dout1_27) FROM=1609.9n TO=1610.1n

.meas tran Vdout1_28ck132 AVG v(dout1_28) FROM=1609.9n TO=1610.1n

.meas tran Vdout1_29ck132 AVG v(dout1_29) FROM=1609.9n TO=1610.1n

.meas tran Vdout1_30ck132 AVG v(dout1_30) FROM=1609.9n TO=1610.1n

.meas tran Vdout1_31ck132 AVG v(dout1_31) FROM=1609.9n TO=1610.1n

.meas tran Vdout1_32ck132 AVG v(dout1_32) FROM=1609.9n TO=1610.1n

.meas tran Vdout1_33ck132 AVG v(dout1_33) FROM=1609.9n TO=1610.1n

.meas tran Vdout1_34ck132 AVG v(dout1_34) FROM=1609.9n TO=1610.1n

.meas tran Vdout1_35ck132 AVG v(dout1_35) FROM=1609.9n TO=1610.1n

.meas tran Vdout1_36ck132 AVG v(dout1_36) FROM=1609.9n TO=1610.1n

.meas tran Vdout1_37ck132 AVG v(dout1_37) FROM=1609.9n TO=1610.1n

.meas tran Vdout1_38ck132 AVG v(dout1_38) FROM=1609.9n TO=1610.1n

.meas tran Vdout1_39ck132 AVG v(dout1_39) FROM=1609.9n TO=1610.1n

.meas tran Vdout1_40ck132 AVG v(dout1_40) FROM=1609.9n TO=1610.1n

.meas tran Vdout1_41ck132 AVG v(dout1_41) FROM=1609.9n TO=1610.1n

.meas tran Vdout1_42ck132 AVG v(dout1_42) FROM=1609.9n TO=1610.1n

.meas tran Vdout1_43ck132 AVG v(dout1_43) FROM=1609.9n TO=1610.1n

.meas tran Vdout1_44ck132 AVG v(dout1_44) FROM=1609.9n TO=1610.1n

.meas tran Vdout1_45ck132 AVG v(dout1_45) FROM=1609.9n TO=1610.1n

.meas tran Vdout1_46ck132 AVG v(dout1_46) FROM=1609.9n TO=1610.1n

.meas tran Vdout1_47ck132 AVG v(dout1_47) FROM=1609.9n TO=1610.1n

.meas tran Vdout1_48ck132 AVG v(dout1_48) FROM=1609.9n TO=1610.1n

.meas tran Vdout1_49ck132 AVG v(dout1_49) FROM=1609.9n TO=1610.1n

.meas tran Vdout1_50ck132 AVG v(dout1_50) FROM=1609.9n TO=1610.1n

.meas tran Vdout1_51ck132 AVG v(dout1_51) FROM=1609.9n TO=1610.1n

.meas tran Vdout1_52ck132 AVG v(dout1_52) FROM=1609.9n TO=1610.1n

.meas tran Vdout1_53ck132 AVG v(dout1_53) FROM=1609.9n TO=1610.1n

.meas tran Vdout1_54ck132 AVG v(dout1_54) FROM=1609.9n TO=1610.1n

.meas tran Vdout1_55ck132 AVG v(dout1_55) FROM=1609.9n TO=1610.1n

.meas tran Vdout1_56ck132 AVG v(dout1_56) FROM=1609.9n TO=1610.1n

.meas tran Vdout1_57ck132 AVG v(dout1_57) FROM=1609.9n TO=1610.1n

.meas tran Vdout1_58ck132 AVG v(dout1_58) FROM=1609.9n TO=1610.1n

.meas tran Vdout1_59ck132 AVG v(dout1_59) FROM=1609.9n TO=1610.1n

.meas tran Vdout1_60ck132 AVG v(dout1_60) FROM=1609.9n TO=1610.1n

.meas tran Vdout1_61ck132 AVG v(dout1_61) FROM=1609.9n TO=1610.1n

.meas tran Vdout1_62ck132 AVG v(dout1_62) FROM=1609.9n TO=1610.1n

.meas tran Vdout1_63ck132 AVG v(dout1_63) FROM=1609.9n TO=1610.1n

.meas tran Vdout1_64ck132 AVG v(dout1_64) FROM=1609.9n TO=1610.1n

.meas tran Vdout1_65ck132 AVG v(dout1_65) FROM=1609.9n TO=1610.1n

.meas tran Vdout1_66ck132 AVG v(dout1_66) FROM=1609.9n TO=1610.1n

.meas tran Vdout1_67ck132 AVG v(dout1_67) FROM=1609.9n TO=1610.1n

.meas tran Vdout1_68ck132 AVG v(dout1_68) FROM=1609.9n TO=1610.1n

.meas tran Vdout1_69ck132 AVG v(dout1_69) FROM=1609.9n TO=1610.1n

.meas tran Vdout1_70ck132 AVG v(dout1_70) FROM=1609.9n TO=1610.1n

.meas tran Vdout1_71ck132 AVG v(dout1_71) FROM=1609.9n TO=1610.1n

.meas tran Vdout1_72ck132 AVG v(dout1_72) FROM=1609.9n TO=1610.1n

.meas tran Vdout1_73ck132 AVG v(dout1_73) FROM=1609.9n TO=1610.1n

.meas tran Vdout1_74ck132 AVG v(dout1_74) FROM=1609.9n TO=1610.1n

.meas tran Vdout1_75ck132 AVG v(dout1_75) FROM=1609.9n TO=1610.1n

.meas tran Vdout1_76ck132 AVG v(dout1_76) FROM=1609.9n TO=1610.1n

.meas tran Vdout1_77ck132 AVG v(dout1_77) FROM=1609.9n TO=1610.1n

.meas tran Vdout1_78ck132 AVG v(dout1_78) FROM=1609.9n TO=1610.1n

.meas tran Vdout1_79ck132 AVG v(dout1_79) FROM=1609.9n TO=1610.1n

.meas tran Vdout1_0ck133 AVG v(dout1_0) FROM=1619.9n TO=1620.1n

.meas tran Vdout1_1ck133 AVG v(dout1_1) FROM=1619.9n TO=1620.1n

.meas tran Vdout1_2ck133 AVG v(dout1_2) FROM=1619.9n TO=1620.1n

.meas tran Vdout1_3ck133 AVG v(dout1_3) FROM=1619.9n TO=1620.1n

.meas tran Vdout1_4ck133 AVG v(dout1_4) FROM=1619.9n TO=1620.1n

.meas tran Vdout1_5ck133 AVG v(dout1_5) FROM=1619.9n TO=1620.1n

.meas tran Vdout1_6ck133 AVG v(dout1_6) FROM=1619.9n TO=1620.1n

.meas tran Vdout1_7ck133 AVG v(dout1_7) FROM=1619.9n TO=1620.1n

.meas tran Vdout1_8ck133 AVG v(dout1_8) FROM=1619.9n TO=1620.1n

.meas tran Vdout1_9ck133 AVG v(dout1_9) FROM=1619.9n TO=1620.1n

.meas tran Vdout1_10ck133 AVG v(dout1_10) FROM=1619.9n TO=1620.1n

.meas tran Vdout1_11ck133 AVG v(dout1_11) FROM=1619.9n TO=1620.1n

.meas tran Vdout1_12ck133 AVG v(dout1_12) FROM=1619.9n TO=1620.1n

.meas tran Vdout1_13ck133 AVG v(dout1_13) FROM=1619.9n TO=1620.1n

.meas tran Vdout1_14ck133 AVG v(dout1_14) FROM=1619.9n TO=1620.1n

.meas tran Vdout1_15ck133 AVG v(dout1_15) FROM=1619.9n TO=1620.1n

.meas tran Vdout1_16ck133 AVG v(dout1_16) FROM=1619.9n TO=1620.1n

.meas tran Vdout1_17ck133 AVG v(dout1_17) FROM=1619.9n TO=1620.1n

.meas tran Vdout1_18ck133 AVG v(dout1_18) FROM=1619.9n TO=1620.1n

.meas tran Vdout1_19ck133 AVG v(dout1_19) FROM=1619.9n TO=1620.1n

.meas tran Vdout1_20ck133 AVG v(dout1_20) FROM=1619.9n TO=1620.1n

.meas tran Vdout1_21ck133 AVG v(dout1_21) FROM=1619.9n TO=1620.1n

.meas tran Vdout1_22ck133 AVG v(dout1_22) FROM=1619.9n TO=1620.1n

.meas tran Vdout1_23ck133 AVG v(dout1_23) FROM=1619.9n TO=1620.1n

.meas tran Vdout1_24ck133 AVG v(dout1_24) FROM=1619.9n TO=1620.1n

.meas tran Vdout1_25ck133 AVG v(dout1_25) FROM=1619.9n TO=1620.1n

.meas tran Vdout1_26ck133 AVG v(dout1_26) FROM=1619.9n TO=1620.1n

.meas tran Vdout1_27ck133 AVG v(dout1_27) FROM=1619.9n TO=1620.1n

.meas tran Vdout1_28ck133 AVG v(dout1_28) FROM=1619.9n TO=1620.1n

.meas tran Vdout1_29ck133 AVG v(dout1_29) FROM=1619.9n TO=1620.1n

.meas tran Vdout1_30ck133 AVG v(dout1_30) FROM=1619.9n TO=1620.1n

.meas tran Vdout1_31ck133 AVG v(dout1_31) FROM=1619.9n TO=1620.1n

.meas tran Vdout1_32ck133 AVG v(dout1_32) FROM=1619.9n TO=1620.1n

.meas tran Vdout1_33ck133 AVG v(dout1_33) FROM=1619.9n TO=1620.1n

.meas tran Vdout1_34ck133 AVG v(dout1_34) FROM=1619.9n TO=1620.1n

.meas tran Vdout1_35ck133 AVG v(dout1_35) FROM=1619.9n TO=1620.1n

.meas tran Vdout1_36ck133 AVG v(dout1_36) FROM=1619.9n TO=1620.1n

.meas tran Vdout1_37ck133 AVG v(dout1_37) FROM=1619.9n TO=1620.1n

.meas tran Vdout1_38ck133 AVG v(dout1_38) FROM=1619.9n TO=1620.1n

.meas tran Vdout1_39ck133 AVG v(dout1_39) FROM=1619.9n TO=1620.1n

.meas tran Vdout1_40ck133 AVG v(dout1_40) FROM=1619.9n TO=1620.1n

.meas tran Vdout1_41ck133 AVG v(dout1_41) FROM=1619.9n TO=1620.1n

.meas tran Vdout1_42ck133 AVG v(dout1_42) FROM=1619.9n TO=1620.1n

.meas tran Vdout1_43ck133 AVG v(dout1_43) FROM=1619.9n TO=1620.1n

.meas tran Vdout1_44ck133 AVG v(dout1_44) FROM=1619.9n TO=1620.1n

.meas tran Vdout1_45ck133 AVG v(dout1_45) FROM=1619.9n TO=1620.1n

.meas tran Vdout1_46ck133 AVG v(dout1_46) FROM=1619.9n TO=1620.1n

.meas tran Vdout1_47ck133 AVG v(dout1_47) FROM=1619.9n TO=1620.1n

.meas tran Vdout1_48ck133 AVG v(dout1_48) FROM=1619.9n TO=1620.1n

.meas tran Vdout1_49ck133 AVG v(dout1_49) FROM=1619.9n TO=1620.1n

.meas tran Vdout1_50ck133 AVG v(dout1_50) FROM=1619.9n TO=1620.1n

.meas tran Vdout1_51ck133 AVG v(dout1_51) FROM=1619.9n TO=1620.1n

.meas tran Vdout1_52ck133 AVG v(dout1_52) FROM=1619.9n TO=1620.1n

.meas tran Vdout1_53ck133 AVG v(dout1_53) FROM=1619.9n TO=1620.1n

.meas tran Vdout1_54ck133 AVG v(dout1_54) FROM=1619.9n TO=1620.1n

.meas tran Vdout1_55ck133 AVG v(dout1_55) FROM=1619.9n TO=1620.1n

.meas tran Vdout1_56ck133 AVG v(dout1_56) FROM=1619.9n TO=1620.1n

.meas tran Vdout1_57ck133 AVG v(dout1_57) FROM=1619.9n TO=1620.1n

.meas tran Vdout1_58ck133 AVG v(dout1_58) FROM=1619.9n TO=1620.1n

.meas tran Vdout1_59ck133 AVG v(dout1_59) FROM=1619.9n TO=1620.1n

.meas tran Vdout1_60ck133 AVG v(dout1_60) FROM=1619.9n TO=1620.1n

.meas tran Vdout1_61ck133 AVG v(dout1_61) FROM=1619.9n TO=1620.1n

.meas tran Vdout1_62ck133 AVG v(dout1_62) FROM=1619.9n TO=1620.1n

.meas tran Vdout1_63ck133 AVG v(dout1_63) FROM=1619.9n TO=1620.1n

.meas tran Vdout1_64ck133 AVG v(dout1_64) FROM=1619.9n TO=1620.1n

.meas tran Vdout1_65ck133 AVG v(dout1_65) FROM=1619.9n TO=1620.1n

.meas tran Vdout1_66ck133 AVG v(dout1_66) FROM=1619.9n TO=1620.1n

.meas tran Vdout1_67ck133 AVG v(dout1_67) FROM=1619.9n TO=1620.1n

.meas tran Vdout1_68ck133 AVG v(dout1_68) FROM=1619.9n TO=1620.1n

.meas tran Vdout1_69ck133 AVG v(dout1_69) FROM=1619.9n TO=1620.1n

.meas tran Vdout1_70ck133 AVG v(dout1_70) FROM=1619.9n TO=1620.1n

.meas tran Vdout1_71ck133 AVG v(dout1_71) FROM=1619.9n TO=1620.1n

.meas tran Vdout1_72ck133 AVG v(dout1_72) FROM=1619.9n TO=1620.1n

.meas tran Vdout1_73ck133 AVG v(dout1_73) FROM=1619.9n TO=1620.1n

.meas tran Vdout1_74ck133 AVG v(dout1_74) FROM=1619.9n TO=1620.1n

.meas tran Vdout1_75ck133 AVG v(dout1_75) FROM=1619.9n TO=1620.1n

.meas tran Vdout1_76ck133 AVG v(dout1_76) FROM=1619.9n TO=1620.1n

.meas tran Vdout1_77ck133 AVG v(dout1_77) FROM=1619.9n TO=1620.1n

.meas tran Vdout1_78ck133 AVG v(dout1_78) FROM=1619.9n TO=1620.1n

.meas tran Vdout1_79ck133 AVG v(dout1_79) FROM=1619.9n TO=1620.1n

.meas tran Vdout1_0ck134 AVG v(dout1_0) FROM=1629.9n TO=1630.1n

.meas tran Vdout1_1ck134 AVG v(dout1_1) FROM=1629.9n TO=1630.1n

.meas tran Vdout1_2ck134 AVG v(dout1_2) FROM=1629.9n TO=1630.1n

.meas tran Vdout1_3ck134 AVG v(dout1_3) FROM=1629.9n TO=1630.1n

.meas tran Vdout1_4ck134 AVG v(dout1_4) FROM=1629.9n TO=1630.1n

.meas tran Vdout1_5ck134 AVG v(dout1_5) FROM=1629.9n TO=1630.1n

.meas tran Vdout1_6ck134 AVG v(dout1_6) FROM=1629.9n TO=1630.1n

.meas tran Vdout1_7ck134 AVG v(dout1_7) FROM=1629.9n TO=1630.1n

.meas tran Vdout1_8ck134 AVG v(dout1_8) FROM=1629.9n TO=1630.1n

.meas tran Vdout1_9ck134 AVG v(dout1_9) FROM=1629.9n TO=1630.1n

.meas tran Vdout1_10ck134 AVG v(dout1_10) FROM=1629.9n TO=1630.1n

.meas tran Vdout1_11ck134 AVG v(dout1_11) FROM=1629.9n TO=1630.1n

.meas tran Vdout1_12ck134 AVG v(dout1_12) FROM=1629.9n TO=1630.1n

.meas tran Vdout1_13ck134 AVG v(dout1_13) FROM=1629.9n TO=1630.1n

.meas tran Vdout1_14ck134 AVG v(dout1_14) FROM=1629.9n TO=1630.1n

.meas tran Vdout1_15ck134 AVG v(dout1_15) FROM=1629.9n TO=1630.1n

.meas tran Vdout1_16ck134 AVG v(dout1_16) FROM=1629.9n TO=1630.1n

.meas tran Vdout1_17ck134 AVG v(dout1_17) FROM=1629.9n TO=1630.1n

.meas tran Vdout1_18ck134 AVG v(dout1_18) FROM=1629.9n TO=1630.1n

.meas tran Vdout1_19ck134 AVG v(dout1_19) FROM=1629.9n TO=1630.1n

.meas tran Vdout1_20ck134 AVG v(dout1_20) FROM=1629.9n TO=1630.1n

.meas tran Vdout1_21ck134 AVG v(dout1_21) FROM=1629.9n TO=1630.1n

.meas tran Vdout1_22ck134 AVG v(dout1_22) FROM=1629.9n TO=1630.1n

.meas tran Vdout1_23ck134 AVG v(dout1_23) FROM=1629.9n TO=1630.1n

.meas tran Vdout1_24ck134 AVG v(dout1_24) FROM=1629.9n TO=1630.1n

.meas tran Vdout1_25ck134 AVG v(dout1_25) FROM=1629.9n TO=1630.1n

.meas tran Vdout1_26ck134 AVG v(dout1_26) FROM=1629.9n TO=1630.1n

.meas tran Vdout1_27ck134 AVG v(dout1_27) FROM=1629.9n TO=1630.1n

.meas tran Vdout1_28ck134 AVG v(dout1_28) FROM=1629.9n TO=1630.1n

.meas tran Vdout1_29ck134 AVG v(dout1_29) FROM=1629.9n TO=1630.1n

.meas tran Vdout1_30ck134 AVG v(dout1_30) FROM=1629.9n TO=1630.1n

.meas tran Vdout1_31ck134 AVG v(dout1_31) FROM=1629.9n TO=1630.1n

.meas tran Vdout1_32ck134 AVG v(dout1_32) FROM=1629.9n TO=1630.1n

.meas tran Vdout1_33ck134 AVG v(dout1_33) FROM=1629.9n TO=1630.1n

.meas tran Vdout1_34ck134 AVG v(dout1_34) FROM=1629.9n TO=1630.1n

.meas tran Vdout1_35ck134 AVG v(dout1_35) FROM=1629.9n TO=1630.1n

.meas tran Vdout1_36ck134 AVG v(dout1_36) FROM=1629.9n TO=1630.1n

.meas tran Vdout1_37ck134 AVG v(dout1_37) FROM=1629.9n TO=1630.1n

.meas tran Vdout1_38ck134 AVG v(dout1_38) FROM=1629.9n TO=1630.1n

.meas tran Vdout1_39ck134 AVG v(dout1_39) FROM=1629.9n TO=1630.1n

.meas tran Vdout1_40ck134 AVG v(dout1_40) FROM=1629.9n TO=1630.1n

.meas tran Vdout1_41ck134 AVG v(dout1_41) FROM=1629.9n TO=1630.1n

.meas tran Vdout1_42ck134 AVG v(dout1_42) FROM=1629.9n TO=1630.1n

.meas tran Vdout1_43ck134 AVG v(dout1_43) FROM=1629.9n TO=1630.1n

.meas tran Vdout1_44ck134 AVG v(dout1_44) FROM=1629.9n TO=1630.1n

.meas tran Vdout1_45ck134 AVG v(dout1_45) FROM=1629.9n TO=1630.1n

.meas tran Vdout1_46ck134 AVG v(dout1_46) FROM=1629.9n TO=1630.1n

.meas tran Vdout1_47ck134 AVG v(dout1_47) FROM=1629.9n TO=1630.1n

.meas tran Vdout1_48ck134 AVG v(dout1_48) FROM=1629.9n TO=1630.1n

.meas tran Vdout1_49ck134 AVG v(dout1_49) FROM=1629.9n TO=1630.1n

.meas tran Vdout1_50ck134 AVG v(dout1_50) FROM=1629.9n TO=1630.1n

.meas tran Vdout1_51ck134 AVG v(dout1_51) FROM=1629.9n TO=1630.1n

.meas tran Vdout1_52ck134 AVG v(dout1_52) FROM=1629.9n TO=1630.1n

.meas tran Vdout1_53ck134 AVG v(dout1_53) FROM=1629.9n TO=1630.1n

.meas tran Vdout1_54ck134 AVG v(dout1_54) FROM=1629.9n TO=1630.1n

.meas tran Vdout1_55ck134 AVG v(dout1_55) FROM=1629.9n TO=1630.1n

.meas tran Vdout1_56ck134 AVG v(dout1_56) FROM=1629.9n TO=1630.1n

.meas tran Vdout1_57ck134 AVG v(dout1_57) FROM=1629.9n TO=1630.1n

.meas tran Vdout1_58ck134 AVG v(dout1_58) FROM=1629.9n TO=1630.1n

.meas tran Vdout1_59ck134 AVG v(dout1_59) FROM=1629.9n TO=1630.1n

.meas tran Vdout1_60ck134 AVG v(dout1_60) FROM=1629.9n TO=1630.1n

.meas tran Vdout1_61ck134 AVG v(dout1_61) FROM=1629.9n TO=1630.1n

.meas tran Vdout1_62ck134 AVG v(dout1_62) FROM=1629.9n TO=1630.1n

.meas tran Vdout1_63ck134 AVG v(dout1_63) FROM=1629.9n TO=1630.1n

.meas tran Vdout1_64ck134 AVG v(dout1_64) FROM=1629.9n TO=1630.1n

.meas tran Vdout1_65ck134 AVG v(dout1_65) FROM=1629.9n TO=1630.1n

.meas tran Vdout1_66ck134 AVG v(dout1_66) FROM=1629.9n TO=1630.1n

.meas tran Vdout1_67ck134 AVG v(dout1_67) FROM=1629.9n TO=1630.1n

.meas tran Vdout1_68ck134 AVG v(dout1_68) FROM=1629.9n TO=1630.1n

.meas tran Vdout1_69ck134 AVG v(dout1_69) FROM=1629.9n TO=1630.1n

.meas tran Vdout1_70ck134 AVG v(dout1_70) FROM=1629.9n TO=1630.1n

.meas tran Vdout1_71ck134 AVG v(dout1_71) FROM=1629.9n TO=1630.1n

.meas tran Vdout1_72ck134 AVG v(dout1_72) FROM=1629.9n TO=1630.1n

.meas tran Vdout1_73ck134 AVG v(dout1_73) FROM=1629.9n TO=1630.1n

.meas tran Vdout1_74ck134 AVG v(dout1_74) FROM=1629.9n TO=1630.1n

.meas tran Vdout1_75ck134 AVG v(dout1_75) FROM=1629.9n TO=1630.1n

.meas tran Vdout1_76ck134 AVG v(dout1_76) FROM=1629.9n TO=1630.1n

.meas tran Vdout1_77ck134 AVG v(dout1_77) FROM=1629.9n TO=1630.1n

.meas tran Vdout1_78ck134 AVG v(dout1_78) FROM=1629.9n TO=1630.1n

.meas tran Vdout1_79ck134 AVG v(dout1_79) FROM=1629.9n TO=1630.1n

.meas tran Vdout1_0ck135 AVG v(dout1_0) FROM=1639.9n TO=1640.1n

.meas tran Vdout1_1ck135 AVG v(dout1_1) FROM=1639.9n TO=1640.1n

.meas tran Vdout1_2ck135 AVG v(dout1_2) FROM=1639.9n TO=1640.1n

.meas tran Vdout1_3ck135 AVG v(dout1_3) FROM=1639.9n TO=1640.1n

.meas tran Vdout1_4ck135 AVG v(dout1_4) FROM=1639.9n TO=1640.1n

.meas tran Vdout1_5ck135 AVG v(dout1_5) FROM=1639.9n TO=1640.1n

.meas tran Vdout1_6ck135 AVG v(dout1_6) FROM=1639.9n TO=1640.1n

.meas tran Vdout1_7ck135 AVG v(dout1_7) FROM=1639.9n TO=1640.1n

.meas tran Vdout1_8ck135 AVG v(dout1_8) FROM=1639.9n TO=1640.1n

.meas tran Vdout1_9ck135 AVG v(dout1_9) FROM=1639.9n TO=1640.1n

.meas tran Vdout1_10ck135 AVG v(dout1_10) FROM=1639.9n TO=1640.1n

.meas tran Vdout1_11ck135 AVG v(dout1_11) FROM=1639.9n TO=1640.1n

.meas tran Vdout1_12ck135 AVG v(dout1_12) FROM=1639.9n TO=1640.1n

.meas tran Vdout1_13ck135 AVG v(dout1_13) FROM=1639.9n TO=1640.1n

.meas tran Vdout1_14ck135 AVG v(dout1_14) FROM=1639.9n TO=1640.1n

.meas tran Vdout1_15ck135 AVG v(dout1_15) FROM=1639.9n TO=1640.1n

.meas tran Vdout1_16ck135 AVG v(dout1_16) FROM=1639.9n TO=1640.1n

.meas tran Vdout1_17ck135 AVG v(dout1_17) FROM=1639.9n TO=1640.1n

.meas tran Vdout1_18ck135 AVG v(dout1_18) FROM=1639.9n TO=1640.1n

.meas tran Vdout1_19ck135 AVG v(dout1_19) FROM=1639.9n TO=1640.1n

.meas tran Vdout1_20ck135 AVG v(dout1_20) FROM=1639.9n TO=1640.1n

.meas tran Vdout1_21ck135 AVG v(dout1_21) FROM=1639.9n TO=1640.1n

.meas tran Vdout1_22ck135 AVG v(dout1_22) FROM=1639.9n TO=1640.1n

.meas tran Vdout1_23ck135 AVG v(dout1_23) FROM=1639.9n TO=1640.1n

.meas tran Vdout1_24ck135 AVG v(dout1_24) FROM=1639.9n TO=1640.1n

.meas tran Vdout1_25ck135 AVG v(dout1_25) FROM=1639.9n TO=1640.1n

.meas tran Vdout1_26ck135 AVG v(dout1_26) FROM=1639.9n TO=1640.1n

.meas tran Vdout1_27ck135 AVG v(dout1_27) FROM=1639.9n TO=1640.1n

.meas tran Vdout1_28ck135 AVG v(dout1_28) FROM=1639.9n TO=1640.1n

.meas tran Vdout1_29ck135 AVG v(dout1_29) FROM=1639.9n TO=1640.1n

.meas tran Vdout1_30ck135 AVG v(dout1_30) FROM=1639.9n TO=1640.1n

.meas tran Vdout1_31ck135 AVG v(dout1_31) FROM=1639.9n TO=1640.1n

.meas tran Vdout1_32ck135 AVG v(dout1_32) FROM=1639.9n TO=1640.1n

.meas tran Vdout1_33ck135 AVG v(dout1_33) FROM=1639.9n TO=1640.1n

.meas tran Vdout1_34ck135 AVG v(dout1_34) FROM=1639.9n TO=1640.1n

.meas tran Vdout1_35ck135 AVG v(dout1_35) FROM=1639.9n TO=1640.1n

.meas tran Vdout1_36ck135 AVG v(dout1_36) FROM=1639.9n TO=1640.1n

.meas tran Vdout1_37ck135 AVG v(dout1_37) FROM=1639.9n TO=1640.1n

.meas tran Vdout1_38ck135 AVG v(dout1_38) FROM=1639.9n TO=1640.1n

.meas tran Vdout1_39ck135 AVG v(dout1_39) FROM=1639.9n TO=1640.1n

.meas tran Vdout1_40ck135 AVG v(dout1_40) FROM=1639.9n TO=1640.1n

.meas tran Vdout1_41ck135 AVG v(dout1_41) FROM=1639.9n TO=1640.1n

.meas tran Vdout1_42ck135 AVG v(dout1_42) FROM=1639.9n TO=1640.1n

.meas tran Vdout1_43ck135 AVG v(dout1_43) FROM=1639.9n TO=1640.1n

.meas tran Vdout1_44ck135 AVG v(dout1_44) FROM=1639.9n TO=1640.1n

.meas tran Vdout1_45ck135 AVG v(dout1_45) FROM=1639.9n TO=1640.1n

.meas tran Vdout1_46ck135 AVG v(dout1_46) FROM=1639.9n TO=1640.1n

.meas tran Vdout1_47ck135 AVG v(dout1_47) FROM=1639.9n TO=1640.1n

.meas tran Vdout1_48ck135 AVG v(dout1_48) FROM=1639.9n TO=1640.1n

.meas tran Vdout1_49ck135 AVG v(dout1_49) FROM=1639.9n TO=1640.1n

.meas tran Vdout1_50ck135 AVG v(dout1_50) FROM=1639.9n TO=1640.1n

.meas tran Vdout1_51ck135 AVG v(dout1_51) FROM=1639.9n TO=1640.1n

.meas tran Vdout1_52ck135 AVG v(dout1_52) FROM=1639.9n TO=1640.1n

.meas tran Vdout1_53ck135 AVG v(dout1_53) FROM=1639.9n TO=1640.1n

.meas tran Vdout1_54ck135 AVG v(dout1_54) FROM=1639.9n TO=1640.1n

.meas tran Vdout1_55ck135 AVG v(dout1_55) FROM=1639.9n TO=1640.1n

.meas tran Vdout1_56ck135 AVG v(dout1_56) FROM=1639.9n TO=1640.1n

.meas tran Vdout1_57ck135 AVG v(dout1_57) FROM=1639.9n TO=1640.1n

.meas tran Vdout1_58ck135 AVG v(dout1_58) FROM=1639.9n TO=1640.1n

.meas tran Vdout1_59ck135 AVG v(dout1_59) FROM=1639.9n TO=1640.1n

.meas tran Vdout1_60ck135 AVG v(dout1_60) FROM=1639.9n TO=1640.1n

.meas tran Vdout1_61ck135 AVG v(dout1_61) FROM=1639.9n TO=1640.1n

.meas tran Vdout1_62ck135 AVG v(dout1_62) FROM=1639.9n TO=1640.1n

.meas tran Vdout1_63ck135 AVG v(dout1_63) FROM=1639.9n TO=1640.1n

.meas tran Vdout1_64ck135 AVG v(dout1_64) FROM=1639.9n TO=1640.1n

.meas tran Vdout1_65ck135 AVG v(dout1_65) FROM=1639.9n TO=1640.1n

.meas tran Vdout1_66ck135 AVG v(dout1_66) FROM=1639.9n TO=1640.1n

.meas tran Vdout1_67ck135 AVG v(dout1_67) FROM=1639.9n TO=1640.1n

.meas tran Vdout1_68ck135 AVG v(dout1_68) FROM=1639.9n TO=1640.1n

.meas tran Vdout1_69ck135 AVG v(dout1_69) FROM=1639.9n TO=1640.1n

.meas tran Vdout1_70ck135 AVG v(dout1_70) FROM=1639.9n TO=1640.1n

.meas tran Vdout1_71ck135 AVG v(dout1_71) FROM=1639.9n TO=1640.1n

.meas tran Vdout1_72ck135 AVG v(dout1_72) FROM=1639.9n TO=1640.1n

.meas tran Vdout1_73ck135 AVG v(dout1_73) FROM=1639.9n TO=1640.1n

.meas tran Vdout1_74ck135 AVG v(dout1_74) FROM=1639.9n TO=1640.1n

.meas tran Vdout1_75ck135 AVG v(dout1_75) FROM=1639.9n TO=1640.1n

.meas tran Vdout1_76ck135 AVG v(dout1_76) FROM=1639.9n TO=1640.1n

.meas tran Vdout1_77ck135 AVG v(dout1_77) FROM=1639.9n TO=1640.1n

.meas tran Vdout1_78ck135 AVG v(dout1_78) FROM=1639.9n TO=1640.1n

.meas tran Vdout1_79ck135 AVG v(dout1_79) FROM=1639.9n TO=1640.1n

.meas tran Vdout1_0ck136 AVG v(dout1_0) FROM=1649.9n TO=1650.1n

.meas tran Vdout1_1ck136 AVG v(dout1_1) FROM=1649.9n TO=1650.1n

.meas tran Vdout1_2ck136 AVG v(dout1_2) FROM=1649.9n TO=1650.1n

.meas tran Vdout1_3ck136 AVG v(dout1_3) FROM=1649.9n TO=1650.1n

.meas tran Vdout1_4ck136 AVG v(dout1_4) FROM=1649.9n TO=1650.1n

.meas tran Vdout1_5ck136 AVG v(dout1_5) FROM=1649.9n TO=1650.1n

.meas tran Vdout1_6ck136 AVG v(dout1_6) FROM=1649.9n TO=1650.1n

.meas tran Vdout1_7ck136 AVG v(dout1_7) FROM=1649.9n TO=1650.1n

.meas tran Vdout1_8ck136 AVG v(dout1_8) FROM=1649.9n TO=1650.1n

.meas tran Vdout1_9ck136 AVG v(dout1_9) FROM=1649.9n TO=1650.1n

.meas tran Vdout1_10ck136 AVG v(dout1_10) FROM=1649.9n TO=1650.1n

.meas tran Vdout1_11ck136 AVG v(dout1_11) FROM=1649.9n TO=1650.1n

.meas tran Vdout1_12ck136 AVG v(dout1_12) FROM=1649.9n TO=1650.1n

.meas tran Vdout1_13ck136 AVG v(dout1_13) FROM=1649.9n TO=1650.1n

.meas tran Vdout1_14ck136 AVG v(dout1_14) FROM=1649.9n TO=1650.1n

.meas tran Vdout1_15ck136 AVG v(dout1_15) FROM=1649.9n TO=1650.1n

.meas tran Vdout1_16ck136 AVG v(dout1_16) FROM=1649.9n TO=1650.1n

.meas tran Vdout1_17ck136 AVG v(dout1_17) FROM=1649.9n TO=1650.1n

.meas tran Vdout1_18ck136 AVG v(dout1_18) FROM=1649.9n TO=1650.1n

.meas tran Vdout1_19ck136 AVG v(dout1_19) FROM=1649.9n TO=1650.1n

.meas tran Vdout1_20ck136 AVG v(dout1_20) FROM=1649.9n TO=1650.1n

.meas tran Vdout1_21ck136 AVG v(dout1_21) FROM=1649.9n TO=1650.1n

.meas tran Vdout1_22ck136 AVG v(dout1_22) FROM=1649.9n TO=1650.1n

.meas tran Vdout1_23ck136 AVG v(dout1_23) FROM=1649.9n TO=1650.1n

.meas tran Vdout1_24ck136 AVG v(dout1_24) FROM=1649.9n TO=1650.1n

.meas tran Vdout1_25ck136 AVG v(dout1_25) FROM=1649.9n TO=1650.1n

.meas tran Vdout1_26ck136 AVG v(dout1_26) FROM=1649.9n TO=1650.1n

.meas tran Vdout1_27ck136 AVG v(dout1_27) FROM=1649.9n TO=1650.1n

.meas tran Vdout1_28ck136 AVG v(dout1_28) FROM=1649.9n TO=1650.1n

.meas tran Vdout1_29ck136 AVG v(dout1_29) FROM=1649.9n TO=1650.1n

.meas tran Vdout1_30ck136 AVG v(dout1_30) FROM=1649.9n TO=1650.1n

.meas tran Vdout1_31ck136 AVG v(dout1_31) FROM=1649.9n TO=1650.1n

.meas tran Vdout1_32ck136 AVG v(dout1_32) FROM=1649.9n TO=1650.1n

.meas tran Vdout1_33ck136 AVG v(dout1_33) FROM=1649.9n TO=1650.1n

.meas tran Vdout1_34ck136 AVG v(dout1_34) FROM=1649.9n TO=1650.1n

.meas tran Vdout1_35ck136 AVG v(dout1_35) FROM=1649.9n TO=1650.1n

.meas tran Vdout1_36ck136 AVG v(dout1_36) FROM=1649.9n TO=1650.1n

.meas tran Vdout1_37ck136 AVG v(dout1_37) FROM=1649.9n TO=1650.1n

.meas tran Vdout1_38ck136 AVG v(dout1_38) FROM=1649.9n TO=1650.1n

.meas tran Vdout1_39ck136 AVG v(dout1_39) FROM=1649.9n TO=1650.1n

.meas tran Vdout1_40ck136 AVG v(dout1_40) FROM=1649.9n TO=1650.1n

.meas tran Vdout1_41ck136 AVG v(dout1_41) FROM=1649.9n TO=1650.1n

.meas tran Vdout1_42ck136 AVG v(dout1_42) FROM=1649.9n TO=1650.1n

.meas tran Vdout1_43ck136 AVG v(dout1_43) FROM=1649.9n TO=1650.1n

.meas tran Vdout1_44ck136 AVG v(dout1_44) FROM=1649.9n TO=1650.1n

.meas tran Vdout1_45ck136 AVG v(dout1_45) FROM=1649.9n TO=1650.1n

.meas tran Vdout1_46ck136 AVG v(dout1_46) FROM=1649.9n TO=1650.1n

.meas tran Vdout1_47ck136 AVG v(dout1_47) FROM=1649.9n TO=1650.1n

.meas tran Vdout1_48ck136 AVG v(dout1_48) FROM=1649.9n TO=1650.1n

.meas tran Vdout1_49ck136 AVG v(dout1_49) FROM=1649.9n TO=1650.1n

.meas tran Vdout1_50ck136 AVG v(dout1_50) FROM=1649.9n TO=1650.1n

.meas tran Vdout1_51ck136 AVG v(dout1_51) FROM=1649.9n TO=1650.1n

.meas tran Vdout1_52ck136 AVG v(dout1_52) FROM=1649.9n TO=1650.1n

.meas tran Vdout1_53ck136 AVG v(dout1_53) FROM=1649.9n TO=1650.1n

.meas tran Vdout1_54ck136 AVG v(dout1_54) FROM=1649.9n TO=1650.1n

.meas tran Vdout1_55ck136 AVG v(dout1_55) FROM=1649.9n TO=1650.1n

.meas tran Vdout1_56ck136 AVG v(dout1_56) FROM=1649.9n TO=1650.1n

.meas tran Vdout1_57ck136 AVG v(dout1_57) FROM=1649.9n TO=1650.1n

.meas tran Vdout1_58ck136 AVG v(dout1_58) FROM=1649.9n TO=1650.1n

.meas tran Vdout1_59ck136 AVG v(dout1_59) FROM=1649.9n TO=1650.1n

.meas tran Vdout1_60ck136 AVG v(dout1_60) FROM=1649.9n TO=1650.1n

.meas tran Vdout1_61ck136 AVG v(dout1_61) FROM=1649.9n TO=1650.1n

.meas tran Vdout1_62ck136 AVG v(dout1_62) FROM=1649.9n TO=1650.1n

.meas tran Vdout1_63ck136 AVG v(dout1_63) FROM=1649.9n TO=1650.1n

.meas tran Vdout1_64ck136 AVG v(dout1_64) FROM=1649.9n TO=1650.1n

.meas tran Vdout1_65ck136 AVG v(dout1_65) FROM=1649.9n TO=1650.1n

.meas tran Vdout1_66ck136 AVG v(dout1_66) FROM=1649.9n TO=1650.1n

.meas tran Vdout1_67ck136 AVG v(dout1_67) FROM=1649.9n TO=1650.1n

.meas tran Vdout1_68ck136 AVG v(dout1_68) FROM=1649.9n TO=1650.1n

.meas tran Vdout1_69ck136 AVG v(dout1_69) FROM=1649.9n TO=1650.1n

.meas tran Vdout1_70ck136 AVG v(dout1_70) FROM=1649.9n TO=1650.1n

.meas tran Vdout1_71ck136 AVG v(dout1_71) FROM=1649.9n TO=1650.1n

.meas tran Vdout1_72ck136 AVG v(dout1_72) FROM=1649.9n TO=1650.1n

.meas tran Vdout1_73ck136 AVG v(dout1_73) FROM=1649.9n TO=1650.1n

.meas tran Vdout1_74ck136 AVG v(dout1_74) FROM=1649.9n TO=1650.1n

.meas tran Vdout1_75ck136 AVG v(dout1_75) FROM=1649.9n TO=1650.1n

.meas tran Vdout1_76ck136 AVG v(dout1_76) FROM=1649.9n TO=1650.1n

.meas tran Vdout1_77ck136 AVG v(dout1_77) FROM=1649.9n TO=1650.1n

.meas tran Vdout1_78ck136 AVG v(dout1_78) FROM=1649.9n TO=1650.1n

.meas tran Vdout1_79ck136 AVG v(dout1_79) FROM=1649.9n TO=1650.1n

.meas tran Vdout1_0ck137 AVG v(dout1_0) FROM=1669.9n TO=1670.1n

.meas tran Vdout1_1ck137 AVG v(dout1_1) FROM=1669.9n TO=1670.1n

.meas tran Vdout1_2ck137 AVG v(dout1_2) FROM=1669.9n TO=1670.1n

.meas tran Vdout1_3ck137 AVG v(dout1_3) FROM=1669.9n TO=1670.1n

.meas tran Vdout1_4ck137 AVG v(dout1_4) FROM=1669.9n TO=1670.1n

.meas tran Vdout1_5ck137 AVG v(dout1_5) FROM=1669.9n TO=1670.1n

.meas tran Vdout1_6ck137 AVG v(dout1_6) FROM=1669.9n TO=1670.1n

.meas tran Vdout1_7ck137 AVG v(dout1_7) FROM=1669.9n TO=1670.1n

.meas tran Vdout1_8ck137 AVG v(dout1_8) FROM=1669.9n TO=1670.1n

.meas tran Vdout1_9ck137 AVG v(dout1_9) FROM=1669.9n TO=1670.1n

.meas tran Vdout1_10ck137 AVG v(dout1_10) FROM=1669.9n TO=1670.1n

.meas tran Vdout1_11ck137 AVG v(dout1_11) FROM=1669.9n TO=1670.1n

.meas tran Vdout1_12ck137 AVG v(dout1_12) FROM=1669.9n TO=1670.1n

.meas tran Vdout1_13ck137 AVG v(dout1_13) FROM=1669.9n TO=1670.1n

.meas tran Vdout1_14ck137 AVG v(dout1_14) FROM=1669.9n TO=1670.1n

.meas tran Vdout1_15ck137 AVG v(dout1_15) FROM=1669.9n TO=1670.1n

.meas tran Vdout1_16ck137 AVG v(dout1_16) FROM=1669.9n TO=1670.1n

.meas tran Vdout1_17ck137 AVG v(dout1_17) FROM=1669.9n TO=1670.1n

.meas tran Vdout1_18ck137 AVG v(dout1_18) FROM=1669.9n TO=1670.1n

.meas tran Vdout1_19ck137 AVG v(dout1_19) FROM=1669.9n TO=1670.1n

.meas tran Vdout1_20ck137 AVG v(dout1_20) FROM=1669.9n TO=1670.1n

.meas tran Vdout1_21ck137 AVG v(dout1_21) FROM=1669.9n TO=1670.1n

.meas tran Vdout1_22ck137 AVG v(dout1_22) FROM=1669.9n TO=1670.1n

.meas tran Vdout1_23ck137 AVG v(dout1_23) FROM=1669.9n TO=1670.1n

.meas tran Vdout1_24ck137 AVG v(dout1_24) FROM=1669.9n TO=1670.1n

.meas tran Vdout1_25ck137 AVG v(dout1_25) FROM=1669.9n TO=1670.1n

.meas tran Vdout1_26ck137 AVG v(dout1_26) FROM=1669.9n TO=1670.1n

.meas tran Vdout1_27ck137 AVG v(dout1_27) FROM=1669.9n TO=1670.1n

.meas tran Vdout1_28ck137 AVG v(dout1_28) FROM=1669.9n TO=1670.1n

.meas tran Vdout1_29ck137 AVG v(dout1_29) FROM=1669.9n TO=1670.1n

.meas tran Vdout1_30ck137 AVG v(dout1_30) FROM=1669.9n TO=1670.1n

.meas tran Vdout1_31ck137 AVG v(dout1_31) FROM=1669.9n TO=1670.1n

.meas tran Vdout1_32ck137 AVG v(dout1_32) FROM=1669.9n TO=1670.1n

.meas tran Vdout1_33ck137 AVG v(dout1_33) FROM=1669.9n TO=1670.1n

.meas tran Vdout1_34ck137 AVG v(dout1_34) FROM=1669.9n TO=1670.1n

.meas tran Vdout1_35ck137 AVG v(dout1_35) FROM=1669.9n TO=1670.1n

.meas tran Vdout1_36ck137 AVG v(dout1_36) FROM=1669.9n TO=1670.1n

.meas tran Vdout1_37ck137 AVG v(dout1_37) FROM=1669.9n TO=1670.1n

.meas tran Vdout1_38ck137 AVG v(dout1_38) FROM=1669.9n TO=1670.1n

.meas tran Vdout1_39ck137 AVG v(dout1_39) FROM=1669.9n TO=1670.1n

.meas tran Vdout1_40ck137 AVG v(dout1_40) FROM=1669.9n TO=1670.1n

.meas tran Vdout1_41ck137 AVG v(dout1_41) FROM=1669.9n TO=1670.1n

.meas tran Vdout1_42ck137 AVG v(dout1_42) FROM=1669.9n TO=1670.1n

.meas tran Vdout1_43ck137 AVG v(dout1_43) FROM=1669.9n TO=1670.1n

.meas tran Vdout1_44ck137 AVG v(dout1_44) FROM=1669.9n TO=1670.1n

.meas tran Vdout1_45ck137 AVG v(dout1_45) FROM=1669.9n TO=1670.1n

.meas tran Vdout1_46ck137 AVG v(dout1_46) FROM=1669.9n TO=1670.1n

.meas tran Vdout1_47ck137 AVG v(dout1_47) FROM=1669.9n TO=1670.1n

.meas tran Vdout1_48ck137 AVG v(dout1_48) FROM=1669.9n TO=1670.1n

.meas tran Vdout1_49ck137 AVG v(dout1_49) FROM=1669.9n TO=1670.1n

.meas tran Vdout1_50ck137 AVG v(dout1_50) FROM=1669.9n TO=1670.1n

.meas tran Vdout1_51ck137 AVG v(dout1_51) FROM=1669.9n TO=1670.1n

.meas tran Vdout1_52ck137 AVG v(dout1_52) FROM=1669.9n TO=1670.1n

.meas tran Vdout1_53ck137 AVG v(dout1_53) FROM=1669.9n TO=1670.1n

.meas tran Vdout1_54ck137 AVG v(dout1_54) FROM=1669.9n TO=1670.1n

.meas tran Vdout1_55ck137 AVG v(dout1_55) FROM=1669.9n TO=1670.1n

.meas tran Vdout1_56ck137 AVG v(dout1_56) FROM=1669.9n TO=1670.1n

.meas tran Vdout1_57ck137 AVG v(dout1_57) FROM=1669.9n TO=1670.1n

.meas tran Vdout1_58ck137 AVG v(dout1_58) FROM=1669.9n TO=1670.1n

.meas tran Vdout1_59ck137 AVG v(dout1_59) FROM=1669.9n TO=1670.1n

.meas tran Vdout1_60ck137 AVG v(dout1_60) FROM=1669.9n TO=1670.1n

.meas tran Vdout1_61ck137 AVG v(dout1_61) FROM=1669.9n TO=1670.1n

.meas tran Vdout1_62ck137 AVG v(dout1_62) FROM=1669.9n TO=1670.1n

.meas tran Vdout1_63ck137 AVG v(dout1_63) FROM=1669.9n TO=1670.1n

.meas tran Vdout1_64ck137 AVG v(dout1_64) FROM=1669.9n TO=1670.1n

.meas tran Vdout1_65ck137 AVG v(dout1_65) FROM=1669.9n TO=1670.1n

.meas tran Vdout1_66ck137 AVG v(dout1_66) FROM=1669.9n TO=1670.1n

.meas tran Vdout1_67ck137 AVG v(dout1_67) FROM=1669.9n TO=1670.1n

.meas tran Vdout1_68ck137 AVG v(dout1_68) FROM=1669.9n TO=1670.1n

.meas tran Vdout1_69ck137 AVG v(dout1_69) FROM=1669.9n TO=1670.1n

.meas tran Vdout1_70ck137 AVG v(dout1_70) FROM=1669.9n TO=1670.1n

.meas tran Vdout1_71ck137 AVG v(dout1_71) FROM=1669.9n TO=1670.1n

.meas tran Vdout1_72ck137 AVG v(dout1_72) FROM=1669.9n TO=1670.1n

.meas tran Vdout1_73ck137 AVG v(dout1_73) FROM=1669.9n TO=1670.1n

.meas tran Vdout1_74ck137 AVG v(dout1_74) FROM=1669.9n TO=1670.1n

.meas tran Vdout1_75ck137 AVG v(dout1_75) FROM=1669.9n TO=1670.1n

.meas tran Vdout1_76ck137 AVG v(dout1_76) FROM=1669.9n TO=1670.1n

.meas tran Vdout1_77ck137 AVG v(dout1_77) FROM=1669.9n TO=1670.1n

.meas tran Vdout1_78ck137 AVG v(dout1_78) FROM=1669.9n TO=1670.1n

.meas tran Vdout1_79ck137 AVG v(dout1_79) FROM=1669.9n TO=1670.1n

.meas tran Vdout0_0ck138 AVG v(dout0_0) FROM=1679.9n TO=1680.1n

.meas tran Vdout0_1ck138 AVG v(dout0_1) FROM=1679.9n TO=1680.1n

.meas tran Vdout0_2ck138 AVG v(dout0_2) FROM=1679.9n TO=1680.1n

.meas tran Vdout0_3ck138 AVG v(dout0_3) FROM=1679.9n TO=1680.1n

.meas tran Vdout0_4ck138 AVG v(dout0_4) FROM=1679.9n TO=1680.1n

.meas tran Vdout0_5ck138 AVG v(dout0_5) FROM=1679.9n TO=1680.1n

.meas tran Vdout0_6ck138 AVG v(dout0_6) FROM=1679.9n TO=1680.1n

.meas tran Vdout0_7ck138 AVG v(dout0_7) FROM=1679.9n TO=1680.1n

.meas tran Vdout0_8ck138 AVG v(dout0_8) FROM=1679.9n TO=1680.1n

.meas tran Vdout0_9ck138 AVG v(dout0_9) FROM=1679.9n TO=1680.1n

.meas tran Vdout0_10ck138 AVG v(dout0_10) FROM=1679.9n TO=1680.1n

.meas tran Vdout0_11ck138 AVG v(dout0_11) FROM=1679.9n TO=1680.1n

.meas tran Vdout0_12ck138 AVG v(dout0_12) FROM=1679.9n TO=1680.1n

.meas tran Vdout0_13ck138 AVG v(dout0_13) FROM=1679.9n TO=1680.1n

.meas tran Vdout0_14ck138 AVG v(dout0_14) FROM=1679.9n TO=1680.1n

.meas tran Vdout0_15ck138 AVG v(dout0_15) FROM=1679.9n TO=1680.1n

.meas tran Vdout0_16ck138 AVG v(dout0_16) FROM=1679.9n TO=1680.1n

.meas tran Vdout0_17ck138 AVG v(dout0_17) FROM=1679.9n TO=1680.1n

.meas tran Vdout0_18ck138 AVG v(dout0_18) FROM=1679.9n TO=1680.1n

.meas tran Vdout0_19ck138 AVG v(dout0_19) FROM=1679.9n TO=1680.1n

.meas tran Vdout0_20ck138 AVG v(dout0_20) FROM=1679.9n TO=1680.1n

.meas tran Vdout0_21ck138 AVG v(dout0_21) FROM=1679.9n TO=1680.1n

.meas tran Vdout0_22ck138 AVG v(dout0_22) FROM=1679.9n TO=1680.1n

.meas tran Vdout0_23ck138 AVG v(dout0_23) FROM=1679.9n TO=1680.1n

.meas tran Vdout0_24ck138 AVG v(dout0_24) FROM=1679.9n TO=1680.1n

.meas tran Vdout0_25ck138 AVG v(dout0_25) FROM=1679.9n TO=1680.1n

.meas tran Vdout0_26ck138 AVG v(dout0_26) FROM=1679.9n TO=1680.1n

.meas tran Vdout0_27ck138 AVG v(dout0_27) FROM=1679.9n TO=1680.1n

.meas tran Vdout0_28ck138 AVG v(dout0_28) FROM=1679.9n TO=1680.1n

.meas tran Vdout0_29ck138 AVG v(dout0_29) FROM=1679.9n TO=1680.1n

.meas tran Vdout0_30ck138 AVG v(dout0_30) FROM=1679.9n TO=1680.1n

.meas tran Vdout0_31ck138 AVG v(dout0_31) FROM=1679.9n TO=1680.1n

.meas tran Vdout0_32ck138 AVG v(dout0_32) FROM=1679.9n TO=1680.1n

.meas tran Vdout0_33ck138 AVG v(dout0_33) FROM=1679.9n TO=1680.1n

.meas tran Vdout0_34ck138 AVG v(dout0_34) FROM=1679.9n TO=1680.1n

.meas tran Vdout0_35ck138 AVG v(dout0_35) FROM=1679.9n TO=1680.1n

.meas tran Vdout0_36ck138 AVG v(dout0_36) FROM=1679.9n TO=1680.1n

.meas tran Vdout0_37ck138 AVG v(dout0_37) FROM=1679.9n TO=1680.1n

.meas tran Vdout0_38ck138 AVG v(dout0_38) FROM=1679.9n TO=1680.1n

.meas tran Vdout0_39ck138 AVG v(dout0_39) FROM=1679.9n TO=1680.1n

.meas tran Vdout0_40ck138 AVG v(dout0_40) FROM=1679.9n TO=1680.1n

.meas tran Vdout0_41ck138 AVG v(dout0_41) FROM=1679.9n TO=1680.1n

.meas tran Vdout0_42ck138 AVG v(dout0_42) FROM=1679.9n TO=1680.1n

.meas tran Vdout0_43ck138 AVG v(dout0_43) FROM=1679.9n TO=1680.1n

.meas tran Vdout0_44ck138 AVG v(dout0_44) FROM=1679.9n TO=1680.1n

.meas tran Vdout0_45ck138 AVG v(dout0_45) FROM=1679.9n TO=1680.1n

.meas tran Vdout0_46ck138 AVG v(dout0_46) FROM=1679.9n TO=1680.1n

.meas tran Vdout0_47ck138 AVG v(dout0_47) FROM=1679.9n TO=1680.1n

.meas tran Vdout0_48ck138 AVG v(dout0_48) FROM=1679.9n TO=1680.1n

.meas tran Vdout0_49ck138 AVG v(dout0_49) FROM=1679.9n TO=1680.1n

.meas tran Vdout0_50ck138 AVG v(dout0_50) FROM=1679.9n TO=1680.1n

.meas tran Vdout0_51ck138 AVG v(dout0_51) FROM=1679.9n TO=1680.1n

.meas tran Vdout0_52ck138 AVG v(dout0_52) FROM=1679.9n TO=1680.1n

.meas tran Vdout0_53ck138 AVG v(dout0_53) FROM=1679.9n TO=1680.1n

.meas tran Vdout0_54ck138 AVG v(dout0_54) FROM=1679.9n TO=1680.1n

.meas tran Vdout0_55ck138 AVG v(dout0_55) FROM=1679.9n TO=1680.1n

.meas tran Vdout0_56ck138 AVG v(dout0_56) FROM=1679.9n TO=1680.1n

.meas tran Vdout0_57ck138 AVG v(dout0_57) FROM=1679.9n TO=1680.1n

.meas tran Vdout0_58ck138 AVG v(dout0_58) FROM=1679.9n TO=1680.1n

.meas tran Vdout0_59ck138 AVG v(dout0_59) FROM=1679.9n TO=1680.1n

.meas tran Vdout0_60ck138 AVG v(dout0_60) FROM=1679.9n TO=1680.1n

.meas tran Vdout0_61ck138 AVG v(dout0_61) FROM=1679.9n TO=1680.1n

.meas tran Vdout0_62ck138 AVG v(dout0_62) FROM=1679.9n TO=1680.1n

.meas tran Vdout0_63ck138 AVG v(dout0_63) FROM=1679.9n TO=1680.1n

.meas tran Vdout0_64ck138 AVG v(dout0_64) FROM=1679.9n TO=1680.1n

.meas tran Vdout0_65ck138 AVG v(dout0_65) FROM=1679.9n TO=1680.1n

.meas tran Vdout0_66ck138 AVG v(dout0_66) FROM=1679.9n TO=1680.1n

.meas tran Vdout0_67ck138 AVG v(dout0_67) FROM=1679.9n TO=1680.1n

.meas tran Vdout0_68ck138 AVG v(dout0_68) FROM=1679.9n TO=1680.1n

.meas tran Vdout0_69ck138 AVG v(dout0_69) FROM=1679.9n TO=1680.1n

.meas tran Vdout0_70ck138 AVG v(dout0_70) FROM=1679.9n TO=1680.1n

.meas tran Vdout0_71ck138 AVG v(dout0_71) FROM=1679.9n TO=1680.1n

.meas tran Vdout0_72ck138 AVG v(dout0_72) FROM=1679.9n TO=1680.1n

.meas tran Vdout0_73ck138 AVG v(dout0_73) FROM=1679.9n TO=1680.1n

.meas tran Vdout0_74ck138 AVG v(dout0_74) FROM=1679.9n TO=1680.1n

.meas tran Vdout0_75ck138 AVG v(dout0_75) FROM=1679.9n TO=1680.1n

.meas tran Vdout0_76ck138 AVG v(dout0_76) FROM=1679.9n TO=1680.1n

.meas tran Vdout0_77ck138 AVG v(dout0_77) FROM=1679.9n TO=1680.1n

.meas tran Vdout0_78ck138 AVG v(dout0_78) FROM=1679.9n TO=1680.1n

.meas tran Vdout0_79ck138 AVG v(dout0_79) FROM=1679.9n TO=1680.1n

.meas tran Vdout1_0ck139 AVG v(dout1_0) FROM=1679.9n TO=1680.1n

.meas tran Vdout1_1ck139 AVG v(dout1_1) FROM=1679.9n TO=1680.1n

.meas tran Vdout1_2ck139 AVG v(dout1_2) FROM=1679.9n TO=1680.1n

.meas tran Vdout1_3ck139 AVG v(dout1_3) FROM=1679.9n TO=1680.1n

.meas tran Vdout1_4ck139 AVG v(dout1_4) FROM=1679.9n TO=1680.1n

.meas tran Vdout1_5ck139 AVG v(dout1_5) FROM=1679.9n TO=1680.1n

.meas tran Vdout1_6ck139 AVG v(dout1_6) FROM=1679.9n TO=1680.1n

.meas tran Vdout1_7ck139 AVG v(dout1_7) FROM=1679.9n TO=1680.1n

.meas tran Vdout1_8ck139 AVG v(dout1_8) FROM=1679.9n TO=1680.1n

.meas tran Vdout1_9ck139 AVG v(dout1_9) FROM=1679.9n TO=1680.1n

.meas tran Vdout1_10ck139 AVG v(dout1_10) FROM=1679.9n TO=1680.1n

.meas tran Vdout1_11ck139 AVG v(dout1_11) FROM=1679.9n TO=1680.1n

.meas tran Vdout1_12ck139 AVG v(dout1_12) FROM=1679.9n TO=1680.1n

.meas tran Vdout1_13ck139 AVG v(dout1_13) FROM=1679.9n TO=1680.1n

.meas tran Vdout1_14ck139 AVG v(dout1_14) FROM=1679.9n TO=1680.1n

.meas tran Vdout1_15ck139 AVG v(dout1_15) FROM=1679.9n TO=1680.1n

.meas tran Vdout1_16ck139 AVG v(dout1_16) FROM=1679.9n TO=1680.1n

.meas tran Vdout1_17ck139 AVG v(dout1_17) FROM=1679.9n TO=1680.1n

.meas tran Vdout1_18ck139 AVG v(dout1_18) FROM=1679.9n TO=1680.1n

.meas tran Vdout1_19ck139 AVG v(dout1_19) FROM=1679.9n TO=1680.1n

.meas tran Vdout1_20ck139 AVG v(dout1_20) FROM=1679.9n TO=1680.1n

.meas tran Vdout1_21ck139 AVG v(dout1_21) FROM=1679.9n TO=1680.1n

.meas tran Vdout1_22ck139 AVG v(dout1_22) FROM=1679.9n TO=1680.1n

.meas tran Vdout1_23ck139 AVG v(dout1_23) FROM=1679.9n TO=1680.1n

.meas tran Vdout1_24ck139 AVG v(dout1_24) FROM=1679.9n TO=1680.1n

.meas tran Vdout1_25ck139 AVG v(dout1_25) FROM=1679.9n TO=1680.1n

.meas tran Vdout1_26ck139 AVG v(dout1_26) FROM=1679.9n TO=1680.1n

.meas tran Vdout1_27ck139 AVG v(dout1_27) FROM=1679.9n TO=1680.1n

.meas tran Vdout1_28ck139 AVG v(dout1_28) FROM=1679.9n TO=1680.1n

.meas tran Vdout1_29ck139 AVG v(dout1_29) FROM=1679.9n TO=1680.1n

.meas tran Vdout1_30ck139 AVG v(dout1_30) FROM=1679.9n TO=1680.1n

.meas tran Vdout1_31ck139 AVG v(dout1_31) FROM=1679.9n TO=1680.1n

.meas tran Vdout1_32ck139 AVG v(dout1_32) FROM=1679.9n TO=1680.1n

.meas tran Vdout1_33ck139 AVG v(dout1_33) FROM=1679.9n TO=1680.1n

.meas tran Vdout1_34ck139 AVG v(dout1_34) FROM=1679.9n TO=1680.1n

.meas tran Vdout1_35ck139 AVG v(dout1_35) FROM=1679.9n TO=1680.1n

.meas tran Vdout1_36ck139 AVG v(dout1_36) FROM=1679.9n TO=1680.1n

.meas tran Vdout1_37ck139 AVG v(dout1_37) FROM=1679.9n TO=1680.1n

.meas tran Vdout1_38ck139 AVG v(dout1_38) FROM=1679.9n TO=1680.1n

.meas tran Vdout1_39ck139 AVG v(dout1_39) FROM=1679.9n TO=1680.1n

.meas tran Vdout1_40ck139 AVG v(dout1_40) FROM=1679.9n TO=1680.1n

.meas tran Vdout1_41ck139 AVG v(dout1_41) FROM=1679.9n TO=1680.1n

.meas tran Vdout1_42ck139 AVG v(dout1_42) FROM=1679.9n TO=1680.1n

.meas tran Vdout1_43ck139 AVG v(dout1_43) FROM=1679.9n TO=1680.1n

.meas tran Vdout1_44ck139 AVG v(dout1_44) FROM=1679.9n TO=1680.1n

.meas tran Vdout1_45ck139 AVG v(dout1_45) FROM=1679.9n TO=1680.1n

.meas tran Vdout1_46ck139 AVG v(dout1_46) FROM=1679.9n TO=1680.1n

.meas tran Vdout1_47ck139 AVG v(dout1_47) FROM=1679.9n TO=1680.1n

.meas tran Vdout1_48ck139 AVG v(dout1_48) FROM=1679.9n TO=1680.1n

.meas tran Vdout1_49ck139 AVG v(dout1_49) FROM=1679.9n TO=1680.1n

.meas tran Vdout1_50ck139 AVG v(dout1_50) FROM=1679.9n TO=1680.1n

.meas tran Vdout1_51ck139 AVG v(dout1_51) FROM=1679.9n TO=1680.1n

.meas tran Vdout1_52ck139 AVG v(dout1_52) FROM=1679.9n TO=1680.1n

.meas tran Vdout1_53ck139 AVG v(dout1_53) FROM=1679.9n TO=1680.1n

.meas tran Vdout1_54ck139 AVG v(dout1_54) FROM=1679.9n TO=1680.1n

.meas tran Vdout1_55ck139 AVG v(dout1_55) FROM=1679.9n TO=1680.1n

.meas tran Vdout1_56ck139 AVG v(dout1_56) FROM=1679.9n TO=1680.1n

.meas tran Vdout1_57ck139 AVG v(dout1_57) FROM=1679.9n TO=1680.1n

.meas tran Vdout1_58ck139 AVG v(dout1_58) FROM=1679.9n TO=1680.1n

.meas tran Vdout1_59ck139 AVG v(dout1_59) FROM=1679.9n TO=1680.1n

.meas tran Vdout1_60ck139 AVG v(dout1_60) FROM=1679.9n TO=1680.1n

.meas tran Vdout1_61ck139 AVG v(dout1_61) FROM=1679.9n TO=1680.1n

.meas tran Vdout1_62ck139 AVG v(dout1_62) FROM=1679.9n TO=1680.1n

.meas tran Vdout1_63ck139 AVG v(dout1_63) FROM=1679.9n TO=1680.1n

.meas tran Vdout1_64ck139 AVG v(dout1_64) FROM=1679.9n TO=1680.1n

.meas tran Vdout1_65ck139 AVG v(dout1_65) FROM=1679.9n TO=1680.1n

.meas tran Vdout1_66ck139 AVG v(dout1_66) FROM=1679.9n TO=1680.1n

.meas tran Vdout1_67ck139 AVG v(dout1_67) FROM=1679.9n TO=1680.1n

.meas tran Vdout1_68ck139 AVG v(dout1_68) FROM=1679.9n TO=1680.1n

.meas tran Vdout1_69ck139 AVG v(dout1_69) FROM=1679.9n TO=1680.1n

.meas tran Vdout1_70ck139 AVG v(dout1_70) FROM=1679.9n TO=1680.1n

.meas tran Vdout1_71ck139 AVG v(dout1_71) FROM=1679.9n TO=1680.1n

.meas tran Vdout1_72ck139 AVG v(dout1_72) FROM=1679.9n TO=1680.1n

.meas tran Vdout1_73ck139 AVG v(dout1_73) FROM=1679.9n TO=1680.1n

.meas tran Vdout1_74ck139 AVG v(dout1_74) FROM=1679.9n TO=1680.1n

.meas tran Vdout1_75ck139 AVG v(dout1_75) FROM=1679.9n TO=1680.1n

.meas tran Vdout1_76ck139 AVG v(dout1_76) FROM=1679.9n TO=1680.1n

.meas tran Vdout1_77ck139 AVG v(dout1_77) FROM=1679.9n TO=1680.1n

.meas tran Vdout1_78ck139 AVG v(dout1_78) FROM=1679.9n TO=1680.1n

.meas tran Vdout1_79ck139 AVG v(dout1_79) FROM=1679.9n TO=1680.1n

.meas tran Vdout1_0ck140 AVG v(dout1_0) FROM=1689.9n TO=1690.1n

.meas tran Vdout1_1ck140 AVG v(dout1_1) FROM=1689.9n TO=1690.1n

.meas tran Vdout1_2ck140 AVG v(dout1_2) FROM=1689.9n TO=1690.1n

.meas tran Vdout1_3ck140 AVG v(dout1_3) FROM=1689.9n TO=1690.1n

.meas tran Vdout1_4ck140 AVG v(dout1_4) FROM=1689.9n TO=1690.1n

.meas tran Vdout1_5ck140 AVG v(dout1_5) FROM=1689.9n TO=1690.1n

.meas tran Vdout1_6ck140 AVG v(dout1_6) FROM=1689.9n TO=1690.1n

.meas tran Vdout1_7ck140 AVG v(dout1_7) FROM=1689.9n TO=1690.1n

.meas tran Vdout1_8ck140 AVG v(dout1_8) FROM=1689.9n TO=1690.1n

.meas tran Vdout1_9ck140 AVG v(dout1_9) FROM=1689.9n TO=1690.1n

.meas tran Vdout1_10ck140 AVG v(dout1_10) FROM=1689.9n TO=1690.1n

.meas tran Vdout1_11ck140 AVG v(dout1_11) FROM=1689.9n TO=1690.1n

.meas tran Vdout1_12ck140 AVG v(dout1_12) FROM=1689.9n TO=1690.1n

.meas tran Vdout1_13ck140 AVG v(dout1_13) FROM=1689.9n TO=1690.1n

.meas tran Vdout1_14ck140 AVG v(dout1_14) FROM=1689.9n TO=1690.1n

.meas tran Vdout1_15ck140 AVG v(dout1_15) FROM=1689.9n TO=1690.1n

.meas tran Vdout1_16ck140 AVG v(dout1_16) FROM=1689.9n TO=1690.1n

.meas tran Vdout1_17ck140 AVG v(dout1_17) FROM=1689.9n TO=1690.1n

.meas tran Vdout1_18ck140 AVG v(dout1_18) FROM=1689.9n TO=1690.1n

.meas tran Vdout1_19ck140 AVG v(dout1_19) FROM=1689.9n TO=1690.1n

.meas tran Vdout1_20ck140 AVG v(dout1_20) FROM=1689.9n TO=1690.1n

.meas tran Vdout1_21ck140 AVG v(dout1_21) FROM=1689.9n TO=1690.1n

.meas tran Vdout1_22ck140 AVG v(dout1_22) FROM=1689.9n TO=1690.1n

.meas tran Vdout1_23ck140 AVG v(dout1_23) FROM=1689.9n TO=1690.1n

.meas tran Vdout1_24ck140 AVG v(dout1_24) FROM=1689.9n TO=1690.1n

.meas tran Vdout1_25ck140 AVG v(dout1_25) FROM=1689.9n TO=1690.1n

.meas tran Vdout1_26ck140 AVG v(dout1_26) FROM=1689.9n TO=1690.1n

.meas tran Vdout1_27ck140 AVG v(dout1_27) FROM=1689.9n TO=1690.1n

.meas tran Vdout1_28ck140 AVG v(dout1_28) FROM=1689.9n TO=1690.1n

.meas tran Vdout1_29ck140 AVG v(dout1_29) FROM=1689.9n TO=1690.1n

.meas tran Vdout1_30ck140 AVG v(dout1_30) FROM=1689.9n TO=1690.1n

.meas tran Vdout1_31ck140 AVG v(dout1_31) FROM=1689.9n TO=1690.1n

.meas tran Vdout1_32ck140 AVG v(dout1_32) FROM=1689.9n TO=1690.1n

.meas tran Vdout1_33ck140 AVG v(dout1_33) FROM=1689.9n TO=1690.1n

.meas tran Vdout1_34ck140 AVG v(dout1_34) FROM=1689.9n TO=1690.1n

.meas tran Vdout1_35ck140 AVG v(dout1_35) FROM=1689.9n TO=1690.1n

.meas tran Vdout1_36ck140 AVG v(dout1_36) FROM=1689.9n TO=1690.1n

.meas tran Vdout1_37ck140 AVG v(dout1_37) FROM=1689.9n TO=1690.1n

.meas tran Vdout1_38ck140 AVG v(dout1_38) FROM=1689.9n TO=1690.1n

.meas tran Vdout1_39ck140 AVG v(dout1_39) FROM=1689.9n TO=1690.1n

.meas tran Vdout1_40ck140 AVG v(dout1_40) FROM=1689.9n TO=1690.1n

.meas tran Vdout1_41ck140 AVG v(dout1_41) FROM=1689.9n TO=1690.1n

.meas tran Vdout1_42ck140 AVG v(dout1_42) FROM=1689.9n TO=1690.1n

.meas tran Vdout1_43ck140 AVG v(dout1_43) FROM=1689.9n TO=1690.1n

.meas tran Vdout1_44ck140 AVG v(dout1_44) FROM=1689.9n TO=1690.1n

.meas tran Vdout1_45ck140 AVG v(dout1_45) FROM=1689.9n TO=1690.1n

.meas tran Vdout1_46ck140 AVG v(dout1_46) FROM=1689.9n TO=1690.1n

.meas tran Vdout1_47ck140 AVG v(dout1_47) FROM=1689.9n TO=1690.1n

.meas tran Vdout1_48ck140 AVG v(dout1_48) FROM=1689.9n TO=1690.1n

.meas tran Vdout1_49ck140 AVG v(dout1_49) FROM=1689.9n TO=1690.1n

.meas tran Vdout1_50ck140 AVG v(dout1_50) FROM=1689.9n TO=1690.1n

.meas tran Vdout1_51ck140 AVG v(dout1_51) FROM=1689.9n TO=1690.1n

.meas tran Vdout1_52ck140 AVG v(dout1_52) FROM=1689.9n TO=1690.1n

.meas tran Vdout1_53ck140 AVG v(dout1_53) FROM=1689.9n TO=1690.1n

.meas tran Vdout1_54ck140 AVG v(dout1_54) FROM=1689.9n TO=1690.1n

.meas tran Vdout1_55ck140 AVG v(dout1_55) FROM=1689.9n TO=1690.1n

.meas tran Vdout1_56ck140 AVG v(dout1_56) FROM=1689.9n TO=1690.1n

.meas tran Vdout1_57ck140 AVG v(dout1_57) FROM=1689.9n TO=1690.1n

.meas tran Vdout1_58ck140 AVG v(dout1_58) FROM=1689.9n TO=1690.1n

.meas tran Vdout1_59ck140 AVG v(dout1_59) FROM=1689.9n TO=1690.1n

.meas tran Vdout1_60ck140 AVG v(dout1_60) FROM=1689.9n TO=1690.1n

.meas tran Vdout1_61ck140 AVG v(dout1_61) FROM=1689.9n TO=1690.1n

.meas tran Vdout1_62ck140 AVG v(dout1_62) FROM=1689.9n TO=1690.1n

.meas tran Vdout1_63ck140 AVG v(dout1_63) FROM=1689.9n TO=1690.1n

.meas tran Vdout1_64ck140 AVG v(dout1_64) FROM=1689.9n TO=1690.1n

.meas tran Vdout1_65ck140 AVG v(dout1_65) FROM=1689.9n TO=1690.1n

.meas tran Vdout1_66ck140 AVG v(dout1_66) FROM=1689.9n TO=1690.1n

.meas tran Vdout1_67ck140 AVG v(dout1_67) FROM=1689.9n TO=1690.1n

.meas tran Vdout1_68ck140 AVG v(dout1_68) FROM=1689.9n TO=1690.1n

.meas tran Vdout1_69ck140 AVG v(dout1_69) FROM=1689.9n TO=1690.1n

.meas tran Vdout1_70ck140 AVG v(dout1_70) FROM=1689.9n TO=1690.1n

.meas tran Vdout1_71ck140 AVG v(dout1_71) FROM=1689.9n TO=1690.1n

.meas tran Vdout1_72ck140 AVG v(dout1_72) FROM=1689.9n TO=1690.1n

.meas tran Vdout1_73ck140 AVG v(dout1_73) FROM=1689.9n TO=1690.1n

.meas tran Vdout1_74ck140 AVG v(dout1_74) FROM=1689.9n TO=1690.1n

.meas tran Vdout1_75ck140 AVG v(dout1_75) FROM=1689.9n TO=1690.1n

.meas tran Vdout1_76ck140 AVG v(dout1_76) FROM=1689.9n TO=1690.1n

.meas tran Vdout1_77ck140 AVG v(dout1_77) FROM=1689.9n TO=1690.1n

.meas tran Vdout1_78ck140 AVG v(dout1_78) FROM=1689.9n TO=1690.1n

.meas tran Vdout1_79ck140 AVG v(dout1_79) FROM=1689.9n TO=1690.1n

.meas tran Vdout1_0ck141 AVG v(dout1_0) FROM=1719.9n TO=1720.1n

.meas tran Vdout1_1ck141 AVG v(dout1_1) FROM=1719.9n TO=1720.1n

.meas tran Vdout1_2ck141 AVG v(dout1_2) FROM=1719.9n TO=1720.1n

.meas tran Vdout1_3ck141 AVG v(dout1_3) FROM=1719.9n TO=1720.1n

.meas tran Vdout1_4ck141 AVG v(dout1_4) FROM=1719.9n TO=1720.1n

.meas tran Vdout1_5ck141 AVG v(dout1_5) FROM=1719.9n TO=1720.1n

.meas tran Vdout1_6ck141 AVG v(dout1_6) FROM=1719.9n TO=1720.1n

.meas tran Vdout1_7ck141 AVG v(dout1_7) FROM=1719.9n TO=1720.1n

.meas tran Vdout1_8ck141 AVG v(dout1_8) FROM=1719.9n TO=1720.1n

.meas tran Vdout1_9ck141 AVG v(dout1_9) FROM=1719.9n TO=1720.1n

.meas tran Vdout1_10ck141 AVG v(dout1_10) FROM=1719.9n TO=1720.1n

.meas tran Vdout1_11ck141 AVG v(dout1_11) FROM=1719.9n TO=1720.1n

.meas tran Vdout1_12ck141 AVG v(dout1_12) FROM=1719.9n TO=1720.1n

.meas tran Vdout1_13ck141 AVG v(dout1_13) FROM=1719.9n TO=1720.1n

.meas tran Vdout1_14ck141 AVG v(dout1_14) FROM=1719.9n TO=1720.1n

.meas tran Vdout1_15ck141 AVG v(dout1_15) FROM=1719.9n TO=1720.1n

.meas tran Vdout1_16ck141 AVG v(dout1_16) FROM=1719.9n TO=1720.1n

.meas tran Vdout1_17ck141 AVG v(dout1_17) FROM=1719.9n TO=1720.1n

.meas tran Vdout1_18ck141 AVG v(dout1_18) FROM=1719.9n TO=1720.1n

.meas tran Vdout1_19ck141 AVG v(dout1_19) FROM=1719.9n TO=1720.1n

.meas tran Vdout1_20ck141 AVG v(dout1_20) FROM=1719.9n TO=1720.1n

.meas tran Vdout1_21ck141 AVG v(dout1_21) FROM=1719.9n TO=1720.1n

.meas tran Vdout1_22ck141 AVG v(dout1_22) FROM=1719.9n TO=1720.1n

.meas tran Vdout1_23ck141 AVG v(dout1_23) FROM=1719.9n TO=1720.1n

.meas tran Vdout1_24ck141 AVG v(dout1_24) FROM=1719.9n TO=1720.1n

.meas tran Vdout1_25ck141 AVG v(dout1_25) FROM=1719.9n TO=1720.1n

.meas tran Vdout1_26ck141 AVG v(dout1_26) FROM=1719.9n TO=1720.1n

.meas tran Vdout1_27ck141 AVG v(dout1_27) FROM=1719.9n TO=1720.1n

.meas tran Vdout1_28ck141 AVG v(dout1_28) FROM=1719.9n TO=1720.1n

.meas tran Vdout1_29ck141 AVG v(dout1_29) FROM=1719.9n TO=1720.1n

.meas tran Vdout1_30ck141 AVG v(dout1_30) FROM=1719.9n TO=1720.1n

.meas tran Vdout1_31ck141 AVG v(dout1_31) FROM=1719.9n TO=1720.1n

.meas tran Vdout1_32ck141 AVG v(dout1_32) FROM=1719.9n TO=1720.1n

.meas tran Vdout1_33ck141 AVG v(dout1_33) FROM=1719.9n TO=1720.1n

.meas tran Vdout1_34ck141 AVG v(dout1_34) FROM=1719.9n TO=1720.1n

.meas tran Vdout1_35ck141 AVG v(dout1_35) FROM=1719.9n TO=1720.1n

.meas tran Vdout1_36ck141 AVG v(dout1_36) FROM=1719.9n TO=1720.1n

.meas tran Vdout1_37ck141 AVG v(dout1_37) FROM=1719.9n TO=1720.1n

.meas tran Vdout1_38ck141 AVG v(dout1_38) FROM=1719.9n TO=1720.1n

.meas tran Vdout1_39ck141 AVG v(dout1_39) FROM=1719.9n TO=1720.1n

.meas tran Vdout1_40ck141 AVG v(dout1_40) FROM=1719.9n TO=1720.1n

.meas tran Vdout1_41ck141 AVG v(dout1_41) FROM=1719.9n TO=1720.1n

.meas tran Vdout1_42ck141 AVG v(dout1_42) FROM=1719.9n TO=1720.1n

.meas tran Vdout1_43ck141 AVG v(dout1_43) FROM=1719.9n TO=1720.1n

.meas tran Vdout1_44ck141 AVG v(dout1_44) FROM=1719.9n TO=1720.1n

.meas tran Vdout1_45ck141 AVG v(dout1_45) FROM=1719.9n TO=1720.1n

.meas tran Vdout1_46ck141 AVG v(dout1_46) FROM=1719.9n TO=1720.1n

.meas tran Vdout1_47ck141 AVG v(dout1_47) FROM=1719.9n TO=1720.1n

.meas tran Vdout1_48ck141 AVG v(dout1_48) FROM=1719.9n TO=1720.1n

.meas tran Vdout1_49ck141 AVG v(dout1_49) FROM=1719.9n TO=1720.1n

.meas tran Vdout1_50ck141 AVG v(dout1_50) FROM=1719.9n TO=1720.1n

.meas tran Vdout1_51ck141 AVG v(dout1_51) FROM=1719.9n TO=1720.1n

.meas tran Vdout1_52ck141 AVG v(dout1_52) FROM=1719.9n TO=1720.1n

.meas tran Vdout1_53ck141 AVG v(dout1_53) FROM=1719.9n TO=1720.1n

.meas tran Vdout1_54ck141 AVG v(dout1_54) FROM=1719.9n TO=1720.1n

.meas tran Vdout1_55ck141 AVG v(dout1_55) FROM=1719.9n TO=1720.1n

.meas tran Vdout1_56ck141 AVG v(dout1_56) FROM=1719.9n TO=1720.1n

.meas tran Vdout1_57ck141 AVG v(dout1_57) FROM=1719.9n TO=1720.1n

.meas tran Vdout1_58ck141 AVG v(dout1_58) FROM=1719.9n TO=1720.1n

.meas tran Vdout1_59ck141 AVG v(dout1_59) FROM=1719.9n TO=1720.1n

.meas tran Vdout1_60ck141 AVG v(dout1_60) FROM=1719.9n TO=1720.1n

.meas tran Vdout1_61ck141 AVG v(dout1_61) FROM=1719.9n TO=1720.1n

.meas tran Vdout1_62ck141 AVG v(dout1_62) FROM=1719.9n TO=1720.1n

.meas tran Vdout1_63ck141 AVG v(dout1_63) FROM=1719.9n TO=1720.1n

.meas tran Vdout1_64ck141 AVG v(dout1_64) FROM=1719.9n TO=1720.1n

.meas tran Vdout1_65ck141 AVG v(dout1_65) FROM=1719.9n TO=1720.1n

.meas tran Vdout1_66ck141 AVG v(dout1_66) FROM=1719.9n TO=1720.1n

.meas tran Vdout1_67ck141 AVG v(dout1_67) FROM=1719.9n TO=1720.1n

.meas tran Vdout1_68ck141 AVG v(dout1_68) FROM=1719.9n TO=1720.1n

.meas tran Vdout1_69ck141 AVG v(dout1_69) FROM=1719.9n TO=1720.1n

.meas tran Vdout1_70ck141 AVG v(dout1_70) FROM=1719.9n TO=1720.1n

.meas tran Vdout1_71ck141 AVG v(dout1_71) FROM=1719.9n TO=1720.1n

.meas tran Vdout1_72ck141 AVG v(dout1_72) FROM=1719.9n TO=1720.1n

.meas tran Vdout1_73ck141 AVG v(dout1_73) FROM=1719.9n TO=1720.1n

.meas tran Vdout1_74ck141 AVG v(dout1_74) FROM=1719.9n TO=1720.1n

.meas tran Vdout1_75ck141 AVG v(dout1_75) FROM=1719.9n TO=1720.1n

.meas tran Vdout1_76ck141 AVG v(dout1_76) FROM=1719.9n TO=1720.1n

.meas tran Vdout1_77ck141 AVG v(dout1_77) FROM=1719.9n TO=1720.1n

.meas tran Vdout1_78ck141 AVG v(dout1_78) FROM=1719.9n TO=1720.1n

.meas tran Vdout1_79ck141 AVG v(dout1_79) FROM=1719.9n TO=1720.1n

.meas tran Vdout1_0ck142 AVG v(dout1_0) FROM=1739.9n TO=1740.1n

.meas tran Vdout1_1ck142 AVG v(dout1_1) FROM=1739.9n TO=1740.1n

.meas tran Vdout1_2ck142 AVG v(dout1_2) FROM=1739.9n TO=1740.1n

.meas tran Vdout1_3ck142 AVG v(dout1_3) FROM=1739.9n TO=1740.1n

.meas tran Vdout1_4ck142 AVG v(dout1_4) FROM=1739.9n TO=1740.1n

.meas tran Vdout1_5ck142 AVG v(dout1_5) FROM=1739.9n TO=1740.1n

.meas tran Vdout1_6ck142 AVG v(dout1_6) FROM=1739.9n TO=1740.1n

.meas tran Vdout1_7ck142 AVG v(dout1_7) FROM=1739.9n TO=1740.1n

.meas tran Vdout1_8ck142 AVG v(dout1_8) FROM=1739.9n TO=1740.1n

.meas tran Vdout1_9ck142 AVG v(dout1_9) FROM=1739.9n TO=1740.1n

.meas tran Vdout1_10ck142 AVG v(dout1_10) FROM=1739.9n TO=1740.1n

.meas tran Vdout1_11ck142 AVG v(dout1_11) FROM=1739.9n TO=1740.1n

.meas tran Vdout1_12ck142 AVG v(dout1_12) FROM=1739.9n TO=1740.1n

.meas tran Vdout1_13ck142 AVG v(dout1_13) FROM=1739.9n TO=1740.1n

.meas tran Vdout1_14ck142 AVG v(dout1_14) FROM=1739.9n TO=1740.1n

.meas tran Vdout1_15ck142 AVG v(dout1_15) FROM=1739.9n TO=1740.1n

.meas tran Vdout1_16ck142 AVG v(dout1_16) FROM=1739.9n TO=1740.1n

.meas tran Vdout1_17ck142 AVG v(dout1_17) FROM=1739.9n TO=1740.1n

.meas tran Vdout1_18ck142 AVG v(dout1_18) FROM=1739.9n TO=1740.1n

.meas tran Vdout1_19ck142 AVG v(dout1_19) FROM=1739.9n TO=1740.1n

.meas tran Vdout1_20ck142 AVG v(dout1_20) FROM=1739.9n TO=1740.1n

.meas tran Vdout1_21ck142 AVG v(dout1_21) FROM=1739.9n TO=1740.1n

.meas tran Vdout1_22ck142 AVG v(dout1_22) FROM=1739.9n TO=1740.1n

.meas tran Vdout1_23ck142 AVG v(dout1_23) FROM=1739.9n TO=1740.1n

.meas tran Vdout1_24ck142 AVG v(dout1_24) FROM=1739.9n TO=1740.1n

.meas tran Vdout1_25ck142 AVG v(dout1_25) FROM=1739.9n TO=1740.1n

.meas tran Vdout1_26ck142 AVG v(dout1_26) FROM=1739.9n TO=1740.1n

.meas tran Vdout1_27ck142 AVG v(dout1_27) FROM=1739.9n TO=1740.1n

.meas tran Vdout1_28ck142 AVG v(dout1_28) FROM=1739.9n TO=1740.1n

.meas tran Vdout1_29ck142 AVG v(dout1_29) FROM=1739.9n TO=1740.1n

.meas tran Vdout1_30ck142 AVG v(dout1_30) FROM=1739.9n TO=1740.1n

.meas tran Vdout1_31ck142 AVG v(dout1_31) FROM=1739.9n TO=1740.1n

.meas tran Vdout1_32ck142 AVG v(dout1_32) FROM=1739.9n TO=1740.1n

.meas tran Vdout1_33ck142 AVG v(dout1_33) FROM=1739.9n TO=1740.1n

.meas tran Vdout1_34ck142 AVG v(dout1_34) FROM=1739.9n TO=1740.1n

.meas tran Vdout1_35ck142 AVG v(dout1_35) FROM=1739.9n TO=1740.1n

.meas tran Vdout1_36ck142 AVG v(dout1_36) FROM=1739.9n TO=1740.1n

.meas tran Vdout1_37ck142 AVG v(dout1_37) FROM=1739.9n TO=1740.1n

.meas tran Vdout1_38ck142 AVG v(dout1_38) FROM=1739.9n TO=1740.1n

.meas tran Vdout1_39ck142 AVG v(dout1_39) FROM=1739.9n TO=1740.1n

.meas tran Vdout1_40ck142 AVG v(dout1_40) FROM=1739.9n TO=1740.1n

.meas tran Vdout1_41ck142 AVG v(dout1_41) FROM=1739.9n TO=1740.1n

.meas tran Vdout1_42ck142 AVG v(dout1_42) FROM=1739.9n TO=1740.1n

.meas tran Vdout1_43ck142 AVG v(dout1_43) FROM=1739.9n TO=1740.1n

.meas tran Vdout1_44ck142 AVG v(dout1_44) FROM=1739.9n TO=1740.1n

.meas tran Vdout1_45ck142 AVG v(dout1_45) FROM=1739.9n TO=1740.1n

.meas tran Vdout1_46ck142 AVG v(dout1_46) FROM=1739.9n TO=1740.1n

.meas tran Vdout1_47ck142 AVG v(dout1_47) FROM=1739.9n TO=1740.1n

.meas tran Vdout1_48ck142 AVG v(dout1_48) FROM=1739.9n TO=1740.1n

.meas tran Vdout1_49ck142 AVG v(dout1_49) FROM=1739.9n TO=1740.1n

.meas tran Vdout1_50ck142 AVG v(dout1_50) FROM=1739.9n TO=1740.1n

.meas tran Vdout1_51ck142 AVG v(dout1_51) FROM=1739.9n TO=1740.1n

.meas tran Vdout1_52ck142 AVG v(dout1_52) FROM=1739.9n TO=1740.1n

.meas tran Vdout1_53ck142 AVG v(dout1_53) FROM=1739.9n TO=1740.1n

.meas tran Vdout1_54ck142 AVG v(dout1_54) FROM=1739.9n TO=1740.1n

.meas tran Vdout1_55ck142 AVG v(dout1_55) FROM=1739.9n TO=1740.1n

.meas tran Vdout1_56ck142 AVG v(dout1_56) FROM=1739.9n TO=1740.1n

.meas tran Vdout1_57ck142 AVG v(dout1_57) FROM=1739.9n TO=1740.1n

.meas tran Vdout1_58ck142 AVG v(dout1_58) FROM=1739.9n TO=1740.1n

.meas tran Vdout1_59ck142 AVG v(dout1_59) FROM=1739.9n TO=1740.1n

.meas tran Vdout1_60ck142 AVG v(dout1_60) FROM=1739.9n TO=1740.1n

.meas tran Vdout1_61ck142 AVG v(dout1_61) FROM=1739.9n TO=1740.1n

.meas tran Vdout1_62ck142 AVG v(dout1_62) FROM=1739.9n TO=1740.1n

.meas tran Vdout1_63ck142 AVG v(dout1_63) FROM=1739.9n TO=1740.1n

.meas tran Vdout1_64ck142 AVG v(dout1_64) FROM=1739.9n TO=1740.1n

.meas tran Vdout1_65ck142 AVG v(dout1_65) FROM=1739.9n TO=1740.1n

.meas tran Vdout1_66ck142 AVG v(dout1_66) FROM=1739.9n TO=1740.1n

.meas tran Vdout1_67ck142 AVG v(dout1_67) FROM=1739.9n TO=1740.1n

.meas tran Vdout1_68ck142 AVG v(dout1_68) FROM=1739.9n TO=1740.1n

.meas tran Vdout1_69ck142 AVG v(dout1_69) FROM=1739.9n TO=1740.1n

.meas tran Vdout1_70ck142 AVG v(dout1_70) FROM=1739.9n TO=1740.1n

.meas tran Vdout1_71ck142 AVG v(dout1_71) FROM=1739.9n TO=1740.1n

.meas tran Vdout1_72ck142 AVG v(dout1_72) FROM=1739.9n TO=1740.1n

.meas tran Vdout1_73ck142 AVG v(dout1_73) FROM=1739.9n TO=1740.1n

.meas tran Vdout1_74ck142 AVG v(dout1_74) FROM=1739.9n TO=1740.1n

.meas tran Vdout1_75ck142 AVG v(dout1_75) FROM=1739.9n TO=1740.1n

.meas tran Vdout1_76ck142 AVG v(dout1_76) FROM=1739.9n TO=1740.1n

.meas tran Vdout1_77ck142 AVG v(dout1_77) FROM=1739.9n TO=1740.1n

.meas tran Vdout1_78ck142 AVG v(dout1_78) FROM=1739.9n TO=1740.1n

.meas tran Vdout1_79ck142 AVG v(dout1_79) FROM=1739.9n TO=1740.1n

.meas tran Vdout1_0ck143 AVG v(dout1_0) FROM=1769.9n TO=1770.1n

.meas tran Vdout1_1ck143 AVG v(dout1_1) FROM=1769.9n TO=1770.1n

.meas tran Vdout1_2ck143 AVG v(dout1_2) FROM=1769.9n TO=1770.1n

.meas tran Vdout1_3ck143 AVG v(dout1_3) FROM=1769.9n TO=1770.1n

.meas tran Vdout1_4ck143 AVG v(dout1_4) FROM=1769.9n TO=1770.1n

.meas tran Vdout1_5ck143 AVG v(dout1_5) FROM=1769.9n TO=1770.1n

.meas tran Vdout1_6ck143 AVG v(dout1_6) FROM=1769.9n TO=1770.1n

.meas tran Vdout1_7ck143 AVG v(dout1_7) FROM=1769.9n TO=1770.1n

.meas tran Vdout1_8ck143 AVG v(dout1_8) FROM=1769.9n TO=1770.1n

.meas tran Vdout1_9ck143 AVG v(dout1_9) FROM=1769.9n TO=1770.1n

.meas tran Vdout1_10ck143 AVG v(dout1_10) FROM=1769.9n TO=1770.1n

.meas tran Vdout1_11ck143 AVG v(dout1_11) FROM=1769.9n TO=1770.1n

.meas tran Vdout1_12ck143 AVG v(dout1_12) FROM=1769.9n TO=1770.1n

.meas tran Vdout1_13ck143 AVG v(dout1_13) FROM=1769.9n TO=1770.1n

.meas tran Vdout1_14ck143 AVG v(dout1_14) FROM=1769.9n TO=1770.1n

.meas tran Vdout1_15ck143 AVG v(dout1_15) FROM=1769.9n TO=1770.1n

.meas tran Vdout1_16ck143 AVG v(dout1_16) FROM=1769.9n TO=1770.1n

.meas tran Vdout1_17ck143 AVG v(dout1_17) FROM=1769.9n TO=1770.1n

.meas tran Vdout1_18ck143 AVG v(dout1_18) FROM=1769.9n TO=1770.1n

.meas tran Vdout1_19ck143 AVG v(dout1_19) FROM=1769.9n TO=1770.1n

.meas tran Vdout1_20ck143 AVG v(dout1_20) FROM=1769.9n TO=1770.1n

.meas tran Vdout1_21ck143 AVG v(dout1_21) FROM=1769.9n TO=1770.1n

.meas tran Vdout1_22ck143 AVG v(dout1_22) FROM=1769.9n TO=1770.1n

.meas tran Vdout1_23ck143 AVG v(dout1_23) FROM=1769.9n TO=1770.1n

.meas tran Vdout1_24ck143 AVG v(dout1_24) FROM=1769.9n TO=1770.1n

.meas tran Vdout1_25ck143 AVG v(dout1_25) FROM=1769.9n TO=1770.1n

.meas tran Vdout1_26ck143 AVG v(dout1_26) FROM=1769.9n TO=1770.1n

.meas tran Vdout1_27ck143 AVG v(dout1_27) FROM=1769.9n TO=1770.1n

.meas tran Vdout1_28ck143 AVG v(dout1_28) FROM=1769.9n TO=1770.1n

.meas tran Vdout1_29ck143 AVG v(dout1_29) FROM=1769.9n TO=1770.1n

.meas tran Vdout1_30ck143 AVG v(dout1_30) FROM=1769.9n TO=1770.1n

.meas tran Vdout1_31ck143 AVG v(dout1_31) FROM=1769.9n TO=1770.1n

.meas tran Vdout1_32ck143 AVG v(dout1_32) FROM=1769.9n TO=1770.1n

.meas tran Vdout1_33ck143 AVG v(dout1_33) FROM=1769.9n TO=1770.1n

.meas tran Vdout1_34ck143 AVG v(dout1_34) FROM=1769.9n TO=1770.1n

.meas tran Vdout1_35ck143 AVG v(dout1_35) FROM=1769.9n TO=1770.1n

.meas tran Vdout1_36ck143 AVG v(dout1_36) FROM=1769.9n TO=1770.1n

.meas tran Vdout1_37ck143 AVG v(dout1_37) FROM=1769.9n TO=1770.1n

.meas tran Vdout1_38ck143 AVG v(dout1_38) FROM=1769.9n TO=1770.1n

.meas tran Vdout1_39ck143 AVG v(dout1_39) FROM=1769.9n TO=1770.1n

.meas tran Vdout1_40ck143 AVG v(dout1_40) FROM=1769.9n TO=1770.1n

.meas tran Vdout1_41ck143 AVG v(dout1_41) FROM=1769.9n TO=1770.1n

.meas tran Vdout1_42ck143 AVG v(dout1_42) FROM=1769.9n TO=1770.1n

.meas tran Vdout1_43ck143 AVG v(dout1_43) FROM=1769.9n TO=1770.1n

.meas tran Vdout1_44ck143 AVG v(dout1_44) FROM=1769.9n TO=1770.1n

.meas tran Vdout1_45ck143 AVG v(dout1_45) FROM=1769.9n TO=1770.1n

.meas tran Vdout1_46ck143 AVG v(dout1_46) FROM=1769.9n TO=1770.1n

.meas tran Vdout1_47ck143 AVG v(dout1_47) FROM=1769.9n TO=1770.1n

.meas tran Vdout1_48ck143 AVG v(dout1_48) FROM=1769.9n TO=1770.1n

.meas tran Vdout1_49ck143 AVG v(dout1_49) FROM=1769.9n TO=1770.1n

.meas tran Vdout1_50ck143 AVG v(dout1_50) FROM=1769.9n TO=1770.1n

.meas tran Vdout1_51ck143 AVG v(dout1_51) FROM=1769.9n TO=1770.1n

.meas tran Vdout1_52ck143 AVG v(dout1_52) FROM=1769.9n TO=1770.1n

.meas tran Vdout1_53ck143 AVG v(dout1_53) FROM=1769.9n TO=1770.1n

.meas tran Vdout1_54ck143 AVG v(dout1_54) FROM=1769.9n TO=1770.1n

.meas tran Vdout1_55ck143 AVG v(dout1_55) FROM=1769.9n TO=1770.1n

.meas tran Vdout1_56ck143 AVG v(dout1_56) FROM=1769.9n TO=1770.1n

.meas tran Vdout1_57ck143 AVG v(dout1_57) FROM=1769.9n TO=1770.1n

.meas tran Vdout1_58ck143 AVG v(dout1_58) FROM=1769.9n TO=1770.1n

.meas tran Vdout1_59ck143 AVG v(dout1_59) FROM=1769.9n TO=1770.1n

.meas tran Vdout1_60ck143 AVG v(dout1_60) FROM=1769.9n TO=1770.1n

.meas tran Vdout1_61ck143 AVG v(dout1_61) FROM=1769.9n TO=1770.1n

.meas tran Vdout1_62ck143 AVG v(dout1_62) FROM=1769.9n TO=1770.1n

.meas tran Vdout1_63ck143 AVG v(dout1_63) FROM=1769.9n TO=1770.1n

.meas tran Vdout1_64ck143 AVG v(dout1_64) FROM=1769.9n TO=1770.1n

.meas tran Vdout1_65ck143 AVG v(dout1_65) FROM=1769.9n TO=1770.1n

.meas tran Vdout1_66ck143 AVG v(dout1_66) FROM=1769.9n TO=1770.1n

.meas tran Vdout1_67ck143 AVG v(dout1_67) FROM=1769.9n TO=1770.1n

.meas tran Vdout1_68ck143 AVG v(dout1_68) FROM=1769.9n TO=1770.1n

.meas tran Vdout1_69ck143 AVG v(dout1_69) FROM=1769.9n TO=1770.1n

.meas tran Vdout1_70ck143 AVG v(dout1_70) FROM=1769.9n TO=1770.1n

.meas tran Vdout1_71ck143 AVG v(dout1_71) FROM=1769.9n TO=1770.1n

.meas tran Vdout1_72ck143 AVG v(dout1_72) FROM=1769.9n TO=1770.1n

.meas tran Vdout1_73ck143 AVG v(dout1_73) FROM=1769.9n TO=1770.1n

.meas tran Vdout1_74ck143 AVG v(dout1_74) FROM=1769.9n TO=1770.1n

.meas tran Vdout1_75ck143 AVG v(dout1_75) FROM=1769.9n TO=1770.1n

.meas tran Vdout1_76ck143 AVG v(dout1_76) FROM=1769.9n TO=1770.1n

.meas tran Vdout1_77ck143 AVG v(dout1_77) FROM=1769.9n TO=1770.1n

.meas tran Vdout1_78ck143 AVG v(dout1_78) FROM=1769.9n TO=1770.1n

.meas tran Vdout1_79ck143 AVG v(dout1_79) FROM=1769.9n TO=1770.1n

.meas tran Vdout1_0ck144 AVG v(dout1_0) FROM=1789.9n TO=1790.1n

.meas tran Vdout1_1ck144 AVG v(dout1_1) FROM=1789.9n TO=1790.1n

.meas tran Vdout1_2ck144 AVG v(dout1_2) FROM=1789.9n TO=1790.1n

.meas tran Vdout1_3ck144 AVG v(dout1_3) FROM=1789.9n TO=1790.1n

.meas tran Vdout1_4ck144 AVG v(dout1_4) FROM=1789.9n TO=1790.1n

.meas tran Vdout1_5ck144 AVG v(dout1_5) FROM=1789.9n TO=1790.1n

.meas tran Vdout1_6ck144 AVG v(dout1_6) FROM=1789.9n TO=1790.1n

.meas tran Vdout1_7ck144 AVG v(dout1_7) FROM=1789.9n TO=1790.1n

.meas tran Vdout1_8ck144 AVG v(dout1_8) FROM=1789.9n TO=1790.1n

.meas tran Vdout1_9ck144 AVG v(dout1_9) FROM=1789.9n TO=1790.1n

.meas tran Vdout1_10ck144 AVG v(dout1_10) FROM=1789.9n TO=1790.1n

.meas tran Vdout1_11ck144 AVG v(dout1_11) FROM=1789.9n TO=1790.1n

.meas tran Vdout1_12ck144 AVG v(dout1_12) FROM=1789.9n TO=1790.1n

.meas tran Vdout1_13ck144 AVG v(dout1_13) FROM=1789.9n TO=1790.1n

.meas tran Vdout1_14ck144 AVG v(dout1_14) FROM=1789.9n TO=1790.1n

.meas tran Vdout1_15ck144 AVG v(dout1_15) FROM=1789.9n TO=1790.1n

.meas tran Vdout1_16ck144 AVG v(dout1_16) FROM=1789.9n TO=1790.1n

.meas tran Vdout1_17ck144 AVG v(dout1_17) FROM=1789.9n TO=1790.1n

.meas tran Vdout1_18ck144 AVG v(dout1_18) FROM=1789.9n TO=1790.1n

.meas tran Vdout1_19ck144 AVG v(dout1_19) FROM=1789.9n TO=1790.1n

.meas tran Vdout1_20ck144 AVG v(dout1_20) FROM=1789.9n TO=1790.1n

.meas tran Vdout1_21ck144 AVG v(dout1_21) FROM=1789.9n TO=1790.1n

.meas tran Vdout1_22ck144 AVG v(dout1_22) FROM=1789.9n TO=1790.1n

.meas tran Vdout1_23ck144 AVG v(dout1_23) FROM=1789.9n TO=1790.1n

.meas tran Vdout1_24ck144 AVG v(dout1_24) FROM=1789.9n TO=1790.1n

.meas tran Vdout1_25ck144 AVG v(dout1_25) FROM=1789.9n TO=1790.1n

.meas tran Vdout1_26ck144 AVG v(dout1_26) FROM=1789.9n TO=1790.1n

.meas tran Vdout1_27ck144 AVG v(dout1_27) FROM=1789.9n TO=1790.1n

.meas tran Vdout1_28ck144 AVG v(dout1_28) FROM=1789.9n TO=1790.1n

.meas tran Vdout1_29ck144 AVG v(dout1_29) FROM=1789.9n TO=1790.1n

.meas tran Vdout1_30ck144 AVG v(dout1_30) FROM=1789.9n TO=1790.1n

.meas tran Vdout1_31ck144 AVG v(dout1_31) FROM=1789.9n TO=1790.1n

.meas tran Vdout1_32ck144 AVG v(dout1_32) FROM=1789.9n TO=1790.1n

.meas tran Vdout1_33ck144 AVG v(dout1_33) FROM=1789.9n TO=1790.1n

.meas tran Vdout1_34ck144 AVG v(dout1_34) FROM=1789.9n TO=1790.1n

.meas tran Vdout1_35ck144 AVG v(dout1_35) FROM=1789.9n TO=1790.1n

.meas tran Vdout1_36ck144 AVG v(dout1_36) FROM=1789.9n TO=1790.1n

.meas tran Vdout1_37ck144 AVG v(dout1_37) FROM=1789.9n TO=1790.1n

.meas tran Vdout1_38ck144 AVG v(dout1_38) FROM=1789.9n TO=1790.1n

.meas tran Vdout1_39ck144 AVG v(dout1_39) FROM=1789.9n TO=1790.1n

.meas tran Vdout1_40ck144 AVG v(dout1_40) FROM=1789.9n TO=1790.1n

.meas tran Vdout1_41ck144 AVG v(dout1_41) FROM=1789.9n TO=1790.1n

.meas tran Vdout1_42ck144 AVG v(dout1_42) FROM=1789.9n TO=1790.1n

.meas tran Vdout1_43ck144 AVG v(dout1_43) FROM=1789.9n TO=1790.1n

.meas tran Vdout1_44ck144 AVG v(dout1_44) FROM=1789.9n TO=1790.1n

.meas tran Vdout1_45ck144 AVG v(dout1_45) FROM=1789.9n TO=1790.1n

.meas tran Vdout1_46ck144 AVG v(dout1_46) FROM=1789.9n TO=1790.1n

.meas tran Vdout1_47ck144 AVG v(dout1_47) FROM=1789.9n TO=1790.1n

.meas tran Vdout1_48ck144 AVG v(dout1_48) FROM=1789.9n TO=1790.1n

.meas tran Vdout1_49ck144 AVG v(dout1_49) FROM=1789.9n TO=1790.1n

.meas tran Vdout1_50ck144 AVG v(dout1_50) FROM=1789.9n TO=1790.1n

.meas tran Vdout1_51ck144 AVG v(dout1_51) FROM=1789.9n TO=1790.1n

.meas tran Vdout1_52ck144 AVG v(dout1_52) FROM=1789.9n TO=1790.1n

.meas tran Vdout1_53ck144 AVG v(dout1_53) FROM=1789.9n TO=1790.1n

.meas tran Vdout1_54ck144 AVG v(dout1_54) FROM=1789.9n TO=1790.1n

.meas tran Vdout1_55ck144 AVG v(dout1_55) FROM=1789.9n TO=1790.1n

.meas tran Vdout1_56ck144 AVG v(dout1_56) FROM=1789.9n TO=1790.1n

.meas tran Vdout1_57ck144 AVG v(dout1_57) FROM=1789.9n TO=1790.1n

.meas tran Vdout1_58ck144 AVG v(dout1_58) FROM=1789.9n TO=1790.1n

.meas tran Vdout1_59ck144 AVG v(dout1_59) FROM=1789.9n TO=1790.1n

.meas tran Vdout1_60ck144 AVG v(dout1_60) FROM=1789.9n TO=1790.1n

.meas tran Vdout1_61ck144 AVG v(dout1_61) FROM=1789.9n TO=1790.1n

.meas tran Vdout1_62ck144 AVG v(dout1_62) FROM=1789.9n TO=1790.1n

.meas tran Vdout1_63ck144 AVG v(dout1_63) FROM=1789.9n TO=1790.1n

.meas tran Vdout1_64ck144 AVG v(dout1_64) FROM=1789.9n TO=1790.1n

.meas tran Vdout1_65ck144 AVG v(dout1_65) FROM=1789.9n TO=1790.1n

.meas tran Vdout1_66ck144 AVG v(dout1_66) FROM=1789.9n TO=1790.1n

.meas tran Vdout1_67ck144 AVG v(dout1_67) FROM=1789.9n TO=1790.1n

.meas tran Vdout1_68ck144 AVG v(dout1_68) FROM=1789.9n TO=1790.1n

.meas tran Vdout1_69ck144 AVG v(dout1_69) FROM=1789.9n TO=1790.1n

.meas tran Vdout1_70ck144 AVG v(dout1_70) FROM=1789.9n TO=1790.1n

.meas tran Vdout1_71ck144 AVG v(dout1_71) FROM=1789.9n TO=1790.1n

.meas tran Vdout1_72ck144 AVG v(dout1_72) FROM=1789.9n TO=1790.1n

.meas tran Vdout1_73ck144 AVG v(dout1_73) FROM=1789.9n TO=1790.1n

.meas tran Vdout1_74ck144 AVG v(dout1_74) FROM=1789.9n TO=1790.1n

.meas tran Vdout1_75ck144 AVG v(dout1_75) FROM=1789.9n TO=1790.1n

.meas tran Vdout1_76ck144 AVG v(dout1_76) FROM=1789.9n TO=1790.1n

.meas tran Vdout1_77ck144 AVG v(dout1_77) FROM=1789.9n TO=1790.1n

.meas tran Vdout1_78ck144 AVG v(dout1_78) FROM=1789.9n TO=1790.1n

.meas tran Vdout1_79ck144 AVG v(dout1_79) FROM=1789.9n TO=1790.1n

.meas tran Vdout0_0ck145 AVG v(dout0_0) FROM=1829.9n TO=1830.1n

.meas tran Vdout0_1ck145 AVG v(dout0_1) FROM=1829.9n TO=1830.1n

.meas tran Vdout0_2ck145 AVG v(dout0_2) FROM=1829.9n TO=1830.1n

.meas tran Vdout0_3ck145 AVG v(dout0_3) FROM=1829.9n TO=1830.1n

.meas tran Vdout0_4ck145 AVG v(dout0_4) FROM=1829.9n TO=1830.1n

.meas tran Vdout0_5ck145 AVG v(dout0_5) FROM=1829.9n TO=1830.1n

.meas tran Vdout0_6ck145 AVG v(dout0_6) FROM=1829.9n TO=1830.1n

.meas tran Vdout0_7ck145 AVG v(dout0_7) FROM=1829.9n TO=1830.1n

.meas tran Vdout0_8ck145 AVG v(dout0_8) FROM=1829.9n TO=1830.1n

.meas tran Vdout0_9ck145 AVG v(dout0_9) FROM=1829.9n TO=1830.1n

.meas tran Vdout0_10ck145 AVG v(dout0_10) FROM=1829.9n TO=1830.1n

.meas tran Vdout0_11ck145 AVG v(dout0_11) FROM=1829.9n TO=1830.1n

.meas tran Vdout0_12ck145 AVG v(dout0_12) FROM=1829.9n TO=1830.1n

.meas tran Vdout0_13ck145 AVG v(dout0_13) FROM=1829.9n TO=1830.1n

.meas tran Vdout0_14ck145 AVG v(dout0_14) FROM=1829.9n TO=1830.1n

.meas tran Vdout0_15ck145 AVG v(dout0_15) FROM=1829.9n TO=1830.1n

.meas tran Vdout0_16ck145 AVG v(dout0_16) FROM=1829.9n TO=1830.1n

.meas tran Vdout0_17ck145 AVG v(dout0_17) FROM=1829.9n TO=1830.1n

.meas tran Vdout0_18ck145 AVG v(dout0_18) FROM=1829.9n TO=1830.1n

.meas tran Vdout0_19ck145 AVG v(dout0_19) FROM=1829.9n TO=1830.1n

.meas tran Vdout0_20ck145 AVG v(dout0_20) FROM=1829.9n TO=1830.1n

.meas tran Vdout0_21ck145 AVG v(dout0_21) FROM=1829.9n TO=1830.1n

.meas tran Vdout0_22ck145 AVG v(dout0_22) FROM=1829.9n TO=1830.1n

.meas tran Vdout0_23ck145 AVG v(dout0_23) FROM=1829.9n TO=1830.1n

.meas tran Vdout0_24ck145 AVG v(dout0_24) FROM=1829.9n TO=1830.1n

.meas tran Vdout0_25ck145 AVG v(dout0_25) FROM=1829.9n TO=1830.1n

.meas tran Vdout0_26ck145 AVG v(dout0_26) FROM=1829.9n TO=1830.1n

.meas tran Vdout0_27ck145 AVG v(dout0_27) FROM=1829.9n TO=1830.1n

.meas tran Vdout0_28ck145 AVG v(dout0_28) FROM=1829.9n TO=1830.1n

.meas tran Vdout0_29ck145 AVG v(dout0_29) FROM=1829.9n TO=1830.1n

.meas tran Vdout0_30ck145 AVG v(dout0_30) FROM=1829.9n TO=1830.1n

.meas tran Vdout0_31ck145 AVG v(dout0_31) FROM=1829.9n TO=1830.1n

.meas tran Vdout0_32ck145 AVG v(dout0_32) FROM=1829.9n TO=1830.1n

.meas tran Vdout0_33ck145 AVG v(dout0_33) FROM=1829.9n TO=1830.1n

.meas tran Vdout0_34ck145 AVG v(dout0_34) FROM=1829.9n TO=1830.1n

.meas tran Vdout0_35ck145 AVG v(dout0_35) FROM=1829.9n TO=1830.1n

.meas tran Vdout0_36ck145 AVG v(dout0_36) FROM=1829.9n TO=1830.1n

.meas tran Vdout0_37ck145 AVG v(dout0_37) FROM=1829.9n TO=1830.1n

.meas tran Vdout0_38ck145 AVG v(dout0_38) FROM=1829.9n TO=1830.1n

.meas tran Vdout0_39ck145 AVG v(dout0_39) FROM=1829.9n TO=1830.1n

.meas tran Vdout0_40ck145 AVG v(dout0_40) FROM=1829.9n TO=1830.1n

.meas tran Vdout0_41ck145 AVG v(dout0_41) FROM=1829.9n TO=1830.1n

.meas tran Vdout0_42ck145 AVG v(dout0_42) FROM=1829.9n TO=1830.1n

.meas tran Vdout0_43ck145 AVG v(dout0_43) FROM=1829.9n TO=1830.1n

.meas tran Vdout0_44ck145 AVG v(dout0_44) FROM=1829.9n TO=1830.1n

.meas tran Vdout0_45ck145 AVG v(dout0_45) FROM=1829.9n TO=1830.1n

.meas tran Vdout0_46ck145 AVG v(dout0_46) FROM=1829.9n TO=1830.1n

.meas tran Vdout0_47ck145 AVG v(dout0_47) FROM=1829.9n TO=1830.1n

.meas tran Vdout0_48ck145 AVG v(dout0_48) FROM=1829.9n TO=1830.1n

.meas tran Vdout0_49ck145 AVG v(dout0_49) FROM=1829.9n TO=1830.1n

.meas tran Vdout0_50ck145 AVG v(dout0_50) FROM=1829.9n TO=1830.1n

.meas tran Vdout0_51ck145 AVG v(dout0_51) FROM=1829.9n TO=1830.1n

.meas tran Vdout0_52ck145 AVG v(dout0_52) FROM=1829.9n TO=1830.1n

.meas tran Vdout0_53ck145 AVG v(dout0_53) FROM=1829.9n TO=1830.1n

.meas tran Vdout0_54ck145 AVG v(dout0_54) FROM=1829.9n TO=1830.1n

.meas tran Vdout0_55ck145 AVG v(dout0_55) FROM=1829.9n TO=1830.1n

.meas tran Vdout0_56ck145 AVG v(dout0_56) FROM=1829.9n TO=1830.1n

.meas tran Vdout0_57ck145 AVG v(dout0_57) FROM=1829.9n TO=1830.1n

.meas tran Vdout0_58ck145 AVG v(dout0_58) FROM=1829.9n TO=1830.1n

.meas tran Vdout0_59ck145 AVG v(dout0_59) FROM=1829.9n TO=1830.1n

.meas tran Vdout0_60ck145 AVG v(dout0_60) FROM=1829.9n TO=1830.1n

.meas tran Vdout0_61ck145 AVG v(dout0_61) FROM=1829.9n TO=1830.1n

.meas tran Vdout0_62ck145 AVG v(dout0_62) FROM=1829.9n TO=1830.1n

.meas tran Vdout0_63ck145 AVG v(dout0_63) FROM=1829.9n TO=1830.1n

.meas tran Vdout0_64ck145 AVG v(dout0_64) FROM=1829.9n TO=1830.1n

.meas tran Vdout0_65ck145 AVG v(dout0_65) FROM=1829.9n TO=1830.1n

.meas tran Vdout0_66ck145 AVG v(dout0_66) FROM=1829.9n TO=1830.1n

.meas tran Vdout0_67ck145 AVG v(dout0_67) FROM=1829.9n TO=1830.1n

.meas tran Vdout0_68ck145 AVG v(dout0_68) FROM=1829.9n TO=1830.1n

.meas tran Vdout0_69ck145 AVG v(dout0_69) FROM=1829.9n TO=1830.1n

.meas tran Vdout0_70ck145 AVG v(dout0_70) FROM=1829.9n TO=1830.1n

.meas tran Vdout0_71ck145 AVG v(dout0_71) FROM=1829.9n TO=1830.1n

.meas tran Vdout0_72ck145 AVG v(dout0_72) FROM=1829.9n TO=1830.1n

.meas tran Vdout0_73ck145 AVG v(dout0_73) FROM=1829.9n TO=1830.1n

.meas tran Vdout0_74ck145 AVG v(dout0_74) FROM=1829.9n TO=1830.1n

.meas tran Vdout0_75ck145 AVG v(dout0_75) FROM=1829.9n TO=1830.1n

.meas tran Vdout0_76ck145 AVG v(dout0_76) FROM=1829.9n TO=1830.1n

.meas tran Vdout0_77ck145 AVG v(dout0_77) FROM=1829.9n TO=1830.1n

.meas tran Vdout0_78ck145 AVG v(dout0_78) FROM=1829.9n TO=1830.1n

.meas tran Vdout0_79ck145 AVG v(dout0_79) FROM=1829.9n TO=1830.1n

.meas tran Vdout0_0ck146 AVG v(dout0_0) FROM=1859.9n TO=1860.1n

.meas tran Vdout0_1ck146 AVG v(dout0_1) FROM=1859.9n TO=1860.1n

.meas tran Vdout0_2ck146 AVG v(dout0_2) FROM=1859.9n TO=1860.1n

.meas tran Vdout0_3ck146 AVG v(dout0_3) FROM=1859.9n TO=1860.1n

.meas tran Vdout0_4ck146 AVG v(dout0_4) FROM=1859.9n TO=1860.1n

.meas tran Vdout0_5ck146 AVG v(dout0_5) FROM=1859.9n TO=1860.1n

.meas tran Vdout0_6ck146 AVG v(dout0_6) FROM=1859.9n TO=1860.1n

.meas tran Vdout0_7ck146 AVG v(dout0_7) FROM=1859.9n TO=1860.1n

.meas tran Vdout0_8ck146 AVG v(dout0_8) FROM=1859.9n TO=1860.1n

.meas tran Vdout0_9ck146 AVG v(dout0_9) FROM=1859.9n TO=1860.1n

.meas tran Vdout0_10ck146 AVG v(dout0_10) FROM=1859.9n TO=1860.1n

.meas tran Vdout0_11ck146 AVG v(dout0_11) FROM=1859.9n TO=1860.1n

.meas tran Vdout0_12ck146 AVG v(dout0_12) FROM=1859.9n TO=1860.1n

.meas tran Vdout0_13ck146 AVG v(dout0_13) FROM=1859.9n TO=1860.1n

.meas tran Vdout0_14ck146 AVG v(dout0_14) FROM=1859.9n TO=1860.1n

.meas tran Vdout0_15ck146 AVG v(dout0_15) FROM=1859.9n TO=1860.1n

.meas tran Vdout0_16ck146 AVG v(dout0_16) FROM=1859.9n TO=1860.1n

.meas tran Vdout0_17ck146 AVG v(dout0_17) FROM=1859.9n TO=1860.1n

.meas tran Vdout0_18ck146 AVG v(dout0_18) FROM=1859.9n TO=1860.1n

.meas tran Vdout0_19ck146 AVG v(dout0_19) FROM=1859.9n TO=1860.1n

.meas tran Vdout0_20ck146 AVG v(dout0_20) FROM=1859.9n TO=1860.1n

.meas tran Vdout0_21ck146 AVG v(dout0_21) FROM=1859.9n TO=1860.1n

.meas tran Vdout0_22ck146 AVG v(dout0_22) FROM=1859.9n TO=1860.1n

.meas tran Vdout0_23ck146 AVG v(dout0_23) FROM=1859.9n TO=1860.1n

.meas tran Vdout0_24ck146 AVG v(dout0_24) FROM=1859.9n TO=1860.1n

.meas tran Vdout0_25ck146 AVG v(dout0_25) FROM=1859.9n TO=1860.1n

.meas tran Vdout0_26ck146 AVG v(dout0_26) FROM=1859.9n TO=1860.1n

.meas tran Vdout0_27ck146 AVG v(dout0_27) FROM=1859.9n TO=1860.1n

.meas tran Vdout0_28ck146 AVG v(dout0_28) FROM=1859.9n TO=1860.1n

.meas tran Vdout0_29ck146 AVG v(dout0_29) FROM=1859.9n TO=1860.1n

.meas tran Vdout0_30ck146 AVG v(dout0_30) FROM=1859.9n TO=1860.1n

.meas tran Vdout0_31ck146 AVG v(dout0_31) FROM=1859.9n TO=1860.1n

.meas tran Vdout0_32ck146 AVG v(dout0_32) FROM=1859.9n TO=1860.1n

.meas tran Vdout0_33ck146 AVG v(dout0_33) FROM=1859.9n TO=1860.1n

.meas tran Vdout0_34ck146 AVG v(dout0_34) FROM=1859.9n TO=1860.1n

.meas tran Vdout0_35ck146 AVG v(dout0_35) FROM=1859.9n TO=1860.1n

.meas tran Vdout0_36ck146 AVG v(dout0_36) FROM=1859.9n TO=1860.1n

.meas tran Vdout0_37ck146 AVG v(dout0_37) FROM=1859.9n TO=1860.1n

.meas tran Vdout0_38ck146 AVG v(dout0_38) FROM=1859.9n TO=1860.1n

.meas tran Vdout0_39ck146 AVG v(dout0_39) FROM=1859.9n TO=1860.1n

.meas tran Vdout0_40ck146 AVG v(dout0_40) FROM=1859.9n TO=1860.1n

.meas tran Vdout0_41ck146 AVG v(dout0_41) FROM=1859.9n TO=1860.1n

.meas tran Vdout0_42ck146 AVG v(dout0_42) FROM=1859.9n TO=1860.1n

.meas tran Vdout0_43ck146 AVG v(dout0_43) FROM=1859.9n TO=1860.1n

.meas tran Vdout0_44ck146 AVG v(dout0_44) FROM=1859.9n TO=1860.1n

.meas tran Vdout0_45ck146 AVG v(dout0_45) FROM=1859.9n TO=1860.1n

.meas tran Vdout0_46ck146 AVG v(dout0_46) FROM=1859.9n TO=1860.1n

.meas tran Vdout0_47ck146 AVG v(dout0_47) FROM=1859.9n TO=1860.1n

.meas tran Vdout0_48ck146 AVG v(dout0_48) FROM=1859.9n TO=1860.1n

.meas tran Vdout0_49ck146 AVG v(dout0_49) FROM=1859.9n TO=1860.1n

.meas tran Vdout0_50ck146 AVG v(dout0_50) FROM=1859.9n TO=1860.1n

.meas tran Vdout0_51ck146 AVG v(dout0_51) FROM=1859.9n TO=1860.1n

.meas tran Vdout0_52ck146 AVG v(dout0_52) FROM=1859.9n TO=1860.1n

.meas tran Vdout0_53ck146 AVG v(dout0_53) FROM=1859.9n TO=1860.1n

.meas tran Vdout0_54ck146 AVG v(dout0_54) FROM=1859.9n TO=1860.1n

.meas tran Vdout0_55ck146 AVG v(dout0_55) FROM=1859.9n TO=1860.1n

.meas tran Vdout0_56ck146 AVG v(dout0_56) FROM=1859.9n TO=1860.1n

.meas tran Vdout0_57ck146 AVG v(dout0_57) FROM=1859.9n TO=1860.1n

.meas tran Vdout0_58ck146 AVG v(dout0_58) FROM=1859.9n TO=1860.1n

.meas tran Vdout0_59ck146 AVG v(dout0_59) FROM=1859.9n TO=1860.1n

.meas tran Vdout0_60ck146 AVG v(dout0_60) FROM=1859.9n TO=1860.1n

.meas tran Vdout0_61ck146 AVG v(dout0_61) FROM=1859.9n TO=1860.1n

.meas tran Vdout0_62ck146 AVG v(dout0_62) FROM=1859.9n TO=1860.1n

.meas tran Vdout0_63ck146 AVG v(dout0_63) FROM=1859.9n TO=1860.1n

.meas tran Vdout0_64ck146 AVG v(dout0_64) FROM=1859.9n TO=1860.1n

.meas tran Vdout0_65ck146 AVG v(dout0_65) FROM=1859.9n TO=1860.1n

.meas tran Vdout0_66ck146 AVG v(dout0_66) FROM=1859.9n TO=1860.1n

.meas tran Vdout0_67ck146 AVG v(dout0_67) FROM=1859.9n TO=1860.1n

.meas tran Vdout0_68ck146 AVG v(dout0_68) FROM=1859.9n TO=1860.1n

.meas tran Vdout0_69ck146 AVG v(dout0_69) FROM=1859.9n TO=1860.1n

.meas tran Vdout0_70ck146 AVG v(dout0_70) FROM=1859.9n TO=1860.1n

.meas tran Vdout0_71ck146 AVG v(dout0_71) FROM=1859.9n TO=1860.1n

.meas tran Vdout0_72ck146 AVG v(dout0_72) FROM=1859.9n TO=1860.1n

.meas tran Vdout0_73ck146 AVG v(dout0_73) FROM=1859.9n TO=1860.1n

.meas tran Vdout0_74ck146 AVG v(dout0_74) FROM=1859.9n TO=1860.1n

.meas tran Vdout0_75ck146 AVG v(dout0_75) FROM=1859.9n TO=1860.1n

.meas tran Vdout0_76ck146 AVG v(dout0_76) FROM=1859.9n TO=1860.1n

.meas tran Vdout0_77ck146 AVG v(dout0_77) FROM=1859.9n TO=1860.1n

.meas tran Vdout0_78ck146 AVG v(dout0_78) FROM=1859.9n TO=1860.1n

.meas tran Vdout0_79ck146 AVG v(dout0_79) FROM=1859.9n TO=1860.1n

.meas tran Vdout1_0ck147 AVG v(dout1_0) FROM=1859.9n TO=1860.1n

.meas tran Vdout1_1ck147 AVG v(dout1_1) FROM=1859.9n TO=1860.1n

.meas tran Vdout1_2ck147 AVG v(dout1_2) FROM=1859.9n TO=1860.1n

.meas tran Vdout1_3ck147 AVG v(dout1_3) FROM=1859.9n TO=1860.1n

.meas tran Vdout1_4ck147 AVG v(dout1_4) FROM=1859.9n TO=1860.1n

.meas tran Vdout1_5ck147 AVG v(dout1_5) FROM=1859.9n TO=1860.1n

.meas tran Vdout1_6ck147 AVG v(dout1_6) FROM=1859.9n TO=1860.1n

.meas tran Vdout1_7ck147 AVG v(dout1_7) FROM=1859.9n TO=1860.1n

.meas tran Vdout1_8ck147 AVG v(dout1_8) FROM=1859.9n TO=1860.1n

.meas tran Vdout1_9ck147 AVG v(dout1_9) FROM=1859.9n TO=1860.1n

.meas tran Vdout1_10ck147 AVG v(dout1_10) FROM=1859.9n TO=1860.1n

.meas tran Vdout1_11ck147 AVG v(dout1_11) FROM=1859.9n TO=1860.1n

.meas tran Vdout1_12ck147 AVG v(dout1_12) FROM=1859.9n TO=1860.1n

.meas tran Vdout1_13ck147 AVG v(dout1_13) FROM=1859.9n TO=1860.1n

.meas tran Vdout1_14ck147 AVG v(dout1_14) FROM=1859.9n TO=1860.1n

.meas tran Vdout1_15ck147 AVG v(dout1_15) FROM=1859.9n TO=1860.1n

.meas tran Vdout1_16ck147 AVG v(dout1_16) FROM=1859.9n TO=1860.1n

.meas tran Vdout1_17ck147 AVG v(dout1_17) FROM=1859.9n TO=1860.1n

.meas tran Vdout1_18ck147 AVG v(dout1_18) FROM=1859.9n TO=1860.1n

.meas tran Vdout1_19ck147 AVG v(dout1_19) FROM=1859.9n TO=1860.1n

.meas tran Vdout1_20ck147 AVG v(dout1_20) FROM=1859.9n TO=1860.1n

.meas tran Vdout1_21ck147 AVG v(dout1_21) FROM=1859.9n TO=1860.1n

.meas tran Vdout1_22ck147 AVG v(dout1_22) FROM=1859.9n TO=1860.1n

.meas tran Vdout1_23ck147 AVG v(dout1_23) FROM=1859.9n TO=1860.1n

.meas tran Vdout1_24ck147 AVG v(dout1_24) FROM=1859.9n TO=1860.1n

.meas tran Vdout1_25ck147 AVG v(dout1_25) FROM=1859.9n TO=1860.1n

.meas tran Vdout1_26ck147 AVG v(dout1_26) FROM=1859.9n TO=1860.1n

.meas tran Vdout1_27ck147 AVG v(dout1_27) FROM=1859.9n TO=1860.1n

.meas tran Vdout1_28ck147 AVG v(dout1_28) FROM=1859.9n TO=1860.1n

.meas tran Vdout1_29ck147 AVG v(dout1_29) FROM=1859.9n TO=1860.1n

.meas tran Vdout1_30ck147 AVG v(dout1_30) FROM=1859.9n TO=1860.1n

.meas tran Vdout1_31ck147 AVG v(dout1_31) FROM=1859.9n TO=1860.1n

.meas tran Vdout1_32ck147 AVG v(dout1_32) FROM=1859.9n TO=1860.1n

.meas tran Vdout1_33ck147 AVG v(dout1_33) FROM=1859.9n TO=1860.1n

.meas tran Vdout1_34ck147 AVG v(dout1_34) FROM=1859.9n TO=1860.1n

.meas tran Vdout1_35ck147 AVG v(dout1_35) FROM=1859.9n TO=1860.1n

.meas tran Vdout1_36ck147 AVG v(dout1_36) FROM=1859.9n TO=1860.1n

.meas tran Vdout1_37ck147 AVG v(dout1_37) FROM=1859.9n TO=1860.1n

.meas tran Vdout1_38ck147 AVG v(dout1_38) FROM=1859.9n TO=1860.1n

.meas tran Vdout1_39ck147 AVG v(dout1_39) FROM=1859.9n TO=1860.1n

.meas tran Vdout1_40ck147 AVG v(dout1_40) FROM=1859.9n TO=1860.1n

.meas tran Vdout1_41ck147 AVG v(dout1_41) FROM=1859.9n TO=1860.1n

.meas tran Vdout1_42ck147 AVG v(dout1_42) FROM=1859.9n TO=1860.1n

.meas tran Vdout1_43ck147 AVG v(dout1_43) FROM=1859.9n TO=1860.1n

.meas tran Vdout1_44ck147 AVG v(dout1_44) FROM=1859.9n TO=1860.1n

.meas tran Vdout1_45ck147 AVG v(dout1_45) FROM=1859.9n TO=1860.1n

.meas tran Vdout1_46ck147 AVG v(dout1_46) FROM=1859.9n TO=1860.1n

.meas tran Vdout1_47ck147 AVG v(dout1_47) FROM=1859.9n TO=1860.1n

.meas tran Vdout1_48ck147 AVG v(dout1_48) FROM=1859.9n TO=1860.1n

.meas tran Vdout1_49ck147 AVG v(dout1_49) FROM=1859.9n TO=1860.1n

.meas tran Vdout1_50ck147 AVG v(dout1_50) FROM=1859.9n TO=1860.1n

.meas tran Vdout1_51ck147 AVG v(dout1_51) FROM=1859.9n TO=1860.1n

.meas tran Vdout1_52ck147 AVG v(dout1_52) FROM=1859.9n TO=1860.1n

.meas tran Vdout1_53ck147 AVG v(dout1_53) FROM=1859.9n TO=1860.1n

.meas tran Vdout1_54ck147 AVG v(dout1_54) FROM=1859.9n TO=1860.1n

.meas tran Vdout1_55ck147 AVG v(dout1_55) FROM=1859.9n TO=1860.1n

.meas tran Vdout1_56ck147 AVG v(dout1_56) FROM=1859.9n TO=1860.1n

.meas tran Vdout1_57ck147 AVG v(dout1_57) FROM=1859.9n TO=1860.1n

.meas tran Vdout1_58ck147 AVG v(dout1_58) FROM=1859.9n TO=1860.1n

.meas tran Vdout1_59ck147 AVG v(dout1_59) FROM=1859.9n TO=1860.1n

.meas tran Vdout1_60ck147 AVG v(dout1_60) FROM=1859.9n TO=1860.1n

.meas tran Vdout1_61ck147 AVG v(dout1_61) FROM=1859.9n TO=1860.1n

.meas tran Vdout1_62ck147 AVG v(dout1_62) FROM=1859.9n TO=1860.1n

.meas tran Vdout1_63ck147 AVG v(dout1_63) FROM=1859.9n TO=1860.1n

.meas tran Vdout1_64ck147 AVG v(dout1_64) FROM=1859.9n TO=1860.1n

.meas tran Vdout1_65ck147 AVG v(dout1_65) FROM=1859.9n TO=1860.1n

.meas tran Vdout1_66ck147 AVG v(dout1_66) FROM=1859.9n TO=1860.1n

.meas tran Vdout1_67ck147 AVG v(dout1_67) FROM=1859.9n TO=1860.1n

.meas tran Vdout1_68ck147 AVG v(dout1_68) FROM=1859.9n TO=1860.1n

.meas tran Vdout1_69ck147 AVG v(dout1_69) FROM=1859.9n TO=1860.1n

.meas tran Vdout1_70ck147 AVG v(dout1_70) FROM=1859.9n TO=1860.1n

.meas tran Vdout1_71ck147 AVG v(dout1_71) FROM=1859.9n TO=1860.1n

.meas tran Vdout1_72ck147 AVG v(dout1_72) FROM=1859.9n TO=1860.1n

.meas tran Vdout1_73ck147 AVG v(dout1_73) FROM=1859.9n TO=1860.1n

.meas tran Vdout1_74ck147 AVG v(dout1_74) FROM=1859.9n TO=1860.1n

.meas tran Vdout1_75ck147 AVG v(dout1_75) FROM=1859.9n TO=1860.1n

.meas tran Vdout1_76ck147 AVG v(dout1_76) FROM=1859.9n TO=1860.1n

.meas tran Vdout1_77ck147 AVG v(dout1_77) FROM=1859.9n TO=1860.1n

.meas tran Vdout1_78ck147 AVG v(dout1_78) FROM=1859.9n TO=1860.1n

.meas tran Vdout1_79ck147 AVG v(dout1_79) FROM=1859.9n TO=1860.1n

.meas tran Vdout1_0ck148 AVG v(dout1_0) FROM=1869.9n TO=1870.1n

.meas tran Vdout1_1ck148 AVG v(dout1_1) FROM=1869.9n TO=1870.1n

.meas tran Vdout1_2ck148 AVG v(dout1_2) FROM=1869.9n TO=1870.1n

.meas tran Vdout1_3ck148 AVG v(dout1_3) FROM=1869.9n TO=1870.1n

.meas tran Vdout1_4ck148 AVG v(dout1_4) FROM=1869.9n TO=1870.1n

.meas tran Vdout1_5ck148 AVG v(dout1_5) FROM=1869.9n TO=1870.1n

.meas tran Vdout1_6ck148 AVG v(dout1_6) FROM=1869.9n TO=1870.1n

.meas tran Vdout1_7ck148 AVG v(dout1_7) FROM=1869.9n TO=1870.1n

.meas tran Vdout1_8ck148 AVG v(dout1_8) FROM=1869.9n TO=1870.1n

.meas tran Vdout1_9ck148 AVG v(dout1_9) FROM=1869.9n TO=1870.1n

.meas tran Vdout1_10ck148 AVG v(dout1_10) FROM=1869.9n TO=1870.1n

.meas tran Vdout1_11ck148 AVG v(dout1_11) FROM=1869.9n TO=1870.1n

.meas tran Vdout1_12ck148 AVG v(dout1_12) FROM=1869.9n TO=1870.1n

.meas tran Vdout1_13ck148 AVG v(dout1_13) FROM=1869.9n TO=1870.1n

.meas tran Vdout1_14ck148 AVG v(dout1_14) FROM=1869.9n TO=1870.1n

.meas tran Vdout1_15ck148 AVG v(dout1_15) FROM=1869.9n TO=1870.1n

.meas tran Vdout1_16ck148 AVG v(dout1_16) FROM=1869.9n TO=1870.1n

.meas tran Vdout1_17ck148 AVG v(dout1_17) FROM=1869.9n TO=1870.1n

.meas tran Vdout1_18ck148 AVG v(dout1_18) FROM=1869.9n TO=1870.1n

.meas tran Vdout1_19ck148 AVG v(dout1_19) FROM=1869.9n TO=1870.1n

.meas tran Vdout1_20ck148 AVG v(dout1_20) FROM=1869.9n TO=1870.1n

.meas tran Vdout1_21ck148 AVG v(dout1_21) FROM=1869.9n TO=1870.1n

.meas tran Vdout1_22ck148 AVG v(dout1_22) FROM=1869.9n TO=1870.1n

.meas tran Vdout1_23ck148 AVG v(dout1_23) FROM=1869.9n TO=1870.1n

.meas tran Vdout1_24ck148 AVG v(dout1_24) FROM=1869.9n TO=1870.1n

.meas tran Vdout1_25ck148 AVG v(dout1_25) FROM=1869.9n TO=1870.1n

.meas tran Vdout1_26ck148 AVG v(dout1_26) FROM=1869.9n TO=1870.1n

.meas tran Vdout1_27ck148 AVG v(dout1_27) FROM=1869.9n TO=1870.1n

.meas tran Vdout1_28ck148 AVG v(dout1_28) FROM=1869.9n TO=1870.1n

.meas tran Vdout1_29ck148 AVG v(dout1_29) FROM=1869.9n TO=1870.1n

.meas tran Vdout1_30ck148 AVG v(dout1_30) FROM=1869.9n TO=1870.1n

.meas tran Vdout1_31ck148 AVG v(dout1_31) FROM=1869.9n TO=1870.1n

.meas tran Vdout1_32ck148 AVG v(dout1_32) FROM=1869.9n TO=1870.1n

.meas tran Vdout1_33ck148 AVG v(dout1_33) FROM=1869.9n TO=1870.1n

.meas tran Vdout1_34ck148 AVG v(dout1_34) FROM=1869.9n TO=1870.1n

.meas tran Vdout1_35ck148 AVG v(dout1_35) FROM=1869.9n TO=1870.1n

.meas tran Vdout1_36ck148 AVG v(dout1_36) FROM=1869.9n TO=1870.1n

.meas tran Vdout1_37ck148 AVG v(dout1_37) FROM=1869.9n TO=1870.1n

.meas tran Vdout1_38ck148 AVG v(dout1_38) FROM=1869.9n TO=1870.1n

.meas tran Vdout1_39ck148 AVG v(dout1_39) FROM=1869.9n TO=1870.1n

.meas tran Vdout1_40ck148 AVG v(dout1_40) FROM=1869.9n TO=1870.1n

.meas tran Vdout1_41ck148 AVG v(dout1_41) FROM=1869.9n TO=1870.1n

.meas tran Vdout1_42ck148 AVG v(dout1_42) FROM=1869.9n TO=1870.1n

.meas tran Vdout1_43ck148 AVG v(dout1_43) FROM=1869.9n TO=1870.1n

.meas tran Vdout1_44ck148 AVG v(dout1_44) FROM=1869.9n TO=1870.1n

.meas tran Vdout1_45ck148 AVG v(dout1_45) FROM=1869.9n TO=1870.1n

.meas tran Vdout1_46ck148 AVG v(dout1_46) FROM=1869.9n TO=1870.1n

.meas tran Vdout1_47ck148 AVG v(dout1_47) FROM=1869.9n TO=1870.1n

.meas tran Vdout1_48ck148 AVG v(dout1_48) FROM=1869.9n TO=1870.1n

.meas tran Vdout1_49ck148 AVG v(dout1_49) FROM=1869.9n TO=1870.1n

.meas tran Vdout1_50ck148 AVG v(dout1_50) FROM=1869.9n TO=1870.1n

.meas tran Vdout1_51ck148 AVG v(dout1_51) FROM=1869.9n TO=1870.1n

.meas tran Vdout1_52ck148 AVG v(dout1_52) FROM=1869.9n TO=1870.1n

.meas tran Vdout1_53ck148 AVG v(dout1_53) FROM=1869.9n TO=1870.1n

.meas tran Vdout1_54ck148 AVG v(dout1_54) FROM=1869.9n TO=1870.1n

.meas tran Vdout1_55ck148 AVG v(dout1_55) FROM=1869.9n TO=1870.1n

.meas tran Vdout1_56ck148 AVG v(dout1_56) FROM=1869.9n TO=1870.1n

.meas tran Vdout1_57ck148 AVG v(dout1_57) FROM=1869.9n TO=1870.1n

.meas tran Vdout1_58ck148 AVG v(dout1_58) FROM=1869.9n TO=1870.1n

.meas tran Vdout1_59ck148 AVG v(dout1_59) FROM=1869.9n TO=1870.1n

.meas tran Vdout1_60ck148 AVG v(dout1_60) FROM=1869.9n TO=1870.1n

.meas tran Vdout1_61ck148 AVG v(dout1_61) FROM=1869.9n TO=1870.1n

.meas tran Vdout1_62ck148 AVG v(dout1_62) FROM=1869.9n TO=1870.1n

.meas tran Vdout1_63ck148 AVG v(dout1_63) FROM=1869.9n TO=1870.1n

.meas tran Vdout1_64ck148 AVG v(dout1_64) FROM=1869.9n TO=1870.1n

.meas tran Vdout1_65ck148 AVG v(dout1_65) FROM=1869.9n TO=1870.1n

.meas tran Vdout1_66ck148 AVG v(dout1_66) FROM=1869.9n TO=1870.1n

.meas tran Vdout1_67ck148 AVG v(dout1_67) FROM=1869.9n TO=1870.1n

.meas tran Vdout1_68ck148 AVG v(dout1_68) FROM=1869.9n TO=1870.1n

.meas tran Vdout1_69ck148 AVG v(dout1_69) FROM=1869.9n TO=1870.1n

.meas tran Vdout1_70ck148 AVG v(dout1_70) FROM=1869.9n TO=1870.1n

.meas tran Vdout1_71ck148 AVG v(dout1_71) FROM=1869.9n TO=1870.1n

.meas tran Vdout1_72ck148 AVG v(dout1_72) FROM=1869.9n TO=1870.1n

.meas tran Vdout1_73ck148 AVG v(dout1_73) FROM=1869.9n TO=1870.1n

.meas tran Vdout1_74ck148 AVG v(dout1_74) FROM=1869.9n TO=1870.1n

.meas tran Vdout1_75ck148 AVG v(dout1_75) FROM=1869.9n TO=1870.1n

.meas tran Vdout1_76ck148 AVG v(dout1_76) FROM=1869.9n TO=1870.1n

.meas tran Vdout1_77ck148 AVG v(dout1_77) FROM=1869.9n TO=1870.1n

.meas tran Vdout1_78ck148 AVG v(dout1_78) FROM=1869.9n TO=1870.1n

.meas tran Vdout1_79ck148 AVG v(dout1_79) FROM=1869.9n TO=1870.1n

.meas tran Vdout1_0ck149 AVG v(dout1_0) FROM=1879.9n TO=1880.1n

.meas tran Vdout1_1ck149 AVG v(dout1_1) FROM=1879.9n TO=1880.1n

.meas tran Vdout1_2ck149 AVG v(dout1_2) FROM=1879.9n TO=1880.1n

.meas tran Vdout1_3ck149 AVG v(dout1_3) FROM=1879.9n TO=1880.1n

.meas tran Vdout1_4ck149 AVG v(dout1_4) FROM=1879.9n TO=1880.1n

.meas tran Vdout1_5ck149 AVG v(dout1_5) FROM=1879.9n TO=1880.1n

.meas tran Vdout1_6ck149 AVG v(dout1_6) FROM=1879.9n TO=1880.1n

.meas tran Vdout1_7ck149 AVG v(dout1_7) FROM=1879.9n TO=1880.1n

.meas tran Vdout1_8ck149 AVG v(dout1_8) FROM=1879.9n TO=1880.1n

.meas tran Vdout1_9ck149 AVG v(dout1_9) FROM=1879.9n TO=1880.1n

.meas tran Vdout1_10ck149 AVG v(dout1_10) FROM=1879.9n TO=1880.1n

.meas tran Vdout1_11ck149 AVG v(dout1_11) FROM=1879.9n TO=1880.1n

.meas tran Vdout1_12ck149 AVG v(dout1_12) FROM=1879.9n TO=1880.1n

.meas tran Vdout1_13ck149 AVG v(dout1_13) FROM=1879.9n TO=1880.1n

.meas tran Vdout1_14ck149 AVG v(dout1_14) FROM=1879.9n TO=1880.1n

.meas tran Vdout1_15ck149 AVG v(dout1_15) FROM=1879.9n TO=1880.1n

.meas tran Vdout1_16ck149 AVG v(dout1_16) FROM=1879.9n TO=1880.1n

.meas tran Vdout1_17ck149 AVG v(dout1_17) FROM=1879.9n TO=1880.1n

.meas tran Vdout1_18ck149 AVG v(dout1_18) FROM=1879.9n TO=1880.1n

.meas tran Vdout1_19ck149 AVG v(dout1_19) FROM=1879.9n TO=1880.1n

.meas tran Vdout1_20ck149 AVG v(dout1_20) FROM=1879.9n TO=1880.1n

.meas tran Vdout1_21ck149 AVG v(dout1_21) FROM=1879.9n TO=1880.1n

.meas tran Vdout1_22ck149 AVG v(dout1_22) FROM=1879.9n TO=1880.1n

.meas tran Vdout1_23ck149 AVG v(dout1_23) FROM=1879.9n TO=1880.1n

.meas tran Vdout1_24ck149 AVG v(dout1_24) FROM=1879.9n TO=1880.1n

.meas tran Vdout1_25ck149 AVG v(dout1_25) FROM=1879.9n TO=1880.1n

.meas tran Vdout1_26ck149 AVG v(dout1_26) FROM=1879.9n TO=1880.1n

.meas tran Vdout1_27ck149 AVG v(dout1_27) FROM=1879.9n TO=1880.1n

.meas tran Vdout1_28ck149 AVG v(dout1_28) FROM=1879.9n TO=1880.1n

.meas tran Vdout1_29ck149 AVG v(dout1_29) FROM=1879.9n TO=1880.1n

.meas tran Vdout1_30ck149 AVG v(dout1_30) FROM=1879.9n TO=1880.1n

.meas tran Vdout1_31ck149 AVG v(dout1_31) FROM=1879.9n TO=1880.1n

.meas tran Vdout1_32ck149 AVG v(dout1_32) FROM=1879.9n TO=1880.1n

.meas tran Vdout1_33ck149 AVG v(dout1_33) FROM=1879.9n TO=1880.1n

.meas tran Vdout1_34ck149 AVG v(dout1_34) FROM=1879.9n TO=1880.1n

.meas tran Vdout1_35ck149 AVG v(dout1_35) FROM=1879.9n TO=1880.1n

.meas tran Vdout1_36ck149 AVG v(dout1_36) FROM=1879.9n TO=1880.1n

.meas tran Vdout1_37ck149 AVG v(dout1_37) FROM=1879.9n TO=1880.1n

.meas tran Vdout1_38ck149 AVG v(dout1_38) FROM=1879.9n TO=1880.1n

.meas tran Vdout1_39ck149 AVG v(dout1_39) FROM=1879.9n TO=1880.1n

.meas tran Vdout1_40ck149 AVG v(dout1_40) FROM=1879.9n TO=1880.1n

.meas tran Vdout1_41ck149 AVG v(dout1_41) FROM=1879.9n TO=1880.1n

.meas tran Vdout1_42ck149 AVG v(dout1_42) FROM=1879.9n TO=1880.1n

.meas tran Vdout1_43ck149 AVG v(dout1_43) FROM=1879.9n TO=1880.1n

.meas tran Vdout1_44ck149 AVG v(dout1_44) FROM=1879.9n TO=1880.1n

.meas tran Vdout1_45ck149 AVG v(dout1_45) FROM=1879.9n TO=1880.1n

.meas tran Vdout1_46ck149 AVG v(dout1_46) FROM=1879.9n TO=1880.1n

.meas tran Vdout1_47ck149 AVG v(dout1_47) FROM=1879.9n TO=1880.1n

.meas tran Vdout1_48ck149 AVG v(dout1_48) FROM=1879.9n TO=1880.1n

.meas tran Vdout1_49ck149 AVG v(dout1_49) FROM=1879.9n TO=1880.1n

.meas tran Vdout1_50ck149 AVG v(dout1_50) FROM=1879.9n TO=1880.1n

.meas tran Vdout1_51ck149 AVG v(dout1_51) FROM=1879.9n TO=1880.1n

.meas tran Vdout1_52ck149 AVG v(dout1_52) FROM=1879.9n TO=1880.1n

.meas tran Vdout1_53ck149 AVG v(dout1_53) FROM=1879.9n TO=1880.1n

.meas tran Vdout1_54ck149 AVG v(dout1_54) FROM=1879.9n TO=1880.1n

.meas tran Vdout1_55ck149 AVG v(dout1_55) FROM=1879.9n TO=1880.1n

.meas tran Vdout1_56ck149 AVG v(dout1_56) FROM=1879.9n TO=1880.1n

.meas tran Vdout1_57ck149 AVG v(dout1_57) FROM=1879.9n TO=1880.1n

.meas tran Vdout1_58ck149 AVG v(dout1_58) FROM=1879.9n TO=1880.1n

.meas tran Vdout1_59ck149 AVG v(dout1_59) FROM=1879.9n TO=1880.1n

.meas tran Vdout1_60ck149 AVG v(dout1_60) FROM=1879.9n TO=1880.1n

.meas tran Vdout1_61ck149 AVG v(dout1_61) FROM=1879.9n TO=1880.1n

.meas tran Vdout1_62ck149 AVG v(dout1_62) FROM=1879.9n TO=1880.1n

.meas tran Vdout1_63ck149 AVG v(dout1_63) FROM=1879.9n TO=1880.1n

.meas tran Vdout1_64ck149 AVG v(dout1_64) FROM=1879.9n TO=1880.1n

.meas tran Vdout1_65ck149 AVG v(dout1_65) FROM=1879.9n TO=1880.1n

.meas tran Vdout1_66ck149 AVG v(dout1_66) FROM=1879.9n TO=1880.1n

.meas tran Vdout1_67ck149 AVG v(dout1_67) FROM=1879.9n TO=1880.1n

.meas tran Vdout1_68ck149 AVG v(dout1_68) FROM=1879.9n TO=1880.1n

.meas tran Vdout1_69ck149 AVG v(dout1_69) FROM=1879.9n TO=1880.1n

.meas tran Vdout1_70ck149 AVG v(dout1_70) FROM=1879.9n TO=1880.1n

.meas tran Vdout1_71ck149 AVG v(dout1_71) FROM=1879.9n TO=1880.1n

.meas tran Vdout1_72ck149 AVG v(dout1_72) FROM=1879.9n TO=1880.1n

.meas tran Vdout1_73ck149 AVG v(dout1_73) FROM=1879.9n TO=1880.1n

.meas tran Vdout1_74ck149 AVG v(dout1_74) FROM=1879.9n TO=1880.1n

.meas tran Vdout1_75ck149 AVG v(dout1_75) FROM=1879.9n TO=1880.1n

.meas tran Vdout1_76ck149 AVG v(dout1_76) FROM=1879.9n TO=1880.1n

.meas tran Vdout1_77ck149 AVG v(dout1_77) FROM=1879.9n TO=1880.1n

.meas tran Vdout1_78ck149 AVG v(dout1_78) FROM=1879.9n TO=1880.1n

.meas tran Vdout1_79ck149 AVG v(dout1_79) FROM=1879.9n TO=1880.1n

.meas tran Vdout0_0ck150 AVG v(dout0_0) FROM=1919.9n TO=1920.1n

.meas tran Vdout0_1ck150 AVG v(dout0_1) FROM=1919.9n TO=1920.1n

.meas tran Vdout0_2ck150 AVG v(dout0_2) FROM=1919.9n TO=1920.1n

.meas tran Vdout0_3ck150 AVG v(dout0_3) FROM=1919.9n TO=1920.1n

.meas tran Vdout0_4ck150 AVG v(dout0_4) FROM=1919.9n TO=1920.1n

.meas tran Vdout0_5ck150 AVG v(dout0_5) FROM=1919.9n TO=1920.1n

.meas tran Vdout0_6ck150 AVG v(dout0_6) FROM=1919.9n TO=1920.1n

.meas tran Vdout0_7ck150 AVG v(dout0_7) FROM=1919.9n TO=1920.1n

.meas tran Vdout0_8ck150 AVG v(dout0_8) FROM=1919.9n TO=1920.1n

.meas tran Vdout0_9ck150 AVG v(dout0_9) FROM=1919.9n TO=1920.1n

.meas tran Vdout0_10ck150 AVG v(dout0_10) FROM=1919.9n TO=1920.1n

.meas tran Vdout0_11ck150 AVG v(dout0_11) FROM=1919.9n TO=1920.1n

.meas tran Vdout0_12ck150 AVG v(dout0_12) FROM=1919.9n TO=1920.1n

.meas tran Vdout0_13ck150 AVG v(dout0_13) FROM=1919.9n TO=1920.1n

.meas tran Vdout0_14ck150 AVG v(dout0_14) FROM=1919.9n TO=1920.1n

.meas tran Vdout0_15ck150 AVG v(dout0_15) FROM=1919.9n TO=1920.1n

.meas tran Vdout0_16ck150 AVG v(dout0_16) FROM=1919.9n TO=1920.1n

.meas tran Vdout0_17ck150 AVG v(dout0_17) FROM=1919.9n TO=1920.1n

.meas tran Vdout0_18ck150 AVG v(dout0_18) FROM=1919.9n TO=1920.1n

.meas tran Vdout0_19ck150 AVG v(dout0_19) FROM=1919.9n TO=1920.1n

.meas tran Vdout0_20ck150 AVG v(dout0_20) FROM=1919.9n TO=1920.1n

.meas tran Vdout0_21ck150 AVG v(dout0_21) FROM=1919.9n TO=1920.1n

.meas tran Vdout0_22ck150 AVG v(dout0_22) FROM=1919.9n TO=1920.1n

.meas tran Vdout0_23ck150 AVG v(dout0_23) FROM=1919.9n TO=1920.1n

.meas tran Vdout0_24ck150 AVG v(dout0_24) FROM=1919.9n TO=1920.1n

.meas tran Vdout0_25ck150 AVG v(dout0_25) FROM=1919.9n TO=1920.1n

.meas tran Vdout0_26ck150 AVG v(dout0_26) FROM=1919.9n TO=1920.1n

.meas tran Vdout0_27ck150 AVG v(dout0_27) FROM=1919.9n TO=1920.1n

.meas tran Vdout0_28ck150 AVG v(dout0_28) FROM=1919.9n TO=1920.1n

.meas tran Vdout0_29ck150 AVG v(dout0_29) FROM=1919.9n TO=1920.1n

.meas tran Vdout0_30ck150 AVG v(dout0_30) FROM=1919.9n TO=1920.1n

.meas tran Vdout0_31ck150 AVG v(dout0_31) FROM=1919.9n TO=1920.1n

.meas tran Vdout0_32ck150 AVG v(dout0_32) FROM=1919.9n TO=1920.1n

.meas tran Vdout0_33ck150 AVG v(dout0_33) FROM=1919.9n TO=1920.1n

.meas tran Vdout0_34ck150 AVG v(dout0_34) FROM=1919.9n TO=1920.1n

.meas tran Vdout0_35ck150 AVG v(dout0_35) FROM=1919.9n TO=1920.1n

.meas tran Vdout0_36ck150 AVG v(dout0_36) FROM=1919.9n TO=1920.1n

.meas tran Vdout0_37ck150 AVG v(dout0_37) FROM=1919.9n TO=1920.1n

.meas tran Vdout0_38ck150 AVG v(dout0_38) FROM=1919.9n TO=1920.1n

.meas tran Vdout0_39ck150 AVG v(dout0_39) FROM=1919.9n TO=1920.1n

.meas tran Vdout0_40ck150 AVG v(dout0_40) FROM=1919.9n TO=1920.1n

.meas tran Vdout0_41ck150 AVG v(dout0_41) FROM=1919.9n TO=1920.1n

.meas tran Vdout0_42ck150 AVG v(dout0_42) FROM=1919.9n TO=1920.1n

.meas tran Vdout0_43ck150 AVG v(dout0_43) FROM=1919.9n TO=1920.1n

.meas tran Vdout0_44ck150 AVG v(dout0_44) FROM=1919.9n TO=1920.1n

.meas tran Vdout0_45ck150 AVG v(dout0_45) FROM=1919.9n TO=1920.1n

.meas tran Vdout0_46ck150 AVG v(dout0_46) FROM=1919.9n TO=1920.1n

.meas tran Vdout0_47ck150 AVG v(dout0_47) FROM=1919.9n TO=1920.1n

.meas tran Vdout0_48ck150 AVG v(dout0_48) FROM=1919.9n TO=1920.1n

.meas tran Vdout0_49ck150 AVG v(dout0_49) FROM=1919.9n TO=1920.1n

.meas tran Vdout0_50ck150 AVG v(dout0_50) FROM=1919.9n TO=1920.1n

.meas tran Vdout0_51ck150 AVG v(dout0_51) FROM=1919.9n TO=1920.1n

.meas tran Vdout0_52ck150 AVG v(dout0_52) FROM=1919.9n TO=1920.1n

.meas tran Vdout0_53ck150 AVG v(dout0_53) FROM=1919.9n TO=1920.1n

.meas tran Vdout0_54ck150 AVG v(dout0_54) FROM=1919.9n TO=1920.1n

.meas tran Vdout0_55ck150 AVG v(dout0_55) FROM=1919.9n TO=1920.1n

.meas tran Vdout0_56ck150 AVG v(dout0_56) FROM=1919.9n TO=1920.1n

.meas tran Vdout0_57ck150 AVG v(dout0_57) FROM=1919.9n TO=1920.1n

.meas tran Vdout0_58ck150 AVG v(dout0_58) FROM=1919.9n TO=1920.1n

.meas tran Vdout0_59ck150 AVG v(dout0_59) FROM=1919.9n TO=1920.1n

.meas tran Vdout0_60ck150 AVG v(dout0_60) FROM=1919.9n TO=1920.1n

.meas tran Vdout0_61ck150 AVG v(dout0_61) FROM=1919.9n TO=1920.1n

.meas tran Vdout0_62ck150 AVG v(dout0_62) FROM=1919.9n TO=1920.1n

.meas tran Vdout0_63ck150 AVG v(dout0_63) FROM=1919.9n TO=1920.1n

.meas tran Vdout0_64ck150 AVG v(dout0_64) FROM=1919.9n TO=1920.1n

.meas tran Vdout0_65ck150 AVG v(dout0_65) FROM=1919.9n TO=1920.1n

.meas tran Vdout0_66ck150 AVG v(dout0_66) FROM=1919.9n TO=1920.1n

.meas tran Vdout0_67ck150 AVG v(dout0_67) FROM=1919.9n TO=1920.1n

.meas tran Vdout0_68ck150 AVG v(dout0_68) FROM=1919.9n TO=1920.1n

.meas tran Vdout0_69ck150 AVG v(dout0_69) FROM=1919.9n TO=1920.1n

.meas tran Vdout0_70ck150 AVG v(dout0_70) FROM=1919.9n TO=1920.1n

.meas tran Vdout0_71ck150 AVG v(dout0_71) FROM=1919.9n TO=1920.1n

.meas tran Vdout0_72ck150 AVG v(dout0_72) FROM=1919.9n TO=1920.1n

.meas tran Vdout0_73ck150 AVG v(dout0_73) FROM=1919.9n TO=1920.1n

.meas tran Vdout0_74ck150 AVG v(dout0_74) FROM=1919.9n TO=1920.1n

.meas tran Vdout0_75ck150 AVG v(dout0_75) FROM=1919.9n TO=1920.1n

.meas tran Vdout0_76ck150 AVG v(dout0_76) FROM=1919.9n TO=1920.1n

.meas tran Vdout0_77ck150 AVG v(dout0_77) FROM=1919.9n TO=1920.1n

.meas tran Vdout0_78ck150 AVG v(dout0_78) FROM=1919.9n TO=1920.1n

.meas tran Vdout0_79ck150 AVG v(dout0_79) FROM=1919.9n TO=1920.1n

.meas tran Vdout1_0ck151 AVG v(dout1_0) FROM=1929.9n TO=1930.1n

.meas tran Vdout1_1ck151 AVG v(dout1_1) FROM=1929.9n TO=1930.1n

.meas tran Vdout1_2ck151 AVG v(dout1_2) FROM=1929.9n TO=1930.1n

.meas tran Vdout1_3ck151 AVG v(dout1_3) FROM=1929.9n TO=1930.1n

.meas tran Vdout1_4ck151 AVG v(dout1_4) FROM=1929.9n TO=1930.1n

.meas tran Vdout1_5ck151 AVG v(dout1_5) FROM=1929.9n TO=1930.1n

.meas tran Vdout1_6ck151 AVG v(dout1_6) FROM=1929.9n TO=1930.1n

.meas tran Vdout1_7ck151 AVG v(dout1_7) FROM=1929.9n TO=1930.1n

.meas tran Vdout1_8ck151 AVG v(dout1_8) FROM=1929.9n TO=1930.1n

.meas tran Vdout1_9ck151 AVG v(dout1_9) FROM=1929.9n TO=1930.1n

.meas tran Vdout1_10ck151 AVG v(dout1_10) FROM=1929.9n TO=1930.1n

.meas tran Vdout1_11ck151 AVG v(dout1_11) FROM=1929.9n TO=1930.1n

.meas tran Vdout1_12ck151 AVG v(dout1_12) FROM=1929.9n TO=1930.1n

.meas tran Vdout1_13ck151 AVG v(dout1_13) FROM=1929.9n TO=1930.1n

.meas tran Vdout1_14ck151 AVG v(dout1_14) FROM=1929.9n TO=1930.1n

.meas tran Vdout1_15ck151 AVG v(dout1_15) FROM=1929.9n TO=1930.1n

.meas tran Vdout1_16ck151 AVG v(dout1_16) FROM=1929.9n TO=1930.1n

.meas tran Vdout1_17ck151 AVG v(dout1_17) FROM=1929.9n TO=1930.1n

.meas tran Vdout1_18ck151 AVG v(dout1_18) FROM=1929.9n TO=1930.1n

.meas tran Vdout1_19ck151 AVG v(dout1_19) FROM=1929.9n TO=1930.1n

.meas tran Vdout1_20ck151 AVG v(dout1_20) FROM=1929.9n TO=1930.1n

.meas tran Vdout1_21ck151 AVG v(dout1_21) FROM=1929.9n TO=1930.1n

.meas tran Vdout1_22ck151 AVG v(dout1_22) FROM=1929.9n TO=1930.1n

.meas tran Vdout1_23ck151 AVG v(dout1_23) FROM=1929.9n TO=1930.1n

.meas tran Vdout1_24ck151 AVG v(dout1_24) FROM=1929.9n TO=1930.1n

.meas tran Vdout1_25ck151 AVG v(dout1_25) FROM=1929.9n TO=1930.1n

.meas tran Vdout1_26ck151 AVG v(dout1_26) FROM=1929.9n TO=1930.1n

.meas tran Vdout1_27ck151 AVG v(dout1_27) FROM=1929.9n TO=1930.1n

.meas tran Vdout1_28ck151 AVG v(dout1_28) FROM=1929.9n TO=1930.1n

.meas tran Vdout1_29ck151 AVG v(dout1_29) FROM=1929.9n TO=1930.1n

.meas tran Vdout1_30ck151 AVG v(dout1_30) FROM=1929.9n TO=1930.1n

.meas tran Vdout1_31ck151 AVG v(dout1_31) FROM=1929.9n TO=1930.1n

.meas tran Vdout1_32ck151 AVG v(dout1_32) FROM=1929.9n TO=1930.1n

.meas tran Vdout1_33ck151 AVG v(dout1_33) FROM=1929.9n TO=1930.1n

.meas tran Vdout1_34ck151 AVG v(dout1_34) FROM=1929.9n TO=1930.1n

.meas tran Vdout1_35ck151 AVG v(dout1_35) FROM=1929.9n TO=1930.1n

.meas tran Vdout1_36ck151 AVG v(dout1_36) FROM=1929.9n TO=1930.1n

.meas tran Vdout1_37ck151 AVG v(dout1_37) FROM=1929.9n TO=1930.1n

.meas tran Vdout1_38ck151 AVG v(dout1_38) FROM=1929.9n TO=1930.1n

.meas tran Vdout1_39ck151 AVG v(dout1_39) FROM=1929.9n TO=1930.1n

.meas tran Vdout1_40ck151 AVG v(dout1_40) FROM=1929.9n TO=1930.1n

.meas tran Vdout1_41ck151 AVG v(dout1_41) FROM=1929.9n TO=1930.1n

.meas tran Vdout1_42ck151 AVG v(dout1_42) FROM=1929.9n TO=1930.1n

.meas tran Vdout1_43ck151 AVG v(dout1_43) FROM=1929.9n TO=1930.1n

.meas tran Vdout1_44ck151 AVG v(dout1_44) FROM=1929.9n TO=1930.1n

.meas tran Vdout1_45ck151 AVG v(dout1_45) FROM=1929.9n TO=1930.1n

.meas tran Vdout1_46ck151 AVG v(dout1_46) FROM=1929.9n TO=1930.1n

.meas tran Vdout1_47ck151 AVG v(dout1_47) FROM=1929.9n TO=1930.1n

.meas tran Vdout1_48ck151 AVG v(dout1_48) FROM=1929.9n TO=1930.1n

.meas tran Vdout1_49ck151 AVG v(dout1_49) FROM=1929.9n TO=1930.1n

.meas tran Vdout1_50ck151 AVG v(dout1_50) FROM=1929.9n TO=1930.1n

.meas tran Vdout1_51ck151 AVG v(dout1_51) FROM=1929.9n TO=1930.1n

.meas tran Vdout1_52ck151 AVG v(dout1_52) FROM=1929.9n TO=1930.1n

.meas tran Vdout1_53ck151 AVG v(dout1_53) FROM=1929.9n TO=1930.1n

.meas tran Vdout1_54ck151 AVG v(dout1_54) FROM=1929.9n TO=1930.1n

.meas tran Vdout1_55ck151 AVG v(dout1_55) FROM=1929.9n TO=1930.1n

.meas tran Vdout1_56ck151 AVG v(dout1_56) FROM=1929.9n TO=1930.1n

.meas tran Vdout1_57ck151 AVG v(dout1_57) FROM=1929.9n TO=1930.1n

.meas tran Vdout1_58ck151 AVG v(dout1_58) FROM=1929.9n TO=1930.1n

.meas tran Vdout1_59ck151 AVG v(dout1_59) FROM=1929.9n TO=1930.1n

.meas tran Vdout1_60ck151 AVG v(dout1_60) FROM=1929.9n TO=1930.1n

.meas tran Vdout1_61ck151 AVG v(dout1_61) FROM=1929.9n TO=1930.1n

.meas tran Vdout1_62ck151 AVG v(dout1_62) FROM=1929.9n TO=1930.1n

.meas tran Vdout1_63ck151 AVG v(dout1_63) FROM=1929.9n TO=1930.1n

.meas tran Vdout1_64ck151 AVG v(dout1_64) FROM=1929.9n TO=1930.1n

.meas tran Vdout1_65ck151 AVG v(dout1_65) FROM=1929.9n TO=1930.1n

.meas tran Vdout1_66ck151 AVG v(dout1_66) FROM=1929.9n TO=1930.1n

.meas tran Vdout1_67ck151 AVG v(dout1_67) FROM=1929.9n TO=1930.1n

.meas tran Vdout1_68ck151 AVG v(dout1_68) FROM=1929.9n TO=1930.1n

.meas tran Vdout1_69ck151 AVG v(dout1_69) FROM=1929.9n TO=1930.1n

.meas tran Vdout1_70ck151 AVG v(dout1_70) FROM=1929.9n TO=1930.1n

.meas tran Vdout1_71ck151 AVG v(dout1_71) FROM=1929.9n TO=1930.1n

.meas tran Vdout1_72ck151 AVG v(dout1_72) FROM=1929.9n TO=1930.1n

.meas tran Vdout1_73ck151 AVG v(dout1_73) FROM=1929.9n TO=1930.1n

.meas tran Vdout1_74ck151 AVG v(dout1_74) FROM=1929.9n TO=1930.1n

.meas tran Vdout1_75ck151 AVG v(dout1_75) FROM=1929.9n TO=1930.1n

.meas tran Vdout1_76ck151 AVG v(dout1_76) FROM=1929.9n TO=1930.1n

.meas tran Vdout1_77ck151 AVG v(dout1_77) FROM=1929.9n TO=1930.1n

.meas tran Vdout1_78ck151 AVG v(dout1_78) FROM=1929.9n TO=1930.1n

.meas tran Vdout1_79ck151 AVG v(dout1_79) FROM=1929.9n TO=1930.1n

.meas tran Vdout1_0ck152 AVG v(dout1_0) FROM=1939.9n TO=1940.1n

.meas tran Vdout1_1ck152 AVG v(dout1_1) FROM=1939.9n TO=1940.1n

.meas tran Vdout1_2ck152 AVG v(dout1_2) FROM=1939.9n TO=1940.1n

.meas tran Vdout1_3ck152 AVG v(dout1_3) FROM=1939.9n TO=1940.1n

.meas tran Vdout1_4ck152 AVG v(dout1_4) FROM=1939.9n TO=1940.1n

.meas tran Vdout1_5ck152 AVG v(dout1_5) FROM=1939.9n TO=1940.1n

.meas tran Vdout1_6ck152 AVG v(dout1_6) FROM=1939.9n TO=1940.1n

.meas tran Vdout1_7ck152 AVG v(dout1_7) FROM=1939.9n TO=1940.1n

.meas tran Vdout1_8ck152 AVG v(dout1_8) FROM=1939.9n TO=1940.1n

.meas tran Vdout1_9ck152 AVG v(dout1_9) FROM=1939.9n TO=1940.1n

.meas tran Vdout1_10ck152 AVG v(dout1_10) FROM=1939.9n TO=1940.1n

.meas tran Vdout1_11ck152 AVG v(dout1_11) FROM=1939.9n TO=1940.1n

.meas tran Vdout1_12ck152 AVG v(dout1_12) FROM=1939.9n TO=1940.1n

.meas tran Vdout1_13ck152 AVG v(dout1_13) FROM=1939.9n TO=1940.1n

.meas tran Vdout1_14ck152 AVG v(dout1_14) FROM=1939.9n TO=1940.1n

.meas tran Vdout1_15ck152 AVG v(dout1_15) FROM=1939.9n TO=1940.1n

.meas tran Vdout1_16ck152 AVG v(dout1_16) FROM=1939.9n TO=1940.1n

.meas tran Vdout1_17ck152 AVG v(dout1_17) FROM=1939.9n TO=1940.1n

.meas tran Vdout1_18ck152 AVG v(dout1_18) FROM=1939.9n TO=1940.1n

.meas tran Vdout1_19ck152 AVG v(dout1_19) FROM=1939.9n TO=1940.1n

.meas tran Vdout1_20ck152 AVG v(dout1_20) FROM=1939.9n TO=1940.1n

.meas tran Vdout1_21ck152 AVG v(dout1_21) FROM=1939.9n TO=1940.1n

.meas tran Vdout1_22ck152 AVG v(dout1_22) FROM=1939.9n TO=1940.1n

.meas tran Vdout1_23ck152 AVG v(dout1_23) FROM=1939.9n TO=1940.1n

.meas tran Vdout1_24ck152 AVG v(dout1_24) FROM=1939.9n TO=1940.1n

.meas tran Vdout1_25ck152 AVG v(dout1_25) FROM=1939.9n TO=1940.1n

.meas tran Vdout1_26ck152 AVG v(dout1_26) FROM=1939.9n TO=1940.1n

.meas tran Vdout1_27ck152 AVG v(dout1_27) FROM=1939.9n TO=1940.1n

.meas tran Vdout1_28ck152 AVG v(dout1_28) FROM=1939.9n TO=1940.1n

.meas tran Vdout1_29ck152 AVG v(dout1_29) FROM=1939.9n TO=1940.1n

.meas tran Vdout1_30ck152 AVG v(dout1_30) FROM=1939.9n TO=1940.1n

.meas tran Vdout1_31ck152 AVG v(dout1_31) FROM=1939.9n TO=1940.1n

.meas tran Vdout1_32ck152 AVG v(dout1_32) FROM=1939.9n TO=1940.1n

.meas tran Vdout1_33ck152 AVG v(dout1_33) FROM=1939.9n TO=1940.1n

.meas tran Vdout1_34ck152 AVG v(dout1_34) FROM=1939.9n TO=1940.1n

.meas tran Vdout1_35ck152 AVG v(dout1_35) FROM=1939.9n TO=1940.1n

.meas tran Vdout1_36ck152 AVG v(dout1_36) FROM=1939.9n TO=1940.1n

.meas tran Vdout1_37ck152 AVG v(dout1_37) FROM=1939.9n TO=1940.1n

.meas tran Vdout1_38ck152 AVG v(dout1_38) FROM=1939.9n TO=1940.1n

.meas tran Vdout1_39ck152 AVG v(dout1_39) FROM=1939.9n TO=1940.1n

.meas tran Vdout1_40ck152 AVG v(dout1_40) FROM=1939.9n TO=1940.1n

.meas tran Vdout1_41ck152 AVG v(dout1_41) FROM=1939.9n TO=1940.1n

.meas tran Vdout1_42ck152 AVG v(dout1_42) FROM=1939.9n TO=1940.1n

.meas tran Vdout1_43ck152 AVG v(dout1_43) FROM=1939.9n TO=1940.1n

.meas tran Vdout1_44ck152 AVG v(dout1_44) FROM=1939.9n TO=1940.1n

.meas tran Vdout1_45ck152 AVG v(dout1_45) FROM=1939.9n TO=1940.1n

.meas tran Vdout1_46ck152 AVG v(dout1_46) FROM=1939.9n TO=1940.1n

.meas tran Vdout1_47ck152 AVG v(dout1_47) FROM=1939.9n TO=1940.1n

.meas tran Vdout1_48ck152 AVG v(dout1_48) FROM=1939.9n TO=1940.1n

.meas tran Vdout1_49ck152 AVG v(dout1_49) FROM=1939.9n TO=1940.1n

.meas tran Vdout1_50ck152 AVG v(dout1_50) FROM=1939.9n TO=1940.1n

.meas tran Vdout1_51ck152 AVG v(dout1_51) FROM=1939.9n TO=1940.1n

.meas tran Vdout1_52ck152 AVG v(dout1_52) FROM=1939.9n TO=1940.1n

.meas tran Vdout1_53ck152 AVG v(dout1_53) FROM=1939.9n TO=1940.1n

.meas tran Vdout1_54ck152 AVG v(dout1_54) FROM=1939.9n TO=1940.1n

.meas tran Vdout1_55ck152 AVG v(dout1_55) FROM=1939.9n TO=1940.1n

.meas tran Vdout1_56ck152 AVG v(dout1_56) FROM=1939.9n TO=1940.1n

.meas tran Vdout1_57ck152 AVG v(dout1_57) FROM=1939.9n TO=1940.1n

.meas tran Vdout1_58ck152 AVG v(dout1_58) FROM=1939.9n TO=1940.1n

.meas tran Vdout1_59ck152 AVG v(dout1_59) FROM=1939.9n TO=1940.1n

.meas tran Vdout1_60ck152 AVG v(dout1_60) FROM=1939.9n TO=1940.1n

.meas tran Vdout1_61ck152 AVG v(dout1_61) FROM=1939.9n TO=1940.1n

.meas tran Vdout1_62ck152 AVG v(dout1_62) FROM=1939.9n TO=1940.1n

.meas tran Vdout1_63ck152 AVG v(dout1_63) FROM=1939.9n TO=1940.1n

.meas tran Vdout1_64ck152 AVG v(dout1_64) FROM=1939.9n TO=1940.1n

.meas tran Vdout1_65ck152 AVG v(dout1_65) FROM=1939.9n TO=1940.1n

.meas tran Vdout1_66ck152 AVG v(dout1_66) FROM=1939.9n TO=1940.1n

.meas tran Vdout1_67ck152 AVG v(dout1_67) FROM=1939.9n TO=1940.1n

.meas tran Vdout1_68ck152 AVG v(dout1_68) FROM=1939.9n TO=1940.1n

.meas tran Vdout1_69ck152 AVG v(dout1_69) FROM=1939.9n TO=1940.1n

.meas tran Vdout1_70ck152 AVG v(dout1_70) FROM=1939.9n TO=1940.1n

.meas tran Vdout1_71ck152 AVG v(dout1_71) FROM=1939.9n TO=1940.1n

.meas tran Vdout1_72ck152 AVG v(dout1_72) FROM=1939.9n TO=1940.1n

.meas tran Vdout1_73ck152 AVG v(dout1_73) FROM=1939.9n TO=1940.1n

.meas tran Vdout1_74ck152 AVG v(dout1_74) FROM=1939.9n TO=1940.1n

.meas tran Vdout1_75ck152 AVG v(dout1_75) FROM=1939.9n TO=1940.1n

.meas tran Vdout1_76ck152 AVG v(dout1_76) FROM=1939.9n TO=1940.1n

.meas tran Vdout1_77ck152 AVG v(dout1_77) FROM=1939.9n TO=1940.1n

.meas tran Vdout1_78ck152 AVG v(dout1_78) FROM=1939.9n TO=1940.1n

.meas tran Vdout1_79ck152 AVG v(dout1_79) FROM=1939.9n TO=1940.1n

.meas tran Vdout0_0ck153 AVG v(dout0_0) FROM=1949.9n TO=1950.1n

.meas tran Vdout0_1ck153 AVG v(dout0_1) FROM=1949.9n TO=1950.1n

.meas tran Vdout0_2ck153 AVG v(dout0_2) FROM=1949.9n TO=1950.1n

.meas tran Vdout0_3ck153 AVG v(dout0_3) FROM=1949.9n TO=1950.1n

.meas tran Vdout0_4ck153 AVG v(dout0_4) FROM=1949.9n TO=1950.1n

.meas tran Vdout0_5ck153 AVG v(dout0_5) FROM=1949.9n TO=1950.1n

.meas tran Vdout0_6ck153 AVG v(dout0_6) FROM=1949.9n TO=1950.1n

.meas tran Vdout0_7ck153 AVG v(dout0_7) FROM=1949.9n TO=1950.1n

.meas tran Vdout0_8ck153 AVG v(dout0_8) FROM=1949.9n TO=1950.1n

.meas tran Vdout0_9ck153 AVG v(dout0_9) FROM=1949.9n TO=1950.1n

.meas tran Vdout0_10ck153 AVG v(dout0_10) FROM=1949.9n TO=1950.1n

.meas tran Vdout0_11ck153 AVG v(dout0_11) FROM=1949.9n TO=1950.1n

.meas tran Vdout0_12ck153 AVG v(dout0_12) FROM=1949.9n TO=1950.1n

.meas tran Vdout0_13ck153 AVG v(dout0_13) FROM=1949.9n TO=1950.1n

.meas tran Vdout0_14ck153 AVG v(dout0_14) FROM=1949.9n TO=1950.1n

.meas tran Vdout0_15ck153 AVG v(dout0_15) FROM=1949.9n TO=1950.1n

.meas tran Vdout0_16ck153 AVG v(dout0_16) FROM=1949.9n TO=1950.1n

.meas tran Vdout0_17ck153 AVG v(dout0_17) FROM=1949.9n TO=1950.1n

.meas tran Vdout0_18ck153 AVG v(dout0_18) FROM=1949.9n TO=1950.1n

.meas tran Vdout0_19ck153 AVG v(dout0_19) FROM=1949.9n TO=1950.1n

.meas tran Vdout0_20ck153 AVG v(dout0_20) FROM=1949.9n TO=1950.1n

.meas tran Vdout0_21ck153 AVG v(dout0_21) FROM=1949.9n TO=1950.1n

.meas tran Vdout0_22ck153 AVG v(dout0_22) FROM=1949.9n TO=1950.1n

.meas tran Vdout0_23ck153 AVG v(dout0_23) FROM=1949.9n TO=1950.1n

.meas tran Vdout0_24ck153 AVG v(dout0_24) FROM=1949.9n TO=1950.1n

.meas tran Vdout0_25ck153 AVG v(dout0_25) FROM=1949.9n TO=1950.1n

.meas tran Vdout0_26ck153 AVG v(dout0_26) FROM=1949.9n TO=1950.1n

.meas tran Vdout0_27ck153 AVG v(dout0_27) FROM=1949.9n TO=1950.1n

.meas tran Vdout0_28ck153 AVG v(dout0_28) FROM=1949.9n TO=1950.1n

.meas tran Vdout0_29ck153 AVG v(dout0_29) FROM=1949.9n TO=1950.1n

.meas tran Vdout0_30ck153 AVG v(dout0_30) FROM=1949.9n TO=1950.1n

.meas tran Vdout0_31ck153 AVG v(dout0_31) FROM=1949.9n TO=1950.1n

.meas tran Vdout0_32ck153 AVG v(dout0_32) FROM=1949.9n TO=1950.1n

.meas tran Vdout0_33ck153 AVG v(dout0_33) FROM=1949.9n TO=1950.1n

.meas tran Vdout0_34ck153 AVG v(dout0_34) FROM=1949.9n TO=1950.1n

.meas tran Vdout0_35ck153 AVG v(dout0_35) FROM=1949.9n TO=1950.1n

.meas tran Vdout0_36ck153 AVG v(dout0_36) FROM=1949.9n TO=1950.1n

.meas tran Vdout0_37ck153 AVG v(dout0_37) FROM=1949.9n TO=1950.1n

.meas tran Vdout0_38ck153 AVG v(dout0_38) FROM=1949.9n TO=1950.1n

.meas tran Vdout0_39ck153 AVG v(dout0_39) FROM=1949.9n TO=1950.1n

.meas tran Vdout0_40ck153 AVG v(dout0_40) FROM=1949.9n TO=1950.1n

.meas tran Vdout0_41ck153 AVG v(dout0_41) FROM=1949.9n TO=1950.1n

.meas tran Vdout0_42ck153 AVG v(dout0_42) FROM=1949.9n TO=1950.1n

.meas tran Vdout0_43ck153 AVG v(dout0_43) FROM=1949.9n TO=1950.1n

.meas tran Vdout0_44ck153 AVG v(dout0_44) FROM=1949.9n TO=1950.1n

.meas tran Vdout0_45ck153 AVG v(dout0_45) FROM=1949.9n TO=1950.1n

.meas tran Vdout0_46ck153 AVG v(dout0_46) FROM=1949.9n TO=1950.1n

.meas tran Vdout0_47ck153 AVG v(dout0_47) FROM=1949.9n TO=1950.1n

.meas tran Vdout0_48ck153 AVG v(dout0_48) FROM=1949.9n TO=1950.1n

.meas tran Vdout0_49ck153 AVG v(dout0_49) FROM=1949.9n TO=1950.1n

.meas tran Vdout0_50ck153 AVG v(dout0_50) FROM=1949.9n TO=1950.1n

.meas tran Vdout0_51ck153 AVG v(dout0_51) FROM=1949.9n TO=1950.1n

.meas tran Vdout0_52ck153 AVG v(dout0_52) FROM=1949.9n TO=1950.1n

.meas tran Vdout0_53ck153 AVG v(dout0_53) FROM=1949.9n TO=1950.1n

.meas tran Vdout0_54ck153 AVG v(dout0_54) FROM=1949.9n TO=1950.1n

.meas tran Vdout0_55ck153 AVG v(dout0_55) FROM=1949.9n TO=1950.1n

.meas tran Vdout0_56ck153 AVG v(dout0_56) FROM=1949.9n TO=1950.1n

.meas tran Vdout0_57ck153 AVG v(dout0_57) FROM=1949.9n TO=1950.1n

.meas tran Vdout0_58ck153 AVG v(dout0_58) FROM=1949.9n TO=1950.1n

.meas tran Vdout0_59ck153 AVG v(dout0_59) FROM=1949.9n TO=1950.1n

.meas tran Vdout0_60ck153 AVG v(dout0_60) FROM=1949.9n TO=1950.1n

.meas tran Vdout0_61ck153 AVG v(dout0_61) FROM=1949.9n TO=1950.1n

.meas tran Vdout0_62ck153 AVG v(dout0_62) FROM=1949.9n TO=1950.1n

.meas tran Vdout0_63ck153 AVG v(dout0_63) FROM=1949.9n TO=1950.1n

.meas tran Vdout0_64ck153 AVG v(dout0_64) FROM=1949.9n TO=1950.1n

.meas tran Vdout0_65ck153 AVG v(dout0_65) FROM=1949.9n TO=1950.1n

.meas tran Vdout0_66ck153 AVG v(dout0_66) FROM=1949.9n TO=1950.1n

.meas tran Vdout0_67ck153 AVG v(dout0_67) FROM=1949.9n TO=1950.1n

.meas tran Vdout0_68ck153 AVG v(dout0_68) FROM=1949.9n TO=1950.1n

.meas tran Vdout0_69ck153 AVG v(dout0_69) FROM=1949.9n TO=1950.1n

.meas tran Vdout0_70ck153 AVG v(dout0_70) FROM=1949.9n TO=1950.1n

.meas tran Vdout0_71ck153 AVG v(dout0_71) FROM=1949.9n TO=1950.1n

.meas tran Vdout0_72ck153 AVG v(dout0_72) FROM=1949.9n TO=1950.1n

.meas tran Vdout0_73ck153 AVG v(dout0_73) FROM=1949.9n TO=1950.1n

.meas tran Vdout0_74ck153 AVG v(dout0_74) FROM=1949.9n TO=1950.1n

.meas tran Vdout0_75ck153 AVG v(dout0_75) FROM=1949.9n TO=1950.1n

.meas tran Vdout0_76ck153 AVG v(dout0_76) FROM=1949.9n TO=1950.1n

.meas tran Vdout0_77ck153 AVG v(dout0_77) FROM=1949.9n TO=1950.1n

.meas tran Vdout0_78ck153 AVG v(dout0_78) FROM=1949.9n TO=1950.1n

.meas tran Vdout0_79ck153 AVG v(dout0_79) FROM=1949.9n TO=1950.1n

.meas tran Vdout1_0ck154 AVG v(dout1_0) FROM=1959.9n TO=1960.1n

.meas tran Vdout1_1ck154 AVG v(dout1_1) FROM=1959.9n TO=1960.1n

.meas tran Vdout1_2ck154 AVG v(dout1_2) FROM=1959.9n TO=1960.1n

.meas tran Vdout1_3ck154 AVG v(dout1_3) FROM=1959.9n TO=1960.1n

.meas tran Vdout1_4ck154 AVG v(dout1_4) FROM=1959.9n TO=1960.1n

.meas tran Vdout1_5ck154 AVG v(dout1_5) FROM=1959.9n TO=1960.1n

.meas tran Vdout1_6ck154 AVG v(dout1_6) FROM=1959.9n TO=1960.1n

.meas tran Vdout1_7ck154 AVG v(dout1_7) FROM=1959.9n TO=1960.1n

.meas tran Vdout1_8ck154 AVG v(dout1_8) FROM=1959.9n TO=1960.1n

.meas tran Vdout1_9ck154 AVG v(dout1_9) FROM=1959.9n TO=1960.1n

.meas tran Vdout1_10ck154 AVG v(dout1_10) FROM=1959.9n TO=1960.1n

.meas tran Vdout1_11ck154 AVG v(dout1_11) FROM=1959.9n TO=1960.1n

.meas tran Vdout1_12ck154 AVG v(dout1_12) FROM=1959.9n TO=1960.1n

.meas tran Vdout1_13ck154 AVG v(dout1_13) FROM=1959.9n TO=1960.1n

.meas tran Vdout1_14ck154 AVG v(dout1_14) FROM=1959.9n TO=1960.1n

.meas tran Vdout1_15ck154 AVG v(dout1_15) FROM=1959.9n TO=1960.1n

.meas tran Vdout1_16ck154 AVG v(dout1_16) FROM=1959.9n TO=1960.1n

.meas tran Vdout1_17ck154 AVG v(dout1_17) FROM=1959.9n TO=1960.1n

.meas tran Vdout1_18ck154 AVG v(dout1_18) FROM=1959.9n TO=1960.1n

.meas tran Vdout1_19ck154 AVG v(dout1_19) FROM=1959.9n TO=1960.1n

.meas tran Vdout1_20ck154 AVG v(dout1_20) FROM=1959.9n TO=1960.1n

.meas tran Vdout1_21ck154 AVG v(dout1_21) FROM=1959.9n TO=1960.1n

.meas tran Vdout1_22ck154 AVG v(dout1_22) FROM=1959.9n TO=1960.1n

.meas tran Vdout1_23ck154 AVG v(dout1_23) FROM=1959.9n TO=1960.1n

.meas tran Vdout1_24ck154 AVG v(dout1_24) FROM=1959.9n TO=1960.1n

.meas tran Vdout1_25ck154 AVG v(dout1_25) FROM=1959.9n TO=1960.1n

.meas tran Vdout1_26ck154 AVG v(dout1_26) FROM=1959.9n TO=1960.1n

.meas tran Vdout1_27ck154 AVG v(dout1_27) FROM=1959.9n TO=1960.1n

.meas tran Vdout1_28ck154 AVG v(dout1_28) FROM=1959.9n TO=1960.1n

.meas tran Vdout1_29ck154 AVG v(dout1_29) FROM=1959.9n TO=1960.1n

.meas tran Vdout1_30ck154 AVG v(dout1_30) FROM=1959.9n TO=1960.1n

.meas tran Vdout1_31ck154 AVG v(dout1_31) FROM=1959.9n TO=1960.1n

.meas tran Vdout1_32ck154 AVG v(dout1_32) FROM=1959.9n TO=1960.1n

.meas tran Vdout1_33ck154 AVG v(dout1_33) FROM=1959.9n TO=1960.1n

.meas tran Vdout1_34ck154 AVG v(dout1_34) FROM=1959.9n TO=1960.1n

.meas tran Vdout1_35ck154 AVG v(dout1_35) FROM=1959.9n TO=1960.1n

.meas tran Vdout1_36ck154 AVG v(dout1_36) FROM=1959.9n TO=1960.1n

.meas tran Vdout1_37ck154 AVG v(dout1_37) FROM=1959.9n TO=1960.1n

.meas tran Vdout1_38ck154 AVG v(dout1_38) FROM=1959.9n TO=1960.1n

.meas tran Vdout1_39ck154 AVG v(dout1_39) FROM=1959.9n TO=1960.1n

.meas tran Vdout1_40ck154 AVG v(dout1_40) FROM=1959.9n TO=1960.1n

.meas tran Vdout1_41ck154 AVG v(dout1_41) FROM=1959.9n TO=1960.1n

.meas tran Vdout1_42ck154 AVG v(dout1_42) FROM=1959.9n TO=1960.1n

.meas tran Vdout1_43ck154 AVG v(dout1_43) FROM=1959.9n TO=1960.1n

.meas tran Vdout1_44ck154 AVG v(dout1_44) FROM=1959.9n TO=1960.1n

.meas tran Vdout1_45ck154 AVG v(dout1_45) FROM=1959.9n TO=1960.1n

.meas tran Vdout1_46ck154 AVG v(dout1_46) FROM=1959.9n TO=1960.1n

.meas tran Vdout1_47ck154 AVG v(dout1_47) FROM=1959.9n TO=1960.1n

.meas tran Vdout1_48ck154 AVG v(dout1_48) FROM=1959.9n TO=1960.1n

.meas tran Vdout1_49ck154 AVG v(dout1_49) FROM=1959.9n TO=1960.1n

.meas tran Vdout1_50ck154 AVG v(dout1_50) FROM=1959.9n TO=1960.1n

.meas tran Vdout1_51ck154 AVG v(dout1_51) FROM=1959.9n TO=1960.1n

.meas tran Vdout1_52ck154 AVG v(dout1_52) FROM=1959.9n TO=1960.1n

.meas tran Vdout1_53ck154 AVG v(dout1_53) FROM=1959.9n TO=1960.1n

.meas tran Vdout1_54ck154 AVG v(dout1_54) FROM=1959.9n TO=1960.1n

.meas tran Vdout1_55ck154 AVG v(dout1_55) FROM=1959.9n TO=1960.1n

.meas tran Vdout1_56ck154 AVG v(dout1_56) FROM=1959.9n TO=1960.1n

.meas tran Vdout1_57ck154 AVG v(dout1_57) FROM=1959.9n TO=1960.1n

.meas tran Vdout1_58ck154 AVG v(dout1_58) FROM=1959.9n TO=1960.1n

.meas tran Vdout1_59ck154 AVG v(dout1_59) FROM=1959.9n TO=1960.1n

.meas tran Vdout1_60ck154 AVG v(dout1_60) FROM=1959.9n TO=1960.1n

.meas tran Vdout1_61ck154 AVG v(dout1_61) FROM=1959.9n TO=1960.1n

.meas tran Vdout1_62ck154 AVG v(dout1_62) FROM=1959.9n TO=1960.1n

.meas tran Vdout1_63ck154 AVG v(dout1_63) FROM=1959.9n TO=1960.1n

.meas tran Vdout1_64ck154 AVG v(dout1_64) FROM=1959.9n TO=1960.1n

.meas tran Vdout1_65ck154 AVG v(dout1_65) FROM=1959.9n TO=1960.1n

.meas tran Vdout1_66ck154 AVG v(dout1_66) FROM=1959.9n TO=1960.1n

.meas tran Vdout1_67ck154 AVG v(dout1_67) FROM=1959.9n TO=1960.1n

.meas tran Vdout1_68ck154 AVG v(dout1_68) FROM=1959.9n TO=1960.1n

.meas tran Vdout1_69ck154 AVG v(dout1_69) FROM=1959.9n TO=1960.1n

.meas tran Vdout1_70ck154 AVG v(dout1_70) FROM=1959.9n TO=1960.1n

.meas tran Vdout1_71ck154 AVG v(dout1_71) FROM=1959.9n TO=1960.1n

.meas tran Vdout1_72ck154 AVG v(dout1_72) FROM=1959.9n TO=1960.1n

.meas tran Vdout1_73ck154 AVG v(dout1_73) FROM=1959.9n TO=1960.1n

.meas tran Vdout1_74ck154 AVG v(dout1_74) FROM=1959.9n TO=1960.1n

.meas tran Vdout1_75ck154 AVG v(dout1_75) FROM=1959.9n TO=1960.1n

.meas tran Vdout1_76ck154 AVG v(dout1_76) FROM=1959.9n TO=1960.1n

.meas tran Vdout1_77ck154 AVG v(dout1_77) FROM=1959.9n TO=1960.1n

.meas tran Vdout1_78ck154 AVG v(dout1_78) FROM=1959.9n TO=1960.1n

.meas tran Vdout1_79ck154 AVG v(dout1_79) FROM=1959.9n TO=1960.1n

.meas tran Vdout1_0ck155 AVG v(dout1_0) FROM=1969.9n TO=1970.1n

.meas tran Vdout1_1ck155 AVG v(dout1_1) FROM=1969.9n TO=1970.1n

.meas tran Vdout1_2ck155 AVG v(dout1_2) FROM=1969.9n TO=1970.1n

.meas tran Vdout1_3ck155 AVG v(dout1_3) FROM=1969.9n TO=1970.1n

.meas tran Vdout1_4ck155 AVG v(dout1_4) FROM=1969.9n TO=1970.1n

.meas tran Vdout1_5ck155 AVG v(dout1_5) FROM=1969.9n TO=1970.1n

.meas tran Vdout1_6ck155 AVG v(dout1_6) FROM=1969.9n TO=1970.1n

.meas tran Vdout1_7ck155 AVG v(dout1_7) FROM=1969.9n TO=1970.1n

.meas tran Vdout1_8ck155 AVG v(dout1_8) FROM=1969.9n TO=1970.1n

.meas tran Vdout1_9ck155 AVG v(dout1_9) FROM=1969.9n TO=1970.1n

.meas tran Vdout1_10ck155 AVG v(dout1_10) FROM=1969.9n TO=1970.1n

.meas tran Vdout1_11ck155 AVG v(dout1_11) FROM=1969.9n TO=1970.1n

.meas tran Vdout1_12ck155 AVG v(dout1_12) FROM=1969.9n TO=1970.1n

.meas tran Vdout1_13ck155 AVG v(dout1_13) FROM=1969.9n TO=1970.1n

.meas tran Vdout1_14ck155 AVG v(dout1_14) FROM=1969.9n TO=1970.1n

.meas tran Vdout1_15ck155 AVG v(dout1_15) FROM=1969.9n TO=1970.1n

.meas tran Vdout1_16ck155 AVG v(dout1_16) FROM=1969.9n TO=1970.1n

.meas tran Vdout1_17ck155 AVG v(dout1_17) FROM=1969.9n TO=1970.1n

.meas tran Vdout1_18ck155 AVG v(dout1_18) FROM=1969.9n TO=1970.1n

.meas tran Vdout1_19ck155 AVG v(dout1_19) FROM=1969.9n TO=1970.1n

.meas tran Vdout1_20ck155 AVG v(dout1_20) FROM=1969.9n TO=1970.1n

.meas tran Vdout1_21ck155 AVG v(dout1_21) FROM=1969.9n TO=1970.1n

.meas tran Vdout1_22ck155 AVG v(dout1_22) FROM=1969.9n TO=1970.1n

.meas tran Vdout1_23ck155 AVG v(dout1_23) FROM=1969.9n TO=1970.1n

.meas tran Vdout1_24ck155 AVG v(dout1_24) FROM=1969.9n TO=1970.1n

.meas tran Vdout1_25ck155 AVG v(dout1_25) FROM=1969.9n TO=1970.1n

.meas tran Vdout1_26ck155 AVG v(dout1_26) FROM=1969.9n TO=1970.1n

.meas tran Vdout1_27ck155 AVG v(dout1_27) FROM=1969.9n TO=1970.1n

.meas tran Vdout1_28ck155 AVG v(dout1_28) FROM=1969.9n TO=1970.1n

.meas tran Vdout1_29ck155 AVG v(dout1_29) FROM=1969.9n TO=1970.1n

.meas tran Vdout1_30ck155 AVG v(dout1_30) FROM=1969.9n TO=1970.1n

.meas tran Vdout1_31ck155 AVG v(dout1_31) FROM=1969.9n TO=1970.1n

.meas tran Vdout1_32ck155 AVG v(dout1_32) FROM=1969.9n TO=1970.1n

.meas tran Vdout1_33ck155 AVG v(dout1_33) FROM=1969.9n TO=1970.1n

.meas tran Vdout1_34ck155 AVG v(dout1_34) FROM=1969.9n TO=1970.1n

.meas tran Vdout1_35ck155 AVG v(dout1_35) FROM=1969.9n TO=1970.1n

.meas tran Vdout1_36ck155 AVG v(dout1_36) FROM=1969.9n TO=1970.1n

.meas tran Vdout1_37ck155 AVG v(dout1_37) FROM=1969.9n TO=1970.1n

.meas tran Vdout1_38ck155 AVG v(dout1_38) FROM=1969.9n TO=1970.1n

.meas tran Vdout1_39ck155 AVG v(dout1_39) FROM=1969.9n TO=1970.1n

.meas tran Vdout1_40ck155 AVG v(dout1_40) FROM=1969.9n TO=1970.1n

.meas tran Vdout1_41ck155 AVG v(dout1_41) FROM=1969.9n TO=1970.1n

.meas tran Vdout1_42ck155 AVG v(dout1_42) FROM=1969.9n TO=1970.1n

.meas tran Vdout1_43ck155 AVG v(dout1_43) FROM=1969.9n TO=1970.1n

.meas tran Vdout1_44ck155 AVG v(dout1_44) FROM=1969.9n TO=1970.1n

.meas tran Vdout1_45ck155 AVG v(dout1_45) FROM=1969.9n TO=1970.1n

.meas tran Vdout1_46ck155 AVG v(dout1_46) FROM=1969.9n TO=1970.1n

.meas tran Vdout1_47ck155 AVG v(dout1_47) FROM=1969.9n TO=1970.1n

.meas tran Vdout1_48ck155 AVG v(dout1_48) FROM=1969.9n TO=1970.1n

.meas tran Vdout1_49ck155 AVG v(dout1_49) FROM=1969.9n TO=1970.1n

.meas tran Vdout1_50ck155 AVG v(dout1_50) FROM=1969.9n TO=1970.1n

.meas tran Vdout1_51ck155 AVG v(dout1_51) FROM=1969.9n TO=1970.1n

.meas tran Vdout1_52ck155 AVG v(dout1_52) FROM=1969.9n TO=1970.1n

.meas tran Vdout1_53ck155 AVG v(dout1_53) FROM=1969.9n TO=1970.1n

.meas tran Vdout1_54ck155 AVG v(dout1_54) FROM=1969.9n TO=1970.1n

.meas tran Vdout1_55ck155 AVG v(dout1_55) FROM=1969.9n TO=1970.1n

.meas tran Vdout1_56ck155 AVG v(dout1_56) FROM=1969.9n TO=1970.1n

.meas tran Vdout1_57ck155 AVG v(dout1_57) FROM=1969.9n TO=1970.1n

.meas tran Vdout1_58ck155 AVG v(dout1_58) FROM=1969.9n TO=1970.1n

.meas tran Vdout1_59ck155 AVG v(dout1_59) FROM=1969.9n TO=1970.1n

.meas tran Vdout1_60ck155 AVG v(dout1_60) FROM=1969.9n TO=1970.1n

.meas tran Vdout1_61ck155 AVG v(dout1_61) FROM=1969.9n TO=1970.1n

.meas tran Vdout1_62ck155 AVG v(dout1_62) FROM=1969.9n TO=1970.1n

.meas tran Vdout1_63ck155 AVG v(dout1_63) FROM=1969.9n TO=1970.1n

.meas tran Vdout1_64ck155 AVG v(dout1_64) FROM=1969.9n TO=1970.1n

.meas tran Vdout1_65ck155 AVG v(dout1_65) FROM=1969.9n TO=1970.1n

.meas tran Vdout1_66ck155 AVG v(dout1_66) FROM=1969.9n TO=1970.1n

.meas tran Vdout1_67ck155 AVG v(dout1_67) FROM=1969.9n TO=1970.1n

.meas tran Vdout1_68ck155 AVG v(dout1_68) FROM=1969.9n TO=1970.1n

.meas tran Vdout1_69ck155 AVG v(dout1_69) FROM=1969.9n TO=1970.1n

.meas tran Vdout1_70ck155 AVG v(dout1_70) FROM=1969.9n TO=1970.1n

.meas tran Vdout1_71ck155 AVG v(dout1_71) FROM=1969.9n TO=1970.1n

.meas tran Vdout1_72ck155 AVG v(dout1_72) FROM=1969.9n TO=1970.1n

.meas tran Vdout1_73ck155 AVG v(dout1_73) FROM=1969.9n TO=1970.1n

.meas tran Vdout1_74ck155 AVG v(dout1_74) FROM=1969.9n TO=1970.1n

.meas tran Vdout1_75ck155 AVG v(dout1_75) FROM=1969.9n TO=1970.1n

.meas tran Vdout1_76ck155 AVG v(dout1_76) FROM=1969.9n TO=1970.1n

.meas tran Vdout1_77ck155 AVG v(dout1_77) FROM=1969.9n TO=1970.1n

.meas tran Vdout1_78ck155 AVG v(dout1_78) FROM=1969.9n TO=1970.1n

.meas tran Vdout1_79ck155 AVG v(dout1_79) FROM=1969.9n TO=1970.1n

.meas tran Vdout1_0ck156 AVG v(dout1_0) FROM=1999.9n TO=2000.1n

.meas tran Vdout1_1ck156 AVG v(dout1_1) FROM=1999.9n TO=2000.1n

.meas tran Vdout1_2ck156 AVG v(dout1_2) FROM=1999.9n TO=2000.1n

.meas tran Vdout1_3ck156 AVG v(dout1_3) FROM=1999.9n TO=2000.1n

.meas tran Vdout1_4ck156 AVG v(dout1_4) FROM=1999.9n TO=2000.1n

.meas tran Vdout1_5ck156 AVG v(dout1_5) FROM=1999.9n TO=2000.1n

.meas tran Vdout1_6ck156 AVG v(dout1_6) FROM=1999.9n TO=2000.1n

.meas tran Vdout1_7ck156 AVG v(dout1_7) FROM=1999.9n TO=2000.1n

.meas tran Vdout1_8ck156 AVG v(dout1_8) FROM=1999.9n TO=2000.1n

.meas tran Vdout1_9ck156 AVG v(dout1_9) FROM=1999.9n TO=2000.1n

.meas tran Vdout1_10ck156 AVG v(dout1_10) FROM=1999.9n TO=2000.1n

.meas tran Vdout1_11ck156 AVG v(dout1_11) FROM=1999.9n TO=2000.1n

.meas tran Vdout1_12ck156 AVG v(dout1_12) FROM=1999.9n TO=2000.1n

.meas tran Vdout1_13ck156 AVG v(dout1_13) FROM=1999.9n TO=2000.1n

.meas tran Vdout1_14ck156 AVG v(dout1_14) FROM=1999.9n TO=2000.1n

.meas tran Vdout1_15ck156 AVG v(dout1_15) FROM=1999.9n TO=2000.1n

.meas tran Vdout1_16ck156 AVG v(dout1_16) FROM=1999.9n TO=2000.1n

.meas tran Vdout1_17ck156 AVG v(dout1_17) FROM=1999.9n TO=2000.1n

.meas tran Vdout1_18ck156 AVG v(dout1_18) FROM=1999.9n TO=2000.1n

.meas tran Vdout1_19ck156 AVG v(dout1_19) FROM=1999.9n TO=2000.1n

.meas tran Vdout1_20ck156 AVG v(dout1_20) FROM=1999.9n TO=2000.1n

.meas tran Vdout1_21ck156 AVG v(dout1_21) FROM=1999.9n TO=2000.1n

.meas tran Vdout1_22ck156 AVG v(dout1_22) FROM=1999.9n TO=2000.1n

.meas tran Vdout1_23ck156 AVG v(dout1_23) FROM=1999.9n TO=2000.1n

.meas tran Vdout1_24ck156 AVG v(dout1_24) FROM=1999.9n TO=2000.1n

.meas tran Vdout1_25ck156 AVG v(dout1_25) FROM=1999.9n TO=2000.1n

.meas tran Vdout1_26ck156 AVG v(dout1_26) FROM=1999.9n TO=2000.1n

.meas tran Vdout1_27ck156 AVG v(dout1_27) FROM=1999.9n TO=2000.1n

.meas tran Vdout1_28ck156 AVG v(dout1_28) FROM=1999.9n TO=2000.1n

.meas tran Vdout1_29ck156 AVG v(dout1_29) FROM=1999.9n TO=2000.1n

.meas tran Vdout1_30ck156 AVG v(dout1_30) FROM=1999.9n TO=2000.1n

.meas tran Vdout1_31ck156 AVG v(dout1_31) FROM=1999.9n TO=2000.1n

.meas tran Vdout1_32ck156 AVG v(dout1_32) FROM=1999.9n TO=2000.1n

.meas tran Vdout1_33ck156 AVG v(dout1_33) FROM=1999.9n TO=2000.1n

.meas tran Vdout1_34ck156 AVG v(dout1_34) FROM=1999.9n TO=2000.1n

.meas tran Vdout1_35ck156 AVG v(dout1_35) FROM=1999.9n TO=2000.1n

.meas tran Vdout1_36ck156 AVG v(dout1_36) FROM=1999.9n TO=2000.1n

.meas tran Vdout1_37ck156 AVG v(dout1_37) FROM=1999.9n TO=2000.1n

.meas tran Vdout1_38ck156 AVG v(dout1_38) FROM=1999.9n TO=2000.1n

.meas tran Vdout1_39ck156 AVG v(dout1_39) FROM=1999.9n TO=2000.1n

.meas tran Vdout1_40ck156 AVG v(dout1_40) FROM=1999.9n TO=2000.1n

.meas tran Vdout1_41ck156 AVG v(dout1_41) FROM=1999.9n TO=2000.1n

.meas tran Vdout1_42ck156 AVG v(dout1_42) FROM=1999.9n TO=2000.1n

.meas tran Vdout1_43ck156 AVG v(dout1_43) FROM=1999.9n TO=2000.1n

.meas tran Vdout1_44ck156 AVG v(dout1_44) FROM=1999.9n TO=2000.1n

.meas tran Vdout1_45ck156 AVG v(dout1_45) FROM=1999.9n TO=2000.1n

.meas tran Vdout1_46ck156 AVG v(dout1_46) FROM=1999.9n TO=2000.1n

.meas tran Vdout1_47ck156 AVG v(dout1_47) FROM=1999.9n TO=2000.1n

.meas tran Vdout1_48ck156 AVG v(dout1_48) FROM=1999.9n TO=2000.1n

.meas tran Vdout1_49ck156 AVG v(dout1_49) FROM=1999.9n TO=2000.1n

.meas tran Vdout1_50ck156 AVG v(dout1_50) FROM=1999.9n TO=2000.1n

.meas tran Vdout1_51ck156 AVG v(dout1_51) FROM=1999.9n TO=2000.1n

.meas tran Vdout1_52ck156 AVG v(dout1_52) FROM=1999.9n TO=2000.1n

.meas tran Vdout1_53ck156 AVG v(dout1_53) FROM=1999.9n TO=2000.1n

.meas tran Vdout1_54ck156 AVG v(dout1_54) FROM=1999.9n TO=2000.1n

.meas tran Vdout1_55ck156 AVG v(dout1_55) FROM=1999.9n TO=2000.1n

.meas tran Vdout1_56ck156 AVG v(dout1_56) FROM=1999.9n TO=2000.1n

.meas tran Vdout1_57ck156 AVG v(dout1_57) FROM=1999.9n TO=2000.1n

.meas tran Vdout1_58ck156 AVG v(dout1_58) FROM=1999.9n TO=2000.1n

.meas tran Vdout1_59ck156 AVG v(dout1_59) FROM=1999.9n TO=2000.1n

.meas tran Vdout1_60ck156 AVG v(dout1_60) FROM=1999.9n TO=2000.1n

.meas tran Vdout1_61ck156 AVG v(dout1_61) FROM=1999.9n TO=2000.1n

.meas tran Vdout1_62ck156 AVG v(dout1_62) FROM=1999.9n TO=2000.1n

.meas tran Vdout1_63ck156 AVG v(dout1_63) FROM=1999.9n TO=2000.1n

.meas tran Vdout1_64ck156 AVG v(dout1_64) FROM=1999.9n TO=2000.1n

.meas tran Vdout1_65ck156 AVG v(dout1_65) FROM=1999.9n TO=2000.1n

.meas tran Vdout1_66ck156 AVG v(dout1_66) FROM=1999.9n TO=2000.1n

.meas tran Vdout1_67ck156 AVG v(dout1_67) FROM=1999.9n TO=2000.1n

.meas tran Vdout1_68ck156 AVG v(dout1_68) FROM=1999.9n TO=2000.1n

.meas tran Vdout1_69ck156 AVG v(dout1_69) FROM=1999.9n TO=2000.1n

.meas tran Vdout1_70ck156 AVG v(dout1_70) FROM=1999.9n TO=2000.1n

.meas tran Vdout1_71ck156 AVG v(dout1_71) FROM=1999.9n TO=2000.1n

.meas tran Vdout1_72ck156 AVG v(dout1_72) FROM=1999.9n TO=2000.1n

.meas tran Vdout1_73ck156 AVG v(dout1_73) FROM=1999.9n TO=2000.1n

.meas tran Vdout1_74ck156 AVG v(dout1_74) FROM=1999.9n TO=2000.1n

.meas tran Vdout1_75ck156 AVG v(dout1_75) FROM=1999.9n TO=2000.1n

.meas tran Vdout1_76ck156 AVG v(dout1_76) FROM=1999.9n TO=2000.1n

.meas tran Vdout1_77ck156 AVG v(dout1_77) FROM=1999.9n TO=2000.1n

.meas tran Vdout1_78ck156 AVG v(dout1_78) FROM=1999.9n TO=2000.1n

.meas tran Vdout1_79ck156 AVG v(dout1_79) FROM=1999.9n TO=2000.1n

.meas tran Vdout0_0ck157 AVG v(dout0_0) FROM=2009.9n TO=2010.1n

.meas tran Vdout0_1ck157 AVG v(dout0_1) FROM=2009.9n TO=2010.1n

.meas tran Vdout0_2ck157 AVG v(dout0_2) FROM=2009.9n TO=2010.1n

.meas tran Vdout0_3ck157 AVG v(dout0_3) FROM=2009.9n TO=2010.1n

.meas tran Vdout0_4ck157 AVG v(dout0_4) FROM=2009.9n TO=2010.1n

.meas tran Vdout0_5ck157 AVG v(dout0_5) FROM=2009.9n TO=2010.1n

.meas tran Vdout0_6ck157 AVG v(dout0_6) FROM=2009.9n TO=2010.1n

.meas tran Vdout0_7ck157 AVG v(dout0_7) FROM=2009.9n TO=2010.1n

.meas tran Vdout0_8ck157 AVG v(dout0_8) FROM=2009.9n TO=2010.1n

.meas tran Vdout0_9ck157 AVG v(dout0_9) FROM=2009.9n TO=2010.1n

.meas tran Vdout0_10ck157 AVG v(dout0_10) FROM=2009.9n TO=2010.1n

.meas tran Vdout0_11ck157 AVG v(dout0_11) FROM=2009.9n TO=2010.1n

.meas tran Vdout0_12ck157 AVG v(dout0_12) FROM=2009.9n TO=2010.1n

.meas tran Vdout0_13ck157 AVG v(dout0_13) FROM=2009.9n TO=2010.1n

.meas tran Vdout0_14ck157 AVG v(dout0_14) FROM=2009.9n TO=2010.1n

.meas tran Vdout0_15ck157 AVG v(dout0_15) FROM=2009.9n TO=2010.1n

.meas tran Vdout0_16ck157 AVG v(dout0_16) FROM=2009.9n TO=2010.1n

.meas tran Vdout0_17ck157 AVG v(dout0_17) FROM=2009.9n TO=2010.1n

.meas tran Vdout0_18ck157 AVG v(dout0_18) FROM=2009.9n TO=2010.1n

.meas tran Vdout0_19ck157 AVG v(dout0_19) FROM=2009.9n TO=2010.1n

.meas tran Vdout0_20ck157 AVG v(dout0_20) FROM=2009.9n TO=2010.1n

.meas tran Vdout0_21ck157 AVG v(dout0_21) FROM=2009.9n TO=2010.1n

.meas tran Vdout0_22ck157 AVG v(dout0_22) FROM=2009.9n TO=2010.1n

.meas tran Vdout0_23ck157 AVG v(dout0_23) FROM=2009.9n TO=2010.1n

.meas tran Vdout0_24ck157 AVG v(dout0_24) FROM=2009.9n TO=2010.1n

.meas tran Vdout0_25ck157 AVG v(dout0_25) FROM=2009.9n TO=2010.1n

.meas tran Vdout0_26ck157 AVG v(dout0_26) FROM=2009.9n TO=2010.1n

.meas tran Vdout0_27ck157 AVG v(dout0_27) FROM=2009.9n TO=2010.1n

.meas tran Vdout0_28ck157 AVG v(dout0_28) FROM=2009.9n TO=2010.1n

.meas tran Vdout0_29ck157 AVG v(dout0_29) FROM=2009.9n TO=2010.1n

.meas tran Vdout0_30ck157 AVG v(dout0_30) FROM=2009.9n TO=2010.1n

.meas tran Vdout0_31ck157 AVG v(dout0_31) FROM=2009.9n TO=2010.1n

.meas tran Vdout0_32ck157 AVG v(dout0_32) FROM=2009.9n TO=2010.1n

.meas tran Vdout0_33ck157 AVG v(dout0_33) FROM=2009.9n TO=2010.1n

.meas tran Vdout0_34ck157 AVG v(dout0_34) FROM=2009.9n TO=2010.1n

.meas tran Vdout0_35ck157 AVG v(dout0_35) FROM=2009.9n TO=2010.1n

.meas tran Vdout0_36ck157 AVG v(dout0_36) FROM=2009.9n TO=2010.1n

.meas tran Vdout0_37ck157 AVG v(dout0_37) FROM=2009.9n TO=2010.1n

.meas tran Vdout0_38ck157 AVG v(dout0_38) FROM=2009.9n TO=2010.1n

.meas tran Vdout0_39ck157 AVG v(dout0_39) FROM=2009.9n TO=2010.1n

.meas tran Vdout0_40ck157 AVG v(dout0_40) FROM=2009.9n TO=2010.1n

.meas tran Vdout0_41ck157 AVG v(dout0_41) FROM=2009.9n TO=2010.1n

.meas tran Vdout0_42ck157 AVG v(dout0_42) FROM=2009.9n TO=2010.1n

.meas tran Vdout0_43ck157 AVG v(dout0_43) FROM=2009.9n TO=2010.1n

.meas tran Vdout0_44ck157 AVG v(dout0_44) FROM=2009.9n TO=2010.1n

.meas tran Vdout0_45ck157 AVG v(dout0_45) FROM=2009.9n TO=2010.1n

.meas tran Vdout0_46ck157 AVG v(dout0_46) FROM=2009.9n TO=2010.1n

.meas tran Vdout0_47ck157 AVG v(dout0_47) FROM=2009.9n TO=2010.1n

.meas tran Vdout0_48ck157 AVG v(dout0_48) FROM=2009.9n TO=2010.1n

.meas tran Vdout0_49ck157 AVG v(dout0_49) FROM=2009.9n TO=2010.1n

.meas tran Vdout0_50ck157 AVG v(dout0_50) FROM=2009.9n TO=2010.1n

.meas tran Vdout0_51ck157 AVG v(dout0_51) FROM=2009.9n TO=2010.1n

.meas tran Vdout0_52ck157 AVG v(dout0_52) FROM=2009.9n TO=2010.1n

.meas tran Vdout0_53ck157 AVG v(dout0_53) FROM=2009.9n TO=2010.1n

.meas tran Vdout0_54ck157 AVG v(dout0_54) FROM=2009.9n TO=2010.1n

.meas tran Vdout0_55ck157 AVG v(dout0_55) FROM=2009.9n TO=2010.1n

.meas tran Vdout0_56ck157 AVG v(dout0_56) FROM=2009.9n TO=2010.1n

.meas tran Vdout0_57ck157 AVG v(dout0_57) FROM=2009.9n TO=2010.1n

.meas tran Vdout0_58ck157 AVG v(dout0_58) FROM=2009.9n TO=2010.1n

.meas tran Vdout0_59ck157 AVG v(dout0_59) FROM=2009.9n TO=2010.1n

.meas tran Vdout0_60ck157 AVG v(dout0_60) FROM=2009.9n TO=2010.1n

.meas tran Vdout0_61ck157 AVG v(dout0_61) FROM=2009.9n TO=2010.1n

.meas tran Vdout0_62ck157 AVG v(dout0_62) FROM=2009.9n TO=2010.1n

.meas tran Vdout0_63ck157 AVG v(dout0_63) FROM=2009.9n TO=2010.1n

.meas tran Vdout0_64ck157 AVG v(dout0_64) FROM=2009.9n TO=2010.1n

.meas tran Vdout0_65ck157 AVG v(dout0_65) FROM=2009.9n TO=2010.1n

.meas tran Vdout0_66ck157 AVG v(dout0_66) FROM=2009.9n TO=2010.1n

.meas tran Vdout0_67ck157 AVG v(dout0_67) FROM=2009.9n TO=2010.1n

.meas tran Vdout0_68ck157 AVG v(dout0_68) FROM=2009.9n TO=2010.1n

.meas tran Vdout0_69ck157 AVG v(dout0_69) FROM=2009.9n TO=2010.1n

.meas tran Vdout0_70ck157 AVG v(dout0_70) FROM=2009.9n TO=2010.1n

.meas tran Vdout0_71ck157 AVG v(dout0_71) FROM=2009.9n TO=2010.1n

.meas tran Vdout0_72ck157 AVG v(dout0_72) FROM=2009.9n TO=2010.1n

.meas tran Vdout0_73ck157 AVG v(dout0_73) FROM=2009.9n TO=2010.1n

.meas tran Vdout0_74ck157 AVG v(dout0_74) FROM=2009.9n TO=2010.1n

.meas tran Vdout0_75ck157 AVG v(dout0_75) FROM=2009.9n TO=2010.1n

.meas tran Vdout0_76ck157 AVG v(dout0_76) FROM=2009.9n TO=2010.1n

.meas tran Vdout0_77ck157 AVG v(dout0_77) FROM=2009.9n TO=2010.1n

.meas tran Vdout0_78ck157 AVG v(dout0_78) FROM=2009.9n TO=2010.1n

.meas tran Vdout0_79ck157 AVG v(dout0_79) FROM=2009.9n TO=2010.1n

.meas tran Vdout1_0ck158 AVG v(dout1_0) FROM=2009.9n TO=2010.1n

.meas tran Vdout1_1ck158 AVG v(dout1_1) FROM=2009.9n TO=2010.1n

.meas tran Vdout1_2ck158 AVG v(dout1_2) FROM=2009.9n TO=2010.1n

.meas tran Vdout1_3ck158 AVG v(dout1_3) FROM=2009.9n TO=2010.1n

.meas tran Vdout1_4ck158 AVG v(dout1_4) FROM=2009.9n TO=2010.1n

.meas tran Vdout1_5ck158 AVG v(dout1_5) FROM=2009.9n TO=2010.1n

.meas tran Vdout1_6ck158 AVG v(dout1_6) FROM=2009.9n TO=2010.1n

.meas tran Vdout1_7ck158 AVG v(dout1_7) FROM=2009.9n TO=2010.1n

.meas tran Vdout1_8ck158 AVG v(dout1_8) FROM=2009.9n TO=2010.1n

.meas tran Vdout1_9ck158 AVG v(dout1_9) FROM=2009.9n TO=2010.1n

.meas tran Vdout1_10ck158 AVG v(dout1_10) FROM=2009.9n TO=2010.1n

.meas tran Vdout1_11ck158 AVG v(dout1_11) FROM=2009.9n TO=2010.1n

.meas tran Vdout1_12ck158 AVG v(dout1_12) FROM=2009.9n TO=2010.1n

.meas tran Vdout1_13ck158 AVG v(dout1_13) FROM=2009.9n TO=2010.1n

.meas tran Vdout1_14ck158 AVG v(dout1_14) FROM=2009.9n TO=2010.1n

.meas tran Vdout1_15ck158 AVG v(dout1_15) FROM=2009.9n TO=2010.1n

.meas tran Vdout1_16ck158 AVG v(dout1_16) FROM=2009.9n TO=2010.1n

.meas tran Vdout1_17ck158 AVG v(dout1_17) FROM=2009.9n TO=2010.1n

.meas tran Vdout1_18ck158 AVG v(dout1_18) FROM=2009.9n TO=2010.1n

.meas tran Vdout1_19ck158 AVG v(dout1_19) FROM=2009.9n TO=2010.1n

.meas tran Vdout1_20ck158 AVG v(dout1_20) FROM=2009.9n TO=2010.1n

.meas tran Vdout1_21ck158 AVG v(dout1_21) FROM=2009.9n TO=2010.1n

.meas tran Vdout1_22ck158 AVG v(dout1_22) FROM=2009.9n TO=2010.1n

.meas tran Vdout1_23ck158 AVG v(dout1_23) FROM=2009.9n TO=2010.1n

.meas tran Vdout1_24ck158 AVG v(dout1_24) FROM=2009.9n TO=2010.1n

.meas tran Vdout1_25ck158 AVG v(dout1_25) FROM=2009.9n TO=2010.1n

.meas tran Vdout1_26ck158 AVG v(dout1_26) FROM=2009.9n TO=2010.1n

.meas tran Vdout1_27ck158 AVG v(dout1_27) FROM=2009.9n TO=2010.1n

.meas tran Vdout1_28ck158 AVG v(dout1_28) FROM=2009.9n TO=2010.1n

.meas tran Vdout1_29ck158 AVG v(dout1_29) FROM=2009.9n TO=2010.1n

.meas tran Vdout1_30ck158 AVG v(dout1_30) FROM=2009.9n TO=2010.1n

.meas tran Vdout1_31ck158 AVG v(dout1_31) FROM=2009.9n TO=2010.1n

.meas tran Vdout1_32ck158 AVG v(dout1_32) FROM=2009.9n TO=2010.1n

.meas tran Vdout1_33ck158 AVG v(dout1_33) FROM=2009.9n TO=2010.1n

.meas tran Vdout1_34ck158 AVG v(dout1_34) FROM=2009.9n TO=2010.1n

.meas tran Vdout1_35ck158 AVG v(dout1_35) FROM=2009.9n TO=2010.1n

.meas tran Vdout1_36ck158 AVG v(dout1_36) FROM=2009.9n TO=2010.1n

.meas tran Vdout1_37ck158 AVG v(dout1_37) FROM=2009.9n TO=2010.1n

.meas tran Vdout1_38ck158 AVG v(dout1_38) FROM=2009.9n TO=2010.1n

.meas tran Vdout1_39ck158 AVG v(dout1_39) FROM=2009.9n TO=2010.1n

.meas tran Vdout1_40ck158 AVG v(dout1_40) FROM=2009.9n TO=2010.1n

.meas tran Vdout1_41ck158 AVG v(dout1_41) FROM=2009.9n TO=2010.1n

.meas tran Vdout1_42ck158 AVG v(dout1_42) FROM=2009.9n TO=2010.1n

.meas tran Vdout1_43ck158 AVG v(dout1_43) FROM=2009.9n TO=2010.1n

.meas tran Vdout1_44ck158 AVG v(dout1_44) FROM=2009.9n TO=2010.1n

.meas tran Vdout1_45ck158 AVG v(dout1_45) FROM=2009.9n TO=2010.1n

.meas tran Vdout1_46ck158 AVG v(dout1_46) FROM=2009.9n TO=2010.1n

.meas tran Vdout1_47ck158 AVG v(dout1_47) FROM=2009.9n TO=2010.1n

.meas tran Vdout1_48ck158 AVG v(dout1_48) FROM=2009.9n TO=2010.1n

.meas tran Vdout1_49ck158 AVG v(dout1_49) FROM=2009.9n TO=2010.1n

.meas tran Vdout1_50ck158 AVG v(dout1_50) FROM=2009.9n TO=2010.1n

.meas tran Vdout1_51ck158 AVG v(dout1_51) FROM=2009.9n TO=2010.1n

.meas tran Vdout1_52ck158 AVG v(dout1_52) FROM=2009.9n TO=2010.1n

.meas tran Vdout1_53ck158 AVG v(dout1_53) FROM=2009.9n TO=2010.1n

.meas tran Vdout1_54ck158 AVG v(dout1_54) FROM=2009.9n TO=2010.1n

.meas tran Vdout1_55ck158 AVG v(dout1_55) FROM=2009.9n TO=2010.1n

.meas tran Vdout1_56ck158 AVG v(dout1_56) FROM=2009.9n TO=2010.1n

.meas tran Vdout1_57ck158 AVG v(dout1_57) FROM=2009.9n TO=2010.1n

.meas tran Vdout1_58ck158 AVG v(dout1_58) FROM=2009.9n TO=2010.1n

.meas tran Vdout1_59ck158 AVG v(dout1_59) FROM=2009.9n TO=2010.1n

.meas tran Vdout1_60ck158 AVG v(dout1_60) FROM=2009.9n TO=2010.1n

.meas tran Vdout1_61ck158 AVG v(dout1_61) FROM=2009.9n TO=2010.1n

.meas tran Vdout1_62ck158 AVG v(dout1_62) FROM=2009.9n TO=2010.1n

.meas tran Vdout1_63ck158 AVG v(dout1_63) FROM=2009.9n TO=2010.1n

.meas tran Vdout1_64ck158 AVG v(dout1_64) FROM=2009.9n TO=2010.1n

.meas tran Vdout1_65ck158 AVG v(dout1_65) FROM=2009.9n TO=2010.1n

.meas tran Vdout1_66ck158 AVG v(dout1_66) FROM=2009.9n TO=2010.1n

.meas tran Vdout1_67ck158 AVG v(dout1_67) FROM=2009.9n TO=2010.1n

.meas tran Vdout1_68ck158 AVG v(dout1_68) FROM=2009.9n TO=2010.1n

.meas tran Vdout1_69ck158 AVG v(dout1_69) FROM=2009.9n TO=2010.1n

.meas tran Vdout1_70ck158 AVG v(dout1_70) FROM=2009.9n TO=2010.1n

.meas tran Vdout1_71ck158 AVG v(dout1_71) FROM=2009.9n TO=2010.1n

.meas tran Vdout1_72ck158 AVG v(dout1_72) FROM=2009.9n TO=2010.1n

.meas tran Vdout1_73ck158 AVG v(dout1_73) FROM=2009.9n TO=2010.1n

.meas tran Vdout1_74ck158 AVG v(dout1_74) FROM=2009.9n TO=2010.1n

.meas tran Vdout1_75ck158 AVG v(dout1_75) FROM=2009.9n TO=2010.1n

.meas tran Vdout1_76ck158 AVG v(dout1_76) FROM=2009.9n TO=2010.1n

.meas tran Vdout1_77ck158 AVG v(dout1_77) FROM=2009.9n TO=2010.1n

.meas tran Vdout1_78ck158 AVG v(dout1_78) FROM=2009.9n TO=2010.1n

.meas tran Vdout1_79ck158 AVG v(dout1_79) FROM=2009.9n TO=2010.1n

.TRAN 10p 2040n UIC
.TEMP 25
.OPTIONS POST=1 RUNLVL=4 PROBE
* probe is used for hspice/xa, while plot is used in ngspice
.plot V(*)
.end
